# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VDDP_ALWP: length 18.4
  TOP w0.254: PCH14.1 169.82,45.13 PRH10.1 169.78,44.43 v1(169.76,44.41)
  IN2 w0.254: v1(169.76,44.41) 168,44.41 167.71,44.12 167.71,43.23 166.7,42.21 162.48,42.21 161.74,41.47 156.18,41.47 155.93,41.72 v1(155.93,42.86)
  vias: v1(155.93,47.3) v1(155.93,46.67) v1(155.93,46.03) v1(155.93,45.4) v1(155.93,44.76) v1(155.93,44.13) v1(155.93,43.49) v4(157.58,41.14)
+VDDR3: length 21.6
  BOTTOM w0.254: 115.77,134.49 115.5,134.22 112.97,134.22 112.65,133.9 112.11,133.9 112.07,133.94 ; 115.77,134.49 116.14,134.49 ; 115.77,134.49 115.77,134.7 115.5,134.98 112.52,134.98 112.24,135.26 111.46,135.26
  BOTTOM w0.381: 116.14,134.49 116.61,134.49 116.62,134.51 v1(118.25,134.51) 118.27,134.52 119.07,134.52 UV1.AB18 UV1.AA18 UV1.AA17 119.95,133.41 v1(119.85,133.41) 119.46,133.8 UV1.AB17
  BOTTOM w0.508: 112.07,133.94 111.84,133.94 111.46,134.32 111.46,135.26 v3(110.86,135.86) 110.56,136.16 CV123.1 108.77,136.16 CV66.1 108.68,135.19 LV4.2
GND: length 3224.1
  TOP w0.102: v1(28.86,131.95) v4(28.16,131.95) ; v4(166.79,86.61) v1(166.09,86.61) ; v1(197.58,59.92) 197.58,59.37 v4(197.52,59.3) ; v1(205.28,38.03) 205.27,38.05 v4(205.27,38.83) ; v1(195.03,47.18) 195.04,47.2 v4(195.04,47.87)
  TOP w0.127: v4(18.82,103.93) 18.82,103.3 v1(18.77,103.26) ; v4(188.49,47.39) 188.49,46.68 v1(188.48,46.67) ; v1(38.43,9.08) v4(39.29,9.08)
  TOP w0.203: UE1.35 v1(50.12,70.21) ; UE1.113 34.76,75.41 v1(34.38,75.79) ; v1(9.39,122.93) 9.7,122.62 DT4.2 ; U4.11 43.01,97.47 ; UE1.24 46.55,66.72 46.94,66.33 v1(46.95,66.33) ; U6.11 39.61,50.48 39.71,50.38 v1(39.81,50.38) ; UE1.94 38.15,82.43 v1(38.34,82.24) ; v1(40.55,69.24) 40.59,69.27 40.97,69.27 41.35,68.89 UE1.11 ; DT5.2 9.91,120.3 v1(9.83,120.39) ; PUM01.1 37.65,30.44 37.88,30.67 v1(38.13,30.67) ; PUM01.3 v1(36.85,31.31)
  TOP w0.229: v1(9.39,124.13) DT3.2 ; DT8.2 v1(12.15,124.55) ; DT9.2 11.21,118.62 10.94,118.89 v1(10.94,118.89) ; DT7.2 v1(12.15,126.96)
  TOP w0.254: CV115.2 127.37,136.07 CV42.2 ; UV14.K13 v1(153.91,120.51) ; US1.3 v1(181.78,33.65) ; v1(156.28,146.35) 156.28,146.36 UV12.K14 ; v1(158.32,118.78) 158.31,118.79 UV14.E14 ; UV12.B5 149.51,139.53 v1(149.91,139.93) ; v1(157.91,139.13) 157.51,139.53 UV12.M5 ; v1(150.16,147.24) 150.31,147.09 UV12.C14 UV12.C13 ; UV12.F5 152.71,139.53 v1(153.11,139.93) 153.51,139.53 UV12.G5 ; UV14.G5 v1(157.11,126.11) UV14.F5 ; UV12.A1 148.71,136.28 v1(149.05,135.93) ; v1(148.34,147.1) UV12.A14 ; UV12.C12 150.31,145.04 v1(150.67,144.67) 150.73,144.73 151.52,144.73 151.91,145.11 UV12.E12 ; UV14.B5 160.47,126.27 v1(160.47,126.07) ; UV12.K2 156.31,136.72 v1(156.31,136.72) 155.91,136.32 UV12.K1 ; UV14.U1 v1(148.24,130.17) ; UV14.E12 v1(157.91,120.51) ; CV28.2 115.25,136.16 RV12.2 114.78,137.05 115.01,137.27 v1(115.01,138.22) ; UV12.A3 148.71,137.93 v1(149.11,138.33) 149.91,138.33 UV12.C4 ; v1(158.33,135.76) 158.31,135.78 UV12.N1 ; UV12.N12 158.31,145.13 v1(157.91,145.53) ; UV14.C3 v1(159.51,128.51) ; UV12.H2 UV12.H1 154.31,135.76 v1(154.31,135.76) ; v1(160.18,130.32) 159.91,130.05 UV14.C1 ; v1(162.08,120.61) 161.81,120.61 161.51,120.91 UV14.A12 ; v1(112.74,135.53) 112.93,135.53 113.63,134.83 RV13.2 CV11.2 ; UV12.R14 159.91,146.73 v1(160.31,146.33) ; v1(149.11,144.73) 148.71,145.13 UV12.A12 ; v1(151.82,147.24) 151.91,147.16 UV12.E14 ; UV12.T10 160.71,143.53 v1(160.31,143.93) ; v1(161.17,130.1) 161.51,129.76 UV14.A1 ; UV12.U14 161.51,146.73 v1(161.11,147.13) ; v1(11.97,116.9) 11.85,117.02 DT10.2 ; UV14.R14 v1(149.91,119.71) ; v1(19.45,84.28) 19.01,84.72 19.01,86.19 18.54,86.66 v1(18.14,86.66) 17.44,86.66 16.86,87.24 v1(15.91,87.24) 15.31,86.65 14.03,86.65 v1(13.69,86.3) v1(13.69,84.25) 13.69,81.91 14.07,81.53 v1(14.26,81.53) 15.15,81.53 15.69,82.07 v1(16.4,82.07) v1(18.25,82.07) ; UV14.E1 157.9,130.12 v1(157.9,130.22) ; v1(160.06,118.79) 159.91,118.94 UV14.C14 ; v1(132.23,55.36) 131.5,56.08 CC82.2 ; UV14.K2 UV14.K1 154.31,130.2 v1(154.34,130.23) ; v1(150.71,137.52) 150.31,137.93 UV12.C3 ; UV12.R4 159.91,138.73 v1(160.31,138.33) 159.91,137.93 UV12.R3 ; UV12.U3 161.51,137.93 v1(161.11,138.33) ; UV14.T10 v1(149.91,122.11) ; UV14.G10 v1(157.11,122.91) UV14.F10 ; UV12.C11 150.31,144.32 v1(149.91,143.93) 149.51,143.53 UV12.B10 ; UV14.T5 v1(149.91,126.11) ; UV12.F10 152.71,143.53 v1(153.11,143.13) 153.51,143.52 UV12.G10 ; UV14.B10 v1(160.31,122.11) UV14.C11 ; UV14.C12 v1(160.31,120.51) UV14.C13 ; UV14.H2 155.97,128.97 155.97,129.65 UV14.H1 155.91,130.2 v1(156.06,130.36) ; UV14.U3 v1(149.11,127.71) ; UV14.L10 v1(153.11,122.91) UV14.M10 ; RPC1.1 133.27,90.81 v1(133.46,91) 133.46,91.06 133.21,91.31 RPC1.2 ; v1(150.2,130.27) 150.31,130.17 UV14.R1 ; UV12.D10 151.14,143.53 v1(151.49,143.18) ; v1(157.91,138.33) 157.91,138.32 UV12.N3 ; UV12.R1 159.91,135.87 v1(160.02,135.76) ; v1(161.88,118.94) 161.51,119.31 UV14.A14 ; v1(155.51,119.71) UV14.H13 ; UV14.A3 v1(161.11,127.71) 160.31,127.71 UV14.C4 ; v1(158.73,122.85) 159.08,122.51 UV14.D10 ; UV12.R12 159.91,145.13 v1(160.31,144.73) 159.91,144.33 UV12.R11 ; v1(131.23,60.77) 131.36,60.64 RC60.1 ; UV14.R4 v1(149.91,127.71) UV14.R3 ; UV12.U12 161.51,145.13 v1(161.91,144.73) ; v1(152.31,137.52) 151.91,137.93 UV12.E3 ; UV14.U12 148.62,120.91 v1(148.26,120.54) ; UV12.H13 154.31,145.93 v1(154.71,146.33) 154.31,146.73 UV12.H14 ; v1(161.91,135.92) 161.51,136.32 UV12.U1 ; v1(151.72,135.76) 151.91,135.94 UV12.E1 ; v1(150.04,135.71) 150.31,135.98 UV12.C1 ; UV14.R12 v1(149.91,121.31) UV14.R11 ; UV12.L10 156.71,143.53 v1(157.11,143.13) 157.51,143.52 UV12.M10 ; v1(160.31,139.93) 160.71,139.53 UV12.T5 ; v1(153.97,118.85) 154.31,119.19 UV14.K14 ; UV14.E3 v1(157.91,128.51) ; v1(149.11,118.91) UV14.U14 ; v1(157.91,147.13) 158.31,146.73 UV12.N14 ; UV12.K13 155.91,145.93 v1(156.31,145.53) ; UV14.N12 v1(152.31,120.51) ; v1(156.71,140.09) 156.71,140.09 UV12.L5 ; DT6.2 v1(10.4,118.42) ; v1(151.91,130.29) 151.91,130.26 151.91,130.25 UV14.N1 ; UV14.N14 v1(152.31,118.91) ; UV14.N3 v1(152.31,127.71) ; v1(158.71,143.93) 159.11,143.53 UV12.P10 ; UV14.M5 v1(153.11,126.11) UV14.L5 ; UV14.H14 v1(155.91,118.74) ; UV14.P10 v1(151.51,122.11)
  TOP w0.279: JUSBC1.A12 8.33,118.32 v1(8.38,118.37) ; v1(8.23,123.82) 7.35,123.82 JUSBC1.A1 ; v1(218.77,35.06) 218.77,34.87 218.15,34.25 JCRT.10
  TOP w0.305: v1(219.49,37.1) 219.35,37.25 JCRT.4 ; v1(219.55,38.79) 219.51,38.75 JCRT.1 ; US4.6 206.36,32.19 v1(206.53,32.01) 206.21,31.69 US4.5 ; v1(43.08,59.82) 42.92,59.98 42.92,59.99 42.88,60.02 UC3.3 ; RP5.2 215.2,32.99 214.58,33.6 v1(214.58,33.66) ; US4.8 205.45,33.09 v1(205.74,33.38) 205.95,33.17 US4.7 ; CV35.2 113.89,132.06 114.31,132.48 114.74,132.48 115.36,131.86 CV26.2 ; JCRT.7 218.46,35.75 218.77,35.45 v1(218.77,35.06)
  TOP w0.381: v1(132.19,89.47) 132.62,89.47 132.67,89.42 UC2.3 ; v1(64.67,122.56) PQS10.4 ; PQS30.4 43.63,124.76 v1(44.03,124.37) ; UC5.3 130.51,93.77 130.07,93.33 v1(130.04,93.33) ; v1(116.88,131) 116.88,131.62 CV21.2 117.57,131.65 CV20.2 ; CV119.2 126.8,129.06 CV175.2 ; CV103.2 121.05,125.57 121.26,125.57 v1(121.39,125.44) ; v1(50.1,87.31) 49.67,87.31 UV8.3 ; v1(125.74,130.53) 125.74,130.45 126.24,129.94 CV48.2 CV177.2 127.7,129.6 CV175.2 ; CV127.2 121.34,137.84 v1(120.85,137.36) 120.42,137.79 CV62.2 119.36,137.79 CV63.2 ; v1(135.13,143.39) 137.27,145.52 CV95.2 RV35.2 ; RV2.1 124.91,128.09 v1(124.91,127.63) 124.7,127.63 124.32,127.25 CV102.2 124.32,127.09 124.4,127.01 124.4,126.53 CV101.2 ; CV53.2 130.11,127.94 129.37,128.69 v1(129.31,128.69) 129.3,128.69 CV174.2 127.7,128.92 CV175.2 ; U58.1 218.92,51.81 v1(218.6,51.49) ; RV9.2 CV29.2 117.67,134.26 118.25,133.67 v1(118.25,133.51) ; 36.51,130.11 v1(37.87,130.11) ; PCV34.2 75.52,125.3 76.31,124.51 PCV27.2 76.49,124.57 76.53,124.57 76.72,124.76 v1(76.93,124.76) ; PUS02.3 60.09,127.09 60.47,127.47 60.47,128.01 PQS05.4 ; PRS06.2 PCS02.2 47.73,113.96 PUS01.4 49.64,113.96 v1(50.31,113.29) ; v1(96.93,149.03) PU2.3
  TOP w0.406: v1(18.18,58.61) EU3.3 ; v1(19.72,31.43) EU5.3 ; PUB02.3 165.2,33.02 165.61,32.62 v1(165.61,32.48)
  TOP w0.432: PQS03.4 58.27,132.77 v1(58.44,132.6) ; PQ12.4 169.96,30.81 v1(169.96,31.24) ; PR44.1 172.97,29.25 PQ12.1 ; QS1.1 205.53,34.02 v1(204.93,33.42) ; v1(63.37,122.39) PQS10.1 ; v1(174.53,34.84) 174.53,35.35 174.58,35.4 PQ13.4 ; 172.69,33.71 173,33.71 PQ13.1 173.28,34.59 173.16,34.7 173.16,34.71 v1(173.15,34.71) ; v1(204.91,35.71) 204.51,35.32 QS1.4 ; U5.2 211.8,34.03 211.11,33.33 v1(211.11,33.32)
  TOP w0.457: v1(214.38,49.06) 214.38,48.76 214.28,48.66 C5.2 213.84,47.81 v1(213.48,47.81) 213.23,47.81 213.04,48 RP3.2 RP2.2 ; PCV32.2 67.81,124.83 v1(67.56,125.09) ; CA46.2 33.6,10.4 v1(33.61,10.41) ; CC251.2 224.82,57.7 v1(224.82,57.75)
  TOP w0.508: v1(116.88,73.76) 116.87,73.75 CC36.2 ; Q4.3 110.6,28.1 111.15,27.55 v1(111.15,26.93) ; UC8.2 152.81,29.47 v1(152.45,29.83) ; v1(227.08,61.53) RH23.1 RH22.1 ; PR45.2 172.43,33.45 172.69,33.71 ; C43.1 C44.1 37.9,46.95 v1(37.9,46.55) ; C21.2 C20.2 v1(128.65,30.16) ; v1(32.11,80.77) CE16.2 ; C40.2 42.68,54.48 v1(43.19,53.97) ; RA45.1 v1(28.55,22.73) ; v1(32.91,24.58) 32.95,24.55 PCM14.2 ; PQ16.3 88.33,147.83 88.22,147.71 v1(87.79,147.71) ; RC646.2 RC42.1 ; RC646.2 130.21,45.17 130.22,45.16 130.22,45.02 v1(130.35,44.89) ; RC646.2 RC711.1 ; v1(127.61,42.59) 127.61,42.6 127.54,42.67 RC681.2 CC615.1 ; 212.42,57.46 212.42,57.38 212.01,56.97 v1(211.31,56.97) ; v1(21.5,6.1) CA30.2 CA27.1 ; v1(73.88,110.28) 73.69,110.09 PC2503.2 ; CV243.2 v1(161.28,150.6) ; RS17.2 177.09,31 PR43.2 ; EU4012.1 v1(218.03,25.67) ; CT13.2 41.7,113.25 41.08,113.88 v1(41.03,113.88) ; v1(90.74,147.42) 91.7,147.42 PC21.2 ; v1(67.19,127.36) 67.45,127.62 PRV16.2 PCV20.2 ; v1(67.19,127.36) 67.06,127.48 PCV37.2 ; v1(67.19,127.36) 67.15,127.32 PRV18.2 ; v1(119.72,124.63) 119.72,124.2 CV76.2 ; Q26.4 v1(41.15,92.05) ; v1(191.65,62.58) 191.82,62.42 CS26.2 ; CV91.2 134.95,121 134.95,121.72 134.44,122.23 v1(134.15,122.23) 133.98,122.05 CV92.2 ; D2.1 13.81,131.69 13.31,132.2 v1(13.05,132.2) ; RV118.2 v1(165.76,123.62) ; v1(56.22,116.21) 56.08,116.07 PR6.2 ; CA55.2 26.06,6.97 v1(26.07,6.98) ; v1(169.96,31.24) 169.53,31.67 PR40.2 ; v1(14.74,43.1) 14.74,42.49 14.88,42.35 CU14.2 ; CV210.2 v1(160.3,150.6) ; RT62.2 32.44,132.18 v1(32.27,132) CT62.1 ; CV248.2 v1(163.18,150.6) ; v1(67.85,109.98) 67.41,110.42 PU2501.8 ; v1(30.58,29.54) 31.1,30.06 PCM16.2 ; v1(30.95,69.71) CE5.2 CE17.2 ; v1(182.88,61.65) 182.3,62.23 C53.2 181.91,62.47 C54.2 ; PRH17.2 169.59,52.78 v1(169.05,53.32) ; v1(27.45,120.57) 27.71,120.31 RT134.2 ; CU2.2 20.63,54.94 20.3,55.27 CU4.2 21.47,55.88 v1(21.85,56.26) ; PQS12.3 52.41,129.87 51.9,129.36 v1(51.9,129.17) ; v1(27.1,88.95) 27.56,89.4 RL2.1 ; CV227.2 v1(165.76,129.02) ; CV101.2 CV105.2 ; PCB20.2 PCB19.2 198.81,48.79 v1(198.79,48.76) ; CC92.2 v1(151.55,30.92) ; v1(23,43.65) 23,43.33 PC309.2 22.59,43.04 PC308.2 ; v1(203.45,44.77) 203.91,44.77 204.39,44.29 PCB29.2 ; v1(26.81,120.83) 26.6,120.63 CT17.2 ; PCB43.2 205.23,41 PCB38.2 PCB35.2 203.59,40.29 v1(203.59,39.72) ; CA52.2 28.81,6.03 29.32,5.52 v1(30.7,5.52) ; PRV10.2 72.06,134.63 72.81,135.38 CW15.2 v1(73.62,135.56) ; CV198.2 v1(157.43,150.59) ; v1(164.88,137.92) 164.9,137.92 CV341.2 ; CV81.2 127.34,124.45 v1(127.34,124.48) ; v1(205.27,52.16) 205.23,52.16 204.63,51.56 PRB10.2 204.07,51.55 203.51,52.11 PCB27.2 ; CV64.2 118.64,135.28 v1(118.64,135.8) 119.44,135.8 119.59,135.64 119.89,135.64 CV65.2 ; UW1.2 70.7,138.74 v1(69.88,137.93) ; PRF03.2 88.08,116.93 v1(88.17,116.84) ; PCS03.2 50.01,118.5 v1(50.01,118.87) ; CA21.1 v1(38.39,13.52) ; PCZ112.2 130.02,72.13 v1(129.7,71.81) ; CC63.2 123.22,80.89 v1(123.63,81.3) ; CV225.2 165.13,119.9 CV390.2 v1(165.78,120.95) ; v1(112.81,132.01) 113.04,131.77 CV35.2 ; CE2.2 45.08,64.47 45.08,63.98 v1(45.56,63.5) ; v1(127.07,117.94) 127.07,117.97 127.64,118.55 128.1,118.55 128.61,119.06 RV41.1 ; v1(32.01,116.3) 31.58,116.73 QT4.3 ; PC1806.2 v1(180.96,54.44) ; v1(16.18,116.7) 16.81,116.7 CT32.2 ; v1(20.86,6.15) 20.86,6.6 CA12.2 ; CT21.2 v1(18.45,131.31) ; v1(30.7,6.15) CA4.2 CA2.2 ; CC93.2 v1(152.63,31.3) ; CV85.2 130.01,122.56 130.45,122.13 v1(130.45,122.05) 130.45,121.41 CV86.2 130.66,121.19 CV84.2 130.66,119.66 130.1,119.1 RV40.1 129.62,119.18 RV41.1 ; v1(35.44,46.57) 35.72,46.85 C42.1 ; v1(60.89,129.34) 60.89,128.89 60.39,128.38 PQS05.4 ; CE14.1 32.6,77.03 v1(32.09,77.03) 31.81,77.03 31.01,76.22 EC1.2 ; C19.2 v1(96.68,38.13) ; v1(23.02,3.23) 22.69,2.9 CA66.2 ; PRB20.2 162.64,34.54 v1(162.32,34.22) ; v1(22.67,24.68) 22.98,25 UC21.3 ; v1(26.01,56.89) 26.45,57.34 EU2.1 ; PRV27.2 77.96,123.11 v1(78.1,123.25) ; 203.55,37.14 203.55,37.22 203.08,37.69 v1(203.08,38.4) ; v1(216.8,30.78) CW5.2 CX3.2 ; v1(17.18,81.4) CL18.2 17.97,80.53 RL8.1 ; PQS07.3 63.7,125.46 v1(64.09,125.85) ; v1(32.09,82.91) 32.41,82.58 RE11.1 ; v1(160.63,115) CV333.2 160.64,115.73 CV169.2 ; v1(180.7,27.76) 179.71,27.76 179.1,28.37 RS19.2 ; v1(32.8,89.52) 32.24,88.96 UL2.2 ; v1(86.54,117.04) 86.54,117.01 86.03,116.51 PUF01.8 ; YL1.2 14.68,82.13 v1(14.7,82.1) ; v1(201.96,61.46) 201.96,61.02 C13.2 ; CU18.2 201.89,34.85 201.8,34.76 200.52,34.76 v1(200.18,34.41) ; C30.2 v1(52.35,101.09) ; v1(164.88,145.09) 164.9,145.09 CV394.2 ; v1(22.14,89.2) 22.39,89.2 CL3.2 22.75,88.69 23.53,87.92 RL14.2 ; DA6.1 v1(16.42,22.12) ; CE13.2 CE3.1 54.21,69.68 v1(53.7,69.17) ; PQ11.3 177.09,31 PR43.2 ; C15.2 v1(222.35,49.77) ; CV19.2 110.85,134.61 v1(110.85,134.25) ; v1(181.49,36.19) 181.39,36.09 CS2.2 CS1.2 ; 43.01,97.47 43.34,97.14 C28.2 44.69,97.14 v1(44.74,97.19) ; PRV02.2 PRV04.2 PRV05.2 v1(76.11,134.63) ; C52.2 143.63,40.51 143.15,40.99 v1(142.78,40.99) ; C48.2 v1(31.91,50.67) ; PR62.2 47.77,125.91 v1(48.17,126.3) ; CV344.2 164.96,148.63 164.75,148.84 v1(164.75,148.97) ; v1(80.34,121.9) PCV16.2 PCV17.2 ; PRS27.1 65.75,124.15 PRS29.2 65.87,124.27 65.87,124.91 v1(66.04,125.08) ; v1(47.24,32.48) 46.76,32 CD10.2 ; CA25.1 v1(25.31,22.04) ; CS20.2 203.05,31.8 203.05,31.49 203.02,31.46 203.02,31.41 v1(202.93,31.32) ; PRH14.1 161.03,41.89 v1(160.13,40.99) ; v1(22.17,127.67) 21.56,128.28 CT46.2 ; RS13.1 RS20.2 185.14,39.17 ; RS23.2 194.48,30.54 194.99,31.05 CU20.2 195.51,31.24 v1(195.6,31.33) ; PCB37.2 v1(188.48,46.67) ; v1(168.6,48.23) 169.31,48.94 PQH02.4 ; v1(94.56,131.71) PCV09.2 ; v1(44.39,111.91) 44.55,112.06 CT50.2 ; v1(195.93,36.02) 195.72,35.81 CU19.2 194.99,35.67 194.34,35.03 UU1.2 ; v1(147.1,34.56) 146.86,34.81 Q7.3 ; DA5.1 v1(16.35,7.84) ; v1(156.01,134.81) RV134.2 RV116.2 ; PCH11.2 168.08,43.54 PRH04.2 v1(168.02,42.79) ; CV15.2 RV16.2 113.22,138.87 v1(112.52,138.87) ; v1(163.68,89.5) 163.56,89.38 PCZ08.2 ; C35.1 33.24,51.36 v1(33.09,51.51) ; v1(33.41,120.15) 33.75,119.81 CT53.2 ; CT56.2 29.88,113.14 CT55.2 v1(29.7,112.14) ; v1(216.25,50.72) 215.98,50.45 C66.2 ; PCZ115.2 154.1,53.06 v1(154.1,53.49) ; v1(121.92,71.73) 121.22,72.42 CC64.2 ; UT3.2 v1(34.76,108.82) ; CL12.2 17.76,82.94 v1(19.15,82.94) ; PCB34.2 205.82,44.91 v1(205.68,44.77) ; v1(193.01,42.1) 193.07,42.03 CS13.2 CS14.2 ; v1(112.02,137.79) 111.92,137.89 111.92,138.3 CV61.2 ; C16.2 221.46,49.85 222.02,50.41 v1(222.16,50.41) ; v1(18.46,85.54) 18.26,85.75 CL11.2 ; v1(34.52,119.04) 34.52,118.67 34.96,118.23 CT54.2 ; v1(121.23,53.31) 121.37,53.17 CC1190.2 CC1189.2 ; PRS05.2 49.12,119.38 v1(48.8,119.69) 48.23,119.12 PCS04.2 ; PR43.2 177.02,31.07 177.02,31.48 v1(176.69,31.81) ; PCV31.2 71.9,121.01 72.08,120.84 v1(72.08,120.36) ; CC65.2 124.96,60.34 v1(124.73,60.11) ; v1(50.5,66.53) Q9.3 ; v1(196.87,37.92) 196.87,40.2 195.78,41.3 CS12.2 ; PD3.2 62,117.8 62,117.71 v1(61.74,117.45) ; Q3.3 45.8,61.45 v1(45.21,60.85) ; US5.2 190.01,36.44 190.23,36.66 191.47,36.66 192.05,36.08 192.13,36.08 v1(192.15,36.06) 192.16,36.08 192.78,36.08 CS40.2 ; PCM13.2 36.76,24.28 v1(37.05,24.58) ; PQ2.3 58.12,115.23 v1(58.45,115.57) ; 58.23,63.84 57.97,64.09 57.97,66.1 58.06,66.19 CD58.2 RD4.1 CD61.2 ; CE4.2 v1(40.29,63.81) 40.29,63.67 41.05,62.91 CE12.2 ; CV46.2 114.13,140.47 114.64,139.96 v1(114.64,139.92) ; v1(122.67,126.96) 122.53,126.83 122.39,126.83 122.09,126.53 CV107.2 ; C310.2 211.88,41.36 v1(211.31,41.36) ; v1(32.53,32.92) 32.65,32.92 32.85,33.11 PRM11.2 ; PQS62.3 57.97,133.94 v1(58.61,133.31) ; v1(210.64,46.58) 210.26,46.21 PRB26.2 ; C50.2 38.54,102.13 v1(38.24,102.43) ; v1(165.11,31) 164.76,31 164.35,30.59 PQB04.3 ; RI20.2 27.53,101.07 v1(26.48,102.13) 25.78,101.43 QI1.3 ; v1(119.01,140.72) 119.18,140.54 RV59.1 118.95,139.79 RV29.1 ; v1(147.62,82.53) 147.86,82.78 PCZ31.2 ; CA9.2 33.83,9.29 v1(34.15,9.61) ; 58.47,136.45 PCS63.2 ; 58.47,136.45 58.76,136.16 v1(58.76,135.4) ; 58.47,136.45 58.01,135.99 v1(58.01,135.4) ; CT49.2 44.7,115.46 v1(44.56,115.6) ; RH24.1 v1(227.03,62.35) ; v1(167.52,41.12) 167.52,41.07 PD5.1 ; v1(44.36,63.08) 43.75,63.69 43.6,63.69 CC9.1 ; CT12.2 32.51,112.59 v1(32.8,112.3) ; LE2.1 v1(54.7,85.54) ; v1(79.4,114.66) 79.39,114.66 PCF01.2 ; PCW13.2 v1(149.8,111.99) ; v1(37.6,102.43) 37.32,102.15 C51.2 ; PD2.2 60.12,118.96 60.11,118.95 v1(59.92,118.95) ; RW14.1 67.78,138.68 v1(67.78,137.22) ; EC2.2 CE19.2 31.53,66.48 v1(31.09,66.92) ; PCV12.2 PCV11.2 v1(82.9,129.73) ; v1(208.79,32.44) 209.1,32.12 CS21.2 ; PR15.2 90.56,152.71 90.04,152.19 v1(90.04,151.98) PR16.2 ; CF1.2 v1(175.81,69.34) ; CW7.2 CW10.2 70.33,135.56 v1(70.32,135.54) ; v1(38.95,86.6) 38.58,86.23 CE7.1 CE6.2 ; CC39.2 129.14,65.22 v1(129.7,65.78) ; v1(41.61,49.07) 41.61,49.18 C41.1 ; v1(129.77,89.87) 129.51,89.62 RC16.2 ; CA1.2 v1(31.78,6.98) ; v1(133.56,87.22) 133.32,86.99 CC73.2 ; PCM11.2 v1(51.07,27.19) ; v1(17.74,131.3) 16.94,132.1 CT22.2 ; CW16.2 v1(73.77,136.65) ; PU1.2 81.48,143.42 81.21,143.14 81.17,143.14 80.65,142.62 PCS16.2 v1(80.65,141.92) ; v1(50.81,86.98) 50.39,86.56 CE9.2 RE9.1 ; v1(42.07,50.59) 41.61,51.05 C38.2 ; JCRT.17 v1(223.13,40.55) ; v1(37.66,65.54) CE18.2 ; v1(150.02,55.18) 149.47,55.72 RC62.1 C1.2 ; RC57.1 148.5,61.7 v1(147.94,61.7) ; v1(172.66,28.25) 173.03,28.61 PR44.1 ; PQS11.3 63.41,119.12 v1(62.99,119.54) ; v1(16.1,43.68) 17.38,43.68 PC303.2 ; v1(147.94,60.32) 148.02,60.32 148.23,60.11 148.5,60.11 RC27.1 ; RV17.1 128.63,120.42 128.63,119.82 128.61,119.81 RV41.1 ; CA50.2 v1(38.06,11.49) ; v1(126.02,121.02) 126.03,121.02 RV369.2 ; v1(60.87,126.98) 61.02,127.14 PCS17.2 ; PD6.1 170.02,39.12 169.72,38.82 v1(169.72,38.39) ; PRB33.2 PCB45.2 v1(209.94,42.65) ; v1(114.82,120.99) 114.91,121.08 114.91,121.33 CV106.2 ; v1(44.29,123.5) 44.33,123.46 PQS30.1 45.52,123.46 45.75,123.22 PR66.2 ; CA28.1 v1(24.42,22.6) ; PCS62.2 41.3,128.07 PQS64.3 41.3,129.25 v1(40.93,129.62) ; v1(198.97,51.28) 199.44,51.75 PRB07.2 ; v1(126.73,80.35) 126.19,80.35 CC61.2 ; v1(16.1,107.39) RI16.2 CI10.2 ; CV176.2 128.43,131.79 128.67,132.03 v1(128.67,132.26) ; CA16.2 v1(38.43,9.08) ; CW6.2 223.24,49.87 v1(223.13,49.98) ; PRV09.2 69.03,132.93 PQS14.3 69.65,133.98 69.2,134.42 v1(69.2,134.63) ; PQH02.1 167.63,51.66 v1(167.46,51.82) 167.17,51.53 PCH20.2 ; v1(54.71,118.2) 54.59,118.2 54.45,118.33 54.11,118.33 PD1.1 53.77,117.99 PCS01.1 ; RA51.1 v1(21.37,23.93) ; v1(150.3,91.96) 150.72,91.54 PRZ25.1 ; v1(223.11,29.59) 222.97,29.45 JCRT.18 ; v1(62.69,117.45) 63.11,117.03 PRS30.2 ; C12.2 203.42,60.96 202.92,61.46 v1(202.66,61.46) ; Q26.1 v1(41.15,90.75) ; PCH13.2 162.28,43.03 v1(162.59,43.34) ; ED2.1 37.69,61.37 v1(37.69,61.58) 37.64,61.53 36.17,61.53 34.01,63.69 SW1.1 ; PRB24.2 205.82,46.87 v1(205.68,47.01) ; CC11.2 123.1,56.22 v1(122.23,55.36) ; PC9.2 81.45,141.89 v1(81.29,142.06) ; v1(37.5,97.21) C23.1 ; PC509.2 v1(18.77,103.26) ; RV120.2 v1(153.71,114.96) ; v1(41.59,33.08) 41.17,33.08 40.38,32.29 PCM21.2 ; CC6.1 148.19,59.24 v1(147.94,59.49) ; CI3.2 v1(16.81,98.83) ; v1(132.64,124.74) 132.58,124.68 CV93.2 ; PCF04.2 v1(82.14,109.79) ; v1(90.22,38.13) 90.31,38.22 RE3.2 91.08,37.38 CE1.2 ; R64.1 R65.2 220.7,62.99 v1(220.44,63.24) ; CV247.2 v1(162.24,150.6) ; v1(95.31,38.13) 94.98,37.81 QE1.3 ; YL1.4 v1(16.38,86.66) ; CA17.2 33.56,15.17 33.8,14.93 CA31.2 34.46,14.93 v1(34.91,14.48) ; CA3.2 v1(33.05,6.98) ; CL9.1 27.47,69.12 27.54,69.05 v1(27.54,69.03) ; CV242.2 164.9,135.52 164.88,135.5 v1(164.88,135.38) ; v1(31.46,29.33) 31.65,29.33 31.66,29.33 32.51,29.33 PCM15.2 ; v1(23.54,98.76) 23.78,98.52 PC508.2 ; UT4.2 28.86,117.09 28.94,117.17 v1(28.94,117.23) ; v1(83.89,111.5) 84.21,111.82 85.48,111.82 PCF06.2 85.96,111.29 PCF02.2 ; CC32.2 119.29,77.75 v1(119.26,77.78) ; CC23.2 117.31,76.45 v1(117.68,76.82) ; CH3.2 v1(221.23,67.5) ; C49.2 v1(30.64,50.67) ; CH4.2 v1(221.4,66.3) ; CH2.2 225.3,58.22 v1(224.82,57.75) ; PCH09.2 168.02,46.92 PRH02.2 168.82,46.86 169.59,47.63 v1(169.59,47.94) ; CV335.2 v1(158.54,114.81) ; C65.2 v1(220.33,51.07) ; PRS14.2 PCS11.2 v1(60.49,131.76) ; CC635.2 v1(122.54,42.78) ; CC8.2 43.93,62.4 CC10.1 44.54,61.79 v1(44.83,61.51) ; CV25.2 46.9,88.33 v1(46.5,87.93) ; CV334.2 v1(159.62,114.81) ; CA49.2 v1(38.08,12.38) ; v1(42.85,121.65) 42.45,122.04 42.21,122.04 CT4.2 42.17,122.78 CT10.2 ; RI17.2 v1(24.23,111.37) ; RV53.2 RV135.2 v1(164.9,141.85) ; v1(124.05,44) 123.8,44.25 CC66.2 124,44.9 CC74.2 ; CV34.2 CV33.2 117.57,128.97 117.47,128.88 117.47,128.84 v1(117.32,128.69) ; RV49.2 v1(165.76,122.74) ; RV123.2 v1(153.83,150.62) ; v1(49.49,100.03) 49.88,100.43 C29.2 ; v1(110.82,130.95) 111.18,130.59 111.48,130.59 CV27.2 111.5,131.24 CV39.2 CV179.2 ; CV211.2 v1(159.34,150.59) ; PC2502.2 63.33,114.23 v1(63.33,114.21) ; CV336.2 v1(157.46,114.81) ; DA1.1 v1(27.34,3.17) ; CV124.2 126.04,125.69 v1(126.04,126.21) 126.64,126.21 CV82.2 ; v1(220.3,44.43) 220.7,44.83 U2.2 ; v1(168.71,34.78) 168.27,34.34 PCB44.1 ; CC13.2 133.26,45.51 v1(133.57,45.83) ; v1(165.63,28.36) 165.63,28.64 164.75,29.52 PRB23.2 ; v1(67.8,109.3) 67.65,109.15 PR2503.2 ; v1(176.02,36.68) 175.77,36.93 PR38.2 ; CA14.2 v1(36.18,20.89) ; CA54.1 v1(19.91,6.15) ; v1(69.76,131.68) 69.63,131.55 PCV10.2 ; CV73.2 120.71,134.43 CV74.2 121.29,134.76 v1(121.75,134.3) 121.57,134.12 CV112.2 ; v1(145.88,57.75) 145.47,58.16 RC52.2 CC14.2 ; PCB31.2 v1(176.96,46.69) ; v1(196.81,61.96) CS24.2 CS25.2 ; CT3.2 v1(36.23,108.82) ; CV343.2 164.96,146.55 v1(164.94,146.55) ; CA29.1 v1(31.1,21.03) ; CV213.2 v1(158.38,150.59) ; v1(42.52,57.26) C39.2 ; PCB36.2 v1(187.28,49.36) ; CV342.2 v1(164.9,139.63) ; v1(53.56,68.02) R30.2 ; v1(216.54,44.99) 216.5,45.03 216.5,45.44 216.16,45.78 C14.2 ; DA2.1 v1(19.15,4.42) ; PCZ23.2 155.37,79.58 v1(155.21,79.74) 154.45,80.5 PCZ22.2 ; CA7.2 v1(39.99,21.79) ; CA51.2 v1(38.12,10.54)
  GND1 w0.203: HCPU3.1 114.85,38.01 ; HCPU3.1 115.51,39.78 ; HCPU3.1 110.66,39.78 ; HCPU3.1 111.31,38.01 ; HCPU3.1 114.85,41.54 ; HCPU3.1 113.08,37.35 ; HCPU3.1 111.31,41.54 ; HCPU3.1 113.08,42.2 ; JUSB2.4 16.55,25.75 ; JUSB2.4 15.88,25.08 ; JUSB2.4 15.88,26.42 ; JUSB2.4 16.41,25.22 ; JUSB2.4 15.35,25.22 ; JUSB2.4 16.41,26.28 ; JUSB2.4 15.35,26.28 ; JUSB2.4 15.21,25.75 ; 141.35,118.77 H9.1 ; H9.1 140.77,117.18 ; H9.1 142.95,114.99 ; H9.1 144.55,118.77 ; H9.1 142.95,119.36 ; H9.1 144.55,115.58 ; H9.1 141.35,115.58 ; H9.1 145.13,117.18 ; 12.6,92.26 JHDMI1.2 ; JHDMI1.2 12.02,92.85 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 12.14,93.31 ; JHDMI1.2 12.14,92.39 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 13.06,92.39 ; 1.67,66.42 JRJ45.11 ; JRJ45.11 2.85,65.08 ; JRJ45.11 1.67,65.08 ; JRJ45.11 4.03,66.42 ; JRJ45.11 4.03,65.75 ; JRJ45.11 4.03,65.08 ; JRJ45.11 1.67,65.75 ; JRJ45.11 2.85,66.42 ; JUSBC1.1 7.83,126.29 ; JUSBC1.1 7.83,124.74 ; JUSBC1.1 5.37,125.52 ; JUSBC1.1 5.37,126.29 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 7.83,125.52 ; JUSBC1.1 5.37,124.74 ; 135.71,99.11 HCPU2.1 ; HCPU2.1 135.09,100.78 ; HCPU2.1 139.05,102.44 ; HCPU2.1 137.38,98.49 ; HCPU2.1 139.67,100.78 ; HCPU2.1 139.05,99.11 ; HCPU2.1 137.38,103.06 ; HCPU2.1 135.71,102.44 ; 11.72,21.4 JUSB2.10 ; JUSB2.10 15.28,21.4 ; JUSB2.10 11.72,20.52 ; JUSB2.10 15.28,22.28 ; 11.72,44.42 JUSB1.10 ; JUSB1.10 15.28,45.3 ; JUSB1.10 11.72,45.3 ; JUSB1.10 15.28,44.42 ; JUSB1.10 15.28,46.18 ; JUSB1.10 13.5,44.42 ; 5.38,124.29 JUSBC1.2 ; JUSBC1.2 6.1,126.3 ; JUSBC1.2 6.1,124.29 ; JUSBC1.2 5.38,125.22 ; JUSBC1.2 6.82,126.3 ; JUSBC1.2 5.38,126.3 ; JUSBC1.2 6.82,124.29 ; 14.38,52.48 JUSB1.7 ; JUSB1.7 13.85,52.62 ; JUSB1.7 15.05,53.15 ; JUSB1.7 13.85,53.68 ; JUSB1.7 14.38,53.82 ; JUSB1.7 14.91,52.62 ; JUSB1.7 14.91,53.68 ; H4.1 9.32,84.38 ; H4.1 7.9,87.73 ; H4.1 6.48,84.38 ; H4.1 5.97,85.8 ; H4.1 9.83,85.8 ; H4.1 6.48,87.22 ; H4.1 7.9,83.87 ; H4.1 9.32,87.22 ; JRJ45.9 11.83,83.22 ; JRJ45.9 11.83,82.55 ; JRJ45.9 10.65,83.22 ; JRJ45.9 9.47,83.22 ; JRJ45.9 9.47,82.55 ; JRJ45.9 10.65,81.88 ; JRJ45.9 9.47,81.88 ; JRJ45.9 11.83,81.88 ; 11.72,61.88 JUSB1.12 ; JUSB1.12 15.28,61.88 ; JUSB1.12 15.28,61 ; JUSB1.12 11.72,61 ; JUSB1.12 15.28,60.12 ; JUSB1.12 13.5,61.88 ; JUSB1.4 15.88,50.32 ; JUSB1.4 15.35,49.12 ; JUSB1.4 15.21,49.65 ; JUSB1.4 16.41,49.12 ; JUSB1.4 15.35,50.18 ; JUSB1.4 15.88,48.98 ; JUSB1.4 16.55,49.65 ; JUSB1.4 16.41,50.18 ; JUSBC1.3 6.82,116.1 ; JUSBC1.3 6.82,118.11 ; JUSBC1.3 6.1,116.1 ; JUSBC1.3 6.1,118.11 ; JUSBC1.3 5.38,116.1 ; JUSBC1.3 5.38,118.11 ; JUSBC1.3 5.38,117.18 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 2.02,106 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 3.3,105.07 ; JHDMI1.21 2.02,105.07 ; JHDMI1.21 4.58,106 ; JHDMI1.21 4.58,105.07 ; JHDMI1.21 2.02,106.93 ; H8.1 8.42,111.08 ; H8.1 8.98,112.6 ; H8.1 5.38,111.08 ; H8.1 4.82,112.6 ; H8.1 6.9,110.52 ; H8.1 5.38,114.12 ; H8.1 6.9,114.68 ; H8.1 8.42,114.12 ; 6.4,44.42 JUSB1.11 ; JUSB1.11 5.03,45.3 ; JUSB1.11 7.77,45.3 ; JUSB1.11 7.77,44.42 ; JUSB1.11 5.03,44.42 ; 13.85,28.72 JUSB2.7 ; JUSB2.7 14.91,28.72 ; JUSB2.7 14.38,29.92 ; JUSB2.7 15.05,29.25 ; JUSB2.7 14.91,29.78 ; JUSB2.7 14.38,28.58 ; JUSB2.7 13.85,29.78 ; 5.03,37.98 JUSB2.13 ; JUSB2.13 7.77,37.98 ; JUSB2.13 5.03,37.1 ; JUSB2.13 7.77,37.1 ; JUSB2.13 6.4,37.98 ; H12.1 47.53,129.9 ; H12.1 46.99,128.41 ; H12.1 44.01,128.41 ; H12.1 46.99,131.39 ; H12.1 44.01,131.39 ; H12.1 45.5,127.87 ; H12.1 45.5,131.93 ; H12.1 43.47,129.9 ; 8,39.27 H5.1 ; H5.1 6.07,41.2 ; H5.1 6.58,39.78 ; H5.1 6.58,42.62 ; H5.1 9.42,42.62 ; H5.1 9.93,41.2 ; H5.1 9.42,39.78 ; H5.1 8,43.13 ; 135.09,39.78 HCPU4.1 ; HCPU4.1 137.38,37.35 ; HCPU4.1 137.38,42.2 ; HCPU4.1 135.09,37.35 ; HCPU4.1 139.67,37.35 ; HCPU4.1 135.09,42.2 ; HCPU4.1 139.67,42.2 ; HCPU4.1 139.67,39.78 ; JHDMI1.5 11.63,94.35 ; JHDMI1.5 11.51,94.81 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 11.51,93.89 ; JHDMI1.5 10.59,94.81 ; JHDMI1.5 10.47,94.35 ; H7.1 143.48,27.1 ; H7.1 140.13,28.52 ; H7.1 140.13,25.68 ; H7.1 142.97,25.68 ; H7.1 142.97,28.52 ; H7.1 139.62,27.1 ; H7.1 141.55,29.03 ; H7.1 141.55,25.17 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 11.47,89.6 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 11.47,90.53 ; JHDMI1.23 12.75,88.67 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 14.03,88.67 ; 12.02,95.85 JHDMI1.8 ; JHDMI1.8 12.14,95.39 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 13.18,95.85 ; JHDMI1.8 12.14,96.31 ; JHDMI1.8 13.06,96.31 ; 1.67,81.88 JRJ45.10 ; JRJ45.10 1.67,83.22 ; JRJ45.10 2.85,83.22 ; JRJ45.10 4.03,81.88 ; JRJ45.10 4.03,83.22 ; JRJ45.10 4.03,82.55 ; JRJ45.10 1.67,82.55 ; JRJ45.10 2.85,81.88 ; JUSBC1.6 1.6,117.71 ; JUSBC1.6 3.02,117.71 ; JUSBC1.6 3.02,116.88 ; JUSBC1.6 3.02,116.05 ; JUSBC1.6 1.6,116.05 ; 1.6,124.69 JUSBC1.5 ; JUSBC1.5 3.02,124.69 ; JUSBC1.5 3.02,126.35 ; JUSBC1.5 3.02,125.52 ; JUSBC1.5 1.6,126.35 ; 10.47,97.35 JHDMI1.11 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 10.59,96.89 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 11.63,97.35 ; JHDMI1.11 10.59,97.81 ; JUSBC1.4 7.83,117.65 ; JUSBC1.4 5.37,116.1 ; JUSBC1.4 6.6,116.1 ; JUSBC1.4 7.83,116.88 ; JUSBC1.4 7.83,116.1 ; JUSBC1.4 5.37,116.88 ; 110.66,98.49 HCPU1.1 ; HCPU1.1 115.51,98.49 ; HCPU1.1 115.51,100.78 ; HCPU1.1 113.08,98.49 ; HCPU1.1 113.08,103.06 ; HCPU1.1 115.51,103.06 ; HCPU1.1 110.66,100.78 ; HCPU1.1 110.66,103.06 ; JRJ45.12 11.83,65.08 ; JRJ45.12 9.47,65.75 ; JRJ45.12 11.83,65.75 ; JRJ45.12 9.47,65.08 ; JRJ45.12 11.83,66.42 ; JRJ45.12 9.47,66.42 ; JRJ45.12 10.65,65.08 ; JRJ45.12 10.65,66.42 ; 10.47,100.35 JHDMI1.17 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 10.59,99.89 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 10.59,100.81 ; JHDMI1.17 11.51,100.81 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 3.27,86.77 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 3.27,87.7 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 5.83,88.63 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 4.55,86.77 ; H13.1 216.28,67.43 ; H13.1 216.28,63.57 ; H13.1 211.42,63.57 ; H13.1 211.42,67.43 ; H13.1 211.42,65.5 ; H13.1 216.28,65.5 ; H13.1 213.85,67.43 ; H13.1 213.85,63.57 ; JUSB2.12 15.28,37.1 ; JUSB2.12 15.28,37.98 ; JUSB2.12 13.5,37.98 ; JUSB2.12 15.28,36.22 ; JUSB2.12 11.72,37.98 ; JUSB2.12 11.72,37.1 ; 11.47,105.03 JHDMI1.20 ; JHDMI1.20 14.03,105.03 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 12.75,105.03 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 12.75,103.17 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 11.47,104.1 ; 99.71,128.75 H10.1 ; H10.1 102.91,128.75 ; H10.1 102.91,131.94 ; H10.1 99.71,131.94 ; H10.1 101.31,132.53 ; H10.1 103.49,130.35 ; H10.1 101.31,128.16 ; H10.1 99.13,130.35 ; 4.92,130.5 H1.1 ; H1.1 8.78,130.5 ; H1.1 6.85,128.57 ; H1.1 6.85,132.43 ; H1.1 5.43,131.92 ; H1.1 8.27,129.08 ; H1.1 5.43,129.08 ; H1.1 8.27,131.92 ; H6.1 209.38,63.85 ; H6.1 206.03,62.43 ; H6.1 205.52,63.85 ; H6.1 208.87,65.27 ; H6.1 207.45,61.92 ; H6.1 208.87,62.43 ; H6.1 207.45,65.78 ; H6.1 206.03,65.27 ; 5.03,61 JUSB1.13 ; JUSB1.13 5.03,61.88 ; JUSB1.13 6.4,61.88 ; JUSB1.13 7.77,61 ; JUSB1.13 7.77,61.88 ; JUSB2.11 7.77,20.52 ; JUSB2.11 5.03,21.4 ; JUSB2.11 5.03,20.52 ; JUSB2.11 7.77,21.4
  VCC w0.203: 5.03,61 JUSB1.13 ; JUSB1.13 7.77,61.88 ; JUSB1.13 5.03,61.88 ; JUSB1.13 7.77,61 ; JUSB1.13 6.4,61.88 ; 10.47,100.35 JHDMI1.17 ; JHDMI1.17 10.59,100.81 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 11.51,100.81 ; JHDMI1.17 10.59,99.89 ; 7.9,83.87 H4.1 ; H4.1 6.48,84.38 ; H4.1 9.83,85.8 ; H4.1 6.48,87.22 ; H4.1 5.97,85.8 ; H4.1 9.32,87.22 ; H4.1 7.9,87.73 ; H4.1 9.32,84.38 ; H1.1 8.27,131.92 ; H1.1 8.27,129.08 ; H1.1 6.85,128.57 ; H1.1 5.43,129.08 ; H1.1 5.43,131.92 ; H1.1 6.85,132.43 ; H1.1 4.92,130.5 ; H1.1 8.78,130.5 ; JUSB1.12 15.28,60.12 ; JUSB1.12 15.28,61 ; JUSB1.12 13.5,61.88 ; JUSB1.12 11.72,61 ; JUSB1.12 15.28,61.88 ; JUSB1.12 11.72,61.88 ; 1.6,124.69 JUSBC1.5 ; JUSBC1.5 3.02,125.52 ; JUSBC1.5 3.02,124.69 ; JUSBC1.5 3.02,126.35 ; JUSBC1.5 1.6,126.35 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 10.59,97.81 ; JHDMI1.11 11.63,97.35 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 10.47,97.35 ; JHDMI1.11 10.59,96.89 ; 11.72,20.52 JUSB2.10 ; JUSB2.10 11.72,21.4 ; JUSB2.10 15.28,21.4 ; JUSB2.10 15.28,22.28 ; JUSBC1.4 7.83,116.88 ; JUSBC1.4 7.83,116.1 ; JUSBC1.4 6.6,116.1 ; JUSBC1.4 7.83,117.65 ; JUSBC1.4 5.37,116.88 ; JUSBC1.4 5.37,116.1 ; 2.02,106.93 JHDMI1.21 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 2.02,106 ; JHDMI1.21 4.58,106 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 3.3,105.07 ; JHDMI1.21 2.02,105.07 ; JHDMI1.21 4.58,105.07 ; JUSB2.12 15.28,37.98 ; JUSB2.12 11.72,37.1 ; JUSB2.12 13.5,37.98 ; JUSB2.12 11.72,37.98 ; JUSB2.12 15.28,36.22 ; JUSB2.12 15.28,37.1 ; JRJ45.9 11.83,81.88 ; JRJ45.9 9.47,83.22 ; JRJ45.9 9.47,82.55 ; JRJ45.9 9.47,81.88 ; JRJ45.9 11.83,83.22 ; JRJ45.9 10.65,83.22 ; JRJ45.9 10.65,81.88 ; JRJ45.9 11.83,82.55 ; JUSB1.4 15.88,50.32 ; JUSB1.4 16.55,49.65 ; JUSB1.4 15.35,50.18 ; JUSB1.4 15.21,49.65 ; JUSB1.4 16.41,49.12 ; JUSB1.4 15.88,48.98 ; JUSB1.4 15.35,49.12 ; JUSB1.4 16.41,50.18 ; 11.47,104.1 JHDMI1.20 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 14.03,105.03 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 12.75,103.17 ; JHDMI1.20 12.75,105.03 ; 1.67,83.22 JRJ45.10 ; JRJ45.10 4.03,82.55 ; JRJ45.10 4.03,83.22 ; JRJ45.10 2.85,81.88 ; JRJ45.10 4.03,81.88 ; JRJ45.10 1.67,82.55 ; JRJ45.10 2.85,83.22 ; JRJ45.10 1.67,81.88 ; 13.5,44.42 JUSB1.10 ; JUSB1.10 15.28,46.18 ; JUSB1.10 15.28,45.3 ; JUSB1.10 11.72,44.42 ; JUSB1.10 11.72,45.3 ; JUSB1.10 15.28,44.42 ; JUSB2.4 15.88,26.42 ; JUSB2.4 16.41,26.28 ; JUSB2.4 15.21,25.75 ; JUSB2.4 15.35,25.22 ; JUSB2.4 16.55,25.75 ; JUSB2.4 16.41,25.22 ; JUSB2.4 15.35,26.28 ; JUSB2.4 15.88,25.08 ; 110.66,103.06 HCPU1.1 ; HCPU1.1 113.08,103.06 ; HCPU1.1 113.08,98.49 ; HCPU1.1 115.51,98.49 ; HCPU1.1 115.51,103.06 ; HCPU1.1 110.66,100.78 ; HCPU1.1 115.51,100.78 ; HCPU1.1 110.66,98.49 ; JRJ45.11 2.85,66.42 ; JRJ45.11 4.03,66.42 ; JRJ45.11 4.03,65.75 ; JRJ45.11 1.67,65.75 ; JRJ45.11 1.67,65.08 ; JRJ45.11 2.85,65.08 ; JRJ45.11 4.03,65.08 ; JRJ45.11 1.67,66.42 ; 10.65,65.08 JRJ45.12 ; JRJ45.12 9.47,65.08 ; JRJ45.12 9.47,66.42 ; JRJ45.12 11.83,66.42 ; JRJ45.12 10.65,66.42 ; JRJ45.12 11.83,65.75 ; JRJ45.12 11.83,65.08 ; JRJ45.12 9.47,65.75 ; 5.38,126.3 JUSBC1.2 ; JUSBC1.2 6.82,126.3 ; JUSBC1.2 5.38,124.29 ; JUSBC1.2 6.1,124.29 ; JUSBC1.2 6.82,124.29 ; JUSBC1.2 6.1,126.3 ; JUSBC1.2 5.38,125.22 ; 11.47,88.67 JHDMI1.23 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 12.75,88.67 ; JHDMI1.23 11.47,89.6 ; JHDMI1.23 11.47,90.53 ; JHDMI1.8 13.06,96.31 ; JHDMI1.8 12.02,95.85 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 12.14,95.39 ; JHDMI1.8 13.18,95.85 ; JHDMI1.8 12.14,96.31 ; JUSB2.11 7.77,21.4 ; JUSB2.11 5.03,21.4 ; JUSB2.11 5.03,20.52 ; JUSB2.11 7.77,20.52 ; 5.03,37.1 JUSB2.13 ; JUSB2.13 6.4,37.98 ; JUSB2.13 7.77,37.98 ; JUSB2.13 7.77,37.1 ; JUSB2.13 5.03,37.98 ; 6.07,41.2 H5.1 ; H5.1 6.58,42.62 ; H5.1 6.58,39.78 ; H5.1 8,39.27 ; H5.1 9.42,39.78 ; H5.1 8,43.13 ; H5.1 9.93,41.2 ; H5.1 9.42,42.62 ; JUSB1.11 7.77,45.3 ; JUSB1.11 7.77,44.42 ; JUSB1.11 5.03,44.42 ; JUSB1.11 6.4,44.42 ; JUSB1.11 5.03,45.3 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 3.27,87.7 ; JHDMI1.22 3.27,86.77 ; JHDMI1.22 5.83,88.63 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 4.55,86.77 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 12.14,93.31 ; JHDMI1.2 12.02,92.85 ; JHDMI1.2 12.14,92.39 ; JHDMI1.2 12.6,92.26 ; JHDMI1.2 13.06,93.31 ; JUSBC1.6 3.02,116.88 ; JUSBC1.6 3.02,117.71 ; JUSBC1.6 1.6,117.71 ; JUSBC1.6 1.6,116.05 ; JUSBC1.6 3.02,116.05 ; 10.59,94.81 JHDMI1.5 ; JHDMI1.5 11.51,94.81 ; JHDMI1.5 11.51,93.89 ; JHDMI1.5 10.47,94.35 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 11.63,94.35 ; JUSBC1.3 6.82,116.1 ; JUSBC1.3 6.82,118.11 ; JUSBC1.3 5.38,116.1 ; JUSBC1.3 5.38,118.11 ; JUSBC1.3 6.1,116.1 ; JUSBC1.3 5.38,117.18 ; JUSBC1.3 6.1,118.11 ; 5.37,126.29 JUSBC1.1 ; JUSBC1.1 5.37,124.74 ; JUSBC1.1 5.37,125.52 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 7.83,126.29 ; JUSBC1.1 7.83,125.52 ; JUSBC1.1 7.83,124.74 ; 14.38,28.58 JUSB2.7 ; JUSB2.7 13.85,29.78 ; JUSB2.7 14.91,28.72 ; JUSB2.7 14.91,29.78 ; JUSB2.7 14.38,29.92 ; JUSB2.7 13.85,28.72 ; JUSB2.7 15.05,29.25 ; JUSB1.7 14.91,53.68 ; JUSB1.7 14.91,52.62 ; JUSB1.7 14.38,52.48 ; JUSB1.7 15.05,53.15 ; JUSB1.7 14.38,53.82 ; JUSB1.7 13.85,53.68 ; JUSB1.7 13.85,52.62 ; H8.1 6.9,114.68 ; H8.1 8.98,112.6 ; H8.1 5.38,111.08 ; H8.1 8.42,114.12 ; H8.1 4.82,112.6 ; H8.1 6.9,110.52 ; H8.1 8.42,111.08 ; H8.1 5.38,114.12
  GND2 w0.203: H11.1 127.5,151.56 ; H11.1 127.5,154.54 ; H11.1 126.01,151.02 ; H11.1 123.98,153.05 ; H11.1 124.52,151.56 ; H11.1 128.04,153.05 ; H11.1 126.01,155.08 ; H11.1 124.52,154.54 ; H1.1 8.27,131.92 ; H1.1 6.85,132.43 ; H1.1 8.27,129.08 ; H1.1 5.43,129.08 ; H1.1 4.92,130.5 ; H1.1 8.78,130.5 ; H1.1 5.43,131.92 ; H1.1 6.85,128.57 ; 113.08,98.49 HCPU1.1 ; HCPU1.1 115.51,98.49 ; HCPU1.1 110.66,100.78 ; HCPU1.1 110.66,103.06 ; HCPU1.1 113.08,103.06 ; HCPU1.1 110.66,98.49 ; HCPU1.1 115.51,100.78 ; HCPU1.1 115.51,103.06 ; H12.1 46.99,128.41 ; H12.1 45.5,127.87 ; H12.1 44.01,128.41 ; H12.1 45.5,131.93 ; H12.1 47.53,129.9 ; H12.1 44.01,131.39 ; H12.1 46.99,131.39 ; H12.1 43.47,129.9 ; 15.21,25.75 JUSB2.4 ; JUSB2.4 15.88,25.08 ; JUSB2.4 15.35,26.28 ; JUSB2.4 16.41,25.22 ; JUSB2.4 15.35,25.22 ; JUSB2.4 16.55,25.75 ; JUSB2.4 16.41,26.28 ; JUSB2.4 15.88,26.42 ; H6.1 209.38,63.85 ; H6.1 208.87,65.27 ; H6.1 207.45,65.78 ; H6.1 207.45,61.92 ; H6.1 205.52,63.85 ; H6.1 208.87,62.43 ; H6.1 206.03,62.43 ; H6.1 206.03,65.27 ; 14.38,28.58 JUSB2.7 ; JUSB2.7 13.85,28.72 ; JUSB2.7 13.85,29.78 ; JUSB2.7 14.91,28.72 ; JUSB2.7 14.38,29.92 ; JUSB2.7 14.91,29.78 ; JUSB2.7 15.05,29.25 ; JHDMI1.5 11.51,94.81 ; JHDMI1.5 10.47,94.35 ; JHDMI1.5 10.59,94.81 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 11.63,94.35 ; JHDMI1.5 11.51,93.89 ; 113.08,37.35 HCPU3.1 ; HCPU3.1 111.31,38.01 ; HCPU3.1 114.85,38.01 ; HCPU3.1 111.31,41.54 ; HCPU3.1 115.51,39.78 ; HCPU3.1 110.66,39.78 ; HCPU3.1 114.85,41.54 ; HCPU3.1 113.08,42.2 ; HCPU2.1 139.67,100.78 ; HCPU2.1 139.05,99.11 ; HCPU2.1 137.38,103.06 ; HCPU2.1 135.71,102.44 ; HCPU2.1 137.38,98.49 ; HCPU2.1 135.71,99.11 ; HCPU2.1 139.05,102.44 ; HCPU2.1 135.09,100.78 ; H13.1 216.28,63.57 ; H13.1 216.28,67.43 ; H13.1 216.28,65.5 ; H13.1 213.85,63.57 ; H13.1 211.42,63.57 ; H13.1 213.85,67.43 ; H13.1 211.42,67.43 ; H13.1 211.42,65.5 ; JUSBC1.6 3.02,116.88 ; JUSBC1.6 3.02,116.05 ; JUSBC1.6 1.6,117.71 ; JUSBC1.6 3.02,117.71 ; JUSBC1.6 1.6,116.05 ; JUSB1.7 14.38,53.82 ; JUSB1.7 15.05,53.15 ; JUSB1.7 13.85,53.68 ; JUSB1.7 14.91,53.68 ; JUSB1.7 14.91,52.62 ; JUSB1.7 14.38,52.48 ; JUSB1.7 13.85,52.62 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 2.02,106.93 ; JHDMI1.21 2.02,106 ; JHDMI1.21 3.3,105.07 ; JHDMI1.21 4.58,106 ; JHDMI1.21 2.02,105.07 ; JHDMI1.21 4.58,105.07 ; JHDMI1.21 4.58,106.93 ; 5.03,20.52 JUSB2.11 ; JUSB2.11 7.77,20.52 ; JUSB2.11 7.77,21.4 ; JUSB2.11 5.03,21.4 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 3.27,86.77 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 4.55,86.77 ; JHDMI1.22 3.27,87.7 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 5.83,88.63 ; JUSB1.12 15.28,61.88 ; JUSB1.12 11.72,61 ; JUSB1.12 11.72,61.88 ; JUSB1.12 13.5,61.88 ; JUSB1.12 15.28,61 ; JUSB1.12 15.28,60.12 ; 5.03,37.1 JUSB2.13 ; JUSB2.13 7.77,37.98 ; JUSB2.13 7.77,37.1 ; JUSB2.13 5.03,37.98 ; JUSB2.13 6.4,37.98 ; 99.13,130.35 H10.1 ; H10.1 99.71,128.75 ; H10.1 103.49,130.35 ; H10.1 99.71,131.94 ; H10.1 101.31,132.53 ; H10.1 102.91,128.75 ; H10.1 101.31,128.16 ; H10.1 102.91,131.94 ; H4.1 9.32,87.22 ; H4.1 6.48,84.38 ; H4.1 9.83,85.8 ; H4.1 7.9,83.87 ; H4.1 6.48,87.22 ; H4.1 7.9,87.73 ; H4.1 9.32,84.38 ; H4.1 5.97,85.8 ; 6.1,124.29 JUSBC1.2 ; JUSBC1.2 6.1,126.3 ; JUSBC1.2 5.38,126.3 ; JUSBC1.2 5.38,125.22 ; JUSBC1.2 6.82,124.29 ; JUSBC1.2 5.38,124.29 ; JUSBC1.2 6.82,126.3 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 12.75,88.67 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 11.47,90.53 ; JHDMI1.23 11.47,89.6 ; 15.21,49.65 JUSB1.4 ; JUSB1.4 15.88,48.98 ; JUSB1.4 16.55,49.65 ; JUSB1.4 15.35,49.12 ; JUSB1.4 15.35,50.18 ; JUSB1.4 16.41,49.12 ; JUSB1.4 15.88,50.32 ; JUSB1.4 16.41,50.18 ; JRJ45.12 10.65,66.42 ; JRJ45.12 11.83,65.75 ; JRJ45.12 11.83,65.08 ; JRJ45.12 9.47,65.08 ; JRJ45.12 9.47,65.75 ; JRJ45.12 10.65,65.08 ; JRJ45.12 9.47,66.42 ; JRJ45.12 11.83,66.42 ; JHDMI1.11 11.63,97.35 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 10.59,97.81 ; JHDMI1.11 10.47,97.35 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 10.59,96.89 ; JRJ45.11 2.85,66.42 ; JRJ45.11 4.03,65.75 ; JRJ45.11 1.67,65.08 ; JRJ45.11 4.03,65.08 ; JRJ45.11 4.03,66.42 ; JRJ45.11 1.67,65.75 ; JRJ45.11 1.67,66.42 ; JRJ45.11 2.85,65.08 ; 12.75,103.17 JHDMI1.20 ; JHDMI1.20 11.47,104.1 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 14.03,105.03 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 12.75,105.03 ; 6.6,116.1 JUSBC1.4 ; JUSBC1.4 5.37,116.88 ; JUSBC1.4 7.83,116.88 ; JUSBC1.4 5.37,116.1 ; JUSBC1.4 7.83,117.65 ; JUSBC1.4 7.83,116.1 ; 137.38,37.35 HCPU4.1 ; HCPU4.1 137.38,42.2 ; HCPU4.1 139.67,37.35 ; HCPU4.1 139.67,39.78 ; HCPU4.1 135.09,42.2 ; HCPU4.1 135.09,39.78 ; HCPU4.1 135.09,37.35 ; HCPU4.1 139.67,42.2 ; JUSBC1.5 3.02,126.35 ; JUSBC1.5 1.6,124.69 ; JUSBC1.5 3.02,124.69 ; JUSBC1.5 3.02,125.52 ; JUSBC1.5 1.6,126.35 ; H8.1 8.42,111.08 ; H8.1 6.9,114.68 ; H8.1 5.38,111.08 ; H8.1 5.38,114.12 ; H8.1 6.9,110.52 ; H8.1 8.42,114.12 ; H8.1 4.82,112.6 ; H8.1 8.98,112.6 ; JHDMI1.8 13.06,96.31 ; JHDMI1.8 12.02,95.85 ; JHDMI1.8 13.18,95.85 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 12.14,95.39 ; JHDMI1.8 12.14,96.31 ; 5.03,44.42 JUSB1.11 ; JUSB1.11 6.4,44.42 ; JUSB1.11 7.77,44.42 ; JUSB1.11 5.03,45.3 ; JUSB1.11 7.77,45.3 ; JUSB1.13 7.77,61 ; JUSB1.13 6.4,61.88 ; JUSB1.13 5.03,61 ; JUSB1.13 7.77,61.88 ; JUSB1.13 5.03,61.88 ; 11.72,20.52 JUSB2.10 ; JUSB2.10 15.28,21.4 ; JUSB2.10 15.28,22.28 ; JUSB2.10 11.72,21.4 ; JUSBC1.1 7.83,124.74 ; JUSBC1.1 5.37,124.74 ; JUSBC1.1 5.37,125.52 ; JUSBC1.1 6.6,126.29 ; JUSBC1.1 7.83,126.29 ; JUSBC1.1 7.83,125.52 ; JUSBC1.1 5.37,126.29 ; 5.38,118.11 JUSBC1.3 ; JUSBC1.3 6.82,116.1 ; JUSBC1.3 5.38,116.1 ; JUSBC1.3 6.1,118.11 ; JUSBC1.3 5.38,117.18 ; JUSBC1.3 6.82,118.11 ; JUSBC1.3 6.1,116.1 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 12.6,92.26 ; JHDMI1.2 12.02,92.85 ; JHDMI1.2 12.14,92.39 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 12.14,93.31 ; 2.85,81.88 JRJ45.10 ; JRJ45.10 2.85,83.22 ; JRJ45.10 4.03,82.55 ; JRJ45.10 1.67,83.22 ; JRJ45.10 1.67,82.55 ; JRJ45.10 1.67,81.88 ; JRJ45.10 4.03,83.22 ; JRJ45.10 4.03,81.88 ; JUSB2.12 13.5,37.98 ; JUSB2.12 15.28,37.1 ; JUSB2.12 11.72,37.98 ; JUSB2.12 11.72,37.1 ; JUSB2.12 15.28,36.22 ; JUSB2.12 15.28,37.98 ; 9.47,81.88 JRJ45.9 ; JRJ45.9 11.83,82.55 ; JRJ45.9 11.83,81.88 ; JRJ45.9 10.65,81.88 ; JRJ45.9 10.65,83.22 ; JRJ45.9 9.47,82.55 ; JRJ45.9 11.83,83.22 ; JRJ45.9 9.47,83.22 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 11.51,100.81 ; JHDMI1.17 10.59,99.89 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 10.47,100.35 ; JHDMI1.17 10.59,100.81 ; 140.77,117.18 H9.1 ; H9.1 142.95,119.36 ; H9.1 142.95,114.99 ; H9.1 141.35,118.77 ; H9.1 144.55,115.58 ; H9.1 145.13,117.18 ; H9.1 144.55,118.77 ; H9.1 141.35,115.58 ; 140.13,28.52 H7.1 ; H7.1 141.55,25.17 ; H7.1 140.13,25.68 ; H7.1 143.48,27.1 ; H7.1 141.55,29.03 ; H7.1 139.62,27.1 ; H7.1 142.97,28.52 ; H7.1 142.97,25.68 ; JUSB1.10 15.28,44.42 ; JUSB1.10 15.28,45.3 ; JUSB1.10 11.72,44.42 ; JUSB1.10 11.72,45.3 ; JUSB1.10 15.28,46.18 ; JUSB1.10 13.5,44.42 ; H5.1 9.42,39.78 ; H5.1 9.93,41.2 ; H5.1 6.07,41.2 ; H5.1 6.58,39.78 ; H5.1 8,39.27 ; H5.1 8,43.13 ; H5.1 6.58,42.62 ; H5.1 9.42,42.62
  BOTTOM w0.099: v1(115.25,60.34) 115.28,60.31
  BOTTOM w0.102: UC1.BD30 114.82,54 114.82,53.77 v1(114.56,53.51) ; v1(117.68,76.82) 117.7,76.82 117.7,76.74 118.03,76.41 UC1.R25 ; v4(34.51,130.72) v1(34.51,129.79) ; v1(72.35,44.45) 72.14,44.24 JDIMM1.256 ; v1(113.3,79.35) 113.35,79.31 UC1.M32 ; UC1.H22 120.02,82.51 v1(119.73,82.8) ; v1(119.96,63.76) 119.92,63.76 119.92,63.69 120.43,64.21 ; v4(15.4,107.44) 15.45,107.39 v1(16.1,107.39) ; v1(113.74,54.03) 113.93,54.23 113.93,54.61 ; v4(163.86,150.62) 163.2,150.62 v1(163.18,150.6) ; UC1.G32 113.93,83.39 113.75,83.58 113.61,83.58 113.35,83.84 v1(112.83,83.84) ; v4(110.59,26.41) 110.63,26.41 v1(111.15,26.93) ; 118.03,74.34 117.78,74.59 v1(117.78,74.81) ; v4(201.84,62.82) 202.66,62 v1(202.66,61.46) ; v1(56.22,116.21) 55.59,116.21 v4(55.53,116.26) ; v4(164.94,147.19) v1(164.94,146.55) ; UC1.A30 114.55,86.89 v1(114.34,86.89)
  BOTTOM w0.127: UC1.AR28 115.57,59.31 115.45,59.43 115.45,60.15 115.28,60.31 UC1.AP28 ; UC1.AR26 117.51,59.31 118.03,59.83 UC1.AP25 118.59,59.75 118.77,59.75 v1(118.78,59.75)
  BOTTOM w0.203: U3.11 v1(120.98,114.1) ; UV1.B16 134.58,133 134.67,132.91 v1(134.83,132.91) ; v1(116.14,144.69) 116.14,144.68 UV1.AF32 ; UV1.F22 132.33,137.61 132.58,137.61 v1(132.58,137.61) ; UV1.K2 128.94,122.08 v1(128.84,121.99)
  BOTTOM w0.22: v1(135.04,134.6) UV1.B18 ; v1(134.64,136.31) 134.53,136.2 UV1.B20 ; v1(135,138.36) 134.44,137.8 UV1.B22 ; UV1.B12 134.18,129.8 v1(134.5,129.48) ; v1(134.68,131.27) 134.63,131.32 134.22,131.32 UV1.B14
  BOTTOM w0.25: UV1.B26 134.14,141.48 v1(134.13,141.48) ; v1(131.63,144.92) 131.16,144.45 131.16,144.07 131.35,143.88 131.35,143.81 UV1.G31 ; v1(134.62,139.38) 134.6,139.38 134.6,139.4 UV1.B24 ; UV1.H17 130.73,134 131.35,134.62 v1(131.6,134.62)
  BOTTOM w0.254: UV1.AD32 117.74,144.54 v1(118,144.8) ; UC1.AL5 134.63,62.93 v1(134.75,62.81) 134.75,62.8 134.63,62.68 UC1.AM5 UC1.AN5 ; v1(72.8,97.09) 72.25,97.09 72.1,97.24 JDIMM1.52 ; UV12.E14 151.91,147.16 v1(151.82,147.24) ; UC1.AE12 129.23,68.15 129.49,67.89 v1(129.62,67.89) 130.03,68.3 UC1.AE11 ; v1(137.43,54.8) 137.63,54.8 139.89,52.55 142.24,52.55 143.48,51.3 v1(143.8,51.3) 147.1,51.3 v1(147.42,51.62) 147.42,55.3 147.16,55.56 143.6,55.56 v1(143.6,55.56) 143,54.97 143,54.41 142.31,53.71 140.07,53.71 138.04,55.75 v1(137.27,55.75) ; UX1.9 101.03,37.8 v1(101.25,37.57) ; UC1.AW28 115.73,55.69 v1(115.73,55.69) 116.11,55.69 UC1.AY27 ; v1(72.16,103.45) 71.87,103.74 JDIMM1.26 ; v1(131.85,59) 132.23,58.62 UC1.AU8 ; PUH01.8 166.47,46.28 v1(166.58,46.39) ; v1(59.69,99.17) 59.62,99.24 JDIMM2.44 ; UV12.C12 150.31,145.04 v1(150.67,144.67) ; JDIMM2.239 65.41,48.49 v1(64.84,47.91) ; JDIMM1.78 70.1,90.74 69.77,90.41 v1(69.77,90.4) ; JDIMM2.206 60.07,56.74 60.58,56.23 v1(60.58,56.1) ; v1(59.77,98.13) 59.66,98.24 JDIMM2.48 ; v1(114.22,145.3) 114.22,145.23 114.54,144.91 UV1.AH32 ; UV1.P6 126.04,125.3 v1(126.04,126.21) ; UV14.A3 v1(161.11,127.71) 160.31,127.71 UV14.C4 ; JDIMM1.90 v1(72.22,87.74) ; UV14.R11 v1(149.91,121.31) UV14.R12 ; UV14.F5 v1(157.11,126.11) UV14.G5 ; UC1.BB32 113.93,54.61 ; UV12.P10 159.11,143.53 v1(158.71,143.93) ; UV14.T5 v1(149.91,126.11) ; UV12.M5 157.51,139.53 v1(157.91,139.13) ; UV12.M10 157.51,143.52 v1(157.11,143.13) 156.71,143.53 UV12.L10 ; UC1.AN28 115.67,61.47 115.67,61.9 v1(115.28,62.28) ; v1(68.77,66.3) 68.08,65.61 67.55,65.61 67.43,65.49 JDIMM2.171 ; UV1.AG27 115.34,142.01 v1(115.67,142.34) ; v1(67.68,100.48) 67.67,100.49 JDIMM2.39 ; UV12.E12 v1(152.31,145.53) ; v1(72.45,98.93) 72.45,98.99 72.2,99.24 JDIMM1.44 ; UV12.B5 149.51,139.53 v1(149.91,139.93) ; v1(113.19,81.28) 113.22,81.31 UC1.K32 ; JDIMM1.56 v1(72.18,96.24) ; UV14.C14 159.91,118.94 v1(160.06,118.79) ; UV1.B8 134.65,126.6 134.96,126.29 v1(135.19,126.29) ; v1(77.59,47.96) 78.11,48.49 JDIMM1.239 ; UV14.U3 v1(149.11,127.71) ; v1(72.26,101) 72.03,101.24 JDIMM1.36 ; v1(80.55,105.79) 80.25,105.49 JDIMM1.19 ; PCW10.2 141.63,111.26 142.45,110.44 142.45,110.08 PUW01.8 ; UV12.T10 160.71,143.53 v1(160.31,143.93) ; v1(132.15,121.99) 132.13,121.99 132.13,122.98 UV1.F2 ; UV14.K2 UV14.K1 154.31,130.2 v1(154.34,130.23) ; v1(76.38,88.46) 76.38,89.05 77.32,89.99 JDIMM1.81 ; JDIMM2.27 67.62,103.49 v1(67.69,103.42) ; UV12.C1 150.31,135.98 v1(150.04,135.71) ; UV12.A12 148.71,145.13 v1(149.11,144.73) ; UV12.G10 153.51,143.52 v1(153.11,143.13) 152.71,143.53 UV12.F10 ; UC1.V22 120.43,74.23 v1(120,73.81) 120,73.68 UC1.W23 ; v1(135.13,143.39) 135.13,143.36 135.09,143.4 UV1.A30 ; UV1.F26 132.14,141.16 132.52,141.54 v1(132.52,142.1) 132.52,142.18 UV1.E28 ; v1(126.35,144.69) 126.84,144.2 UV1.M32 ; v1(120.03,61.81) 119.63,61.41 UC1.AN23 ; UV12.R1 159.91,135.87 v1(160.02,135.76) ; v1(161.91,144.73) 161.51,145.13 UV12.U12 ; JDIMM1.48 72.06,98.24 72.32,97.99 v1(72.32,97.95) ; UC1.AV7 133.1,57.31 v1(132.76,56.97) ; UV14.C1 159.91,130.05 v1(160.18,130.32) ; v1(124.5,144.99) 124.14,144.63 UV1.T32 ; JDIMM2.64 v1(59.48,94.24) ; JDIMM1.6 69.6,108.74 69,109.34 v1(69,109.72) ; JDIMM2.188 59.46,61.24 59.72,61.49 v1(59.72,61.51) ; JDIMM1.30 72.26,102.74 v1(72.57,102.43) ; v1(72.22,92.76) 71.74,93.24 JDIMM1.68 ; UV1.F20 132.3,136.2 132.44,136.34 v1(132.6,136.34) ; UV14.A1 161.51,129.76 v1(161.17,130.1) ; v1(61.03,53.88) 61.03,54.03 60.32,54.74 JDIMM2.214 ; UV13.C13 159.91,145.93 v1(160.31,146.33) 159.91,146.73 UV12.R14 ; UV14.K14 154.31,119.25 153.97,118.91 v1(153.97,118.85) ; UV14.M10 v1(153.11,122.91) UV14.L10 ; CV17.2 109.72,145.87 110.3,145.29 110.3,144.43 110.56,144.18 v1(110.59,144.18) 111.33,144.18 v1(111.9,143.6) ; v1(132.64,124.74) 132.53,124.74 132.27,125 UV1.F6 ; UV14.E1 157.9,130.12 v1(157.9,130.22) ; v1(130.06,132.29) 130.04,132.29 130.04,131.99 130.43,131.6 UV1.H14 ; v1(160.47,126.07) 160.47,126.27 UV14.B5 ; JDIMM2.98 v1(59.54,85.74) ; v1(128.23,85.26) 128.21,85.26 127.79,84.84 127.37,84.84 UC1.E14 127.19,84.75 126.76,84.75 126.3,85.22 v1(126.23,85.22) ; JDIMM1.188 70.95,61.24 72.15,61.24 v1(72.42,61.51) ; UV14.B10 v1(160.31,122.11) UV14.C11 ; UV14.G10 v1(157.11,122.91) UV14.F10 ; v1(156.06,130.36) 155.91,130.2 UV14.H1 155.97,129.65 155.97,128.97 UV14.H2 ; 108.36,142.17 108.7,141.82 109.13,141.82 109.64,141.32 CV18.2 ; 108.36,142.17 YV1.2 ; 108.36,142.17 108.12,141.94 105.88,141.94 105.6,142.22 v1(105.6,142.68) 105.6,146.09 106.28,146.77 107.93,146.77 v1(108.03,146.67) ; v1(59.51,48.6) 59.37,48.74 JDIMM2.238 ; UV14.P10 v1(151.51,122.11) ; JDIMM2.60 59.4,95.24 v1(59.48,95.32) ; JDIMM2.31 67.59,102.49 v1(67.71,102.61) ; UV14.U1 v1(148.24,130.17) ; UC1.F28 UC1.E27 v1(116.23,85.31) ; v1(150.16,147.24) 150.31,147.09 UV12.C14 ; UV15.C13 v1(149.91,119.71) UV14.R14 ; JDIMM1.10 v1(72.18,107.74) ; UV12.R4 159.91,138.73 v1(160.31,138.33) 159.91,137.93 UV12.R3 ; JDIMM1.15 77.85,106.49 77.6,106.23 v1(77.6,105.89) ; JDIMM1.39 80.75,100.49 81,100.24 v1(81,100.01) ; UV14.U14 v1(149.11,118.91) ; UV1.AD6 117.69,125 v1(117.29,125.4) 116.94,125.75 UV1.AE7 ; v1(59.48,103.74) JDIMM2.26 ; JDIMM1.243 78.19,47.49 77.66,46.95 v1(77.66,46.83) ; UV14.U12 148.34,120.54 v1(148.26,120.54) ; JDIMM1.206 72.9,56.74 73.22,56.42 73.22,56.17 v1(73.28,56.1) ; v1(22.26,43.65) 22.27,43.65 22.27,43.65 22.26,43.65 22.26,43.46 21.83,43.04 PU301.18 ; UV1.F14 132.14,131.28 v1(132.46,130.96) ; v1(131.6,134.62) 131.62,134.6 UV1.F18 ; v1(104.18,39.8) 104.18,39.35 104.53,39 UX1.16 ; v1(131.23,60.77) 132.02,60.77 132.43,60.36 UC1.AP8 ; UC1.AN26 117.23,61.4 v1(117.65,61.82) ; v1(161.91,135.92) 161.51,136.32 UV12.U1 ; JDIMM1.27 80.17,103.49 v1(80.39,103.7) ; v1(77.67,103.55) 77.67,104.06 78.1,104.49 JDIMM1.23 ; UV1.AB6 119.35,125 v1(119.72,124.63) ; v1(150.2,130.27) 150.31,130.17 UV14.R1 ; JDIMM2.222 59.54,52.74 v1(59.64,52.64) ; v1(151.91,130.29) 151.91,130.26 151.91,130.25 UV14.N1 ; v1(161.11,138.33) 161.51,137.93 UV12.U3 ; UV12.G5 153.51,139.53 v1(153.11,139.93) 152.71,139.53 UV12.F5 ; UV14.N14 v1(152.31,118.91) ; v1(106.12,34.7) 106.02,34.8 UX1.23 ; UV12.N12 158.31,145.13 v1(157.91,145.53) ; UV12.R11 159.91,144.33 v1(160.31,144.73) 159.91,145.13 UV12.R12 ; v1(113.78,76.76) 113.93,76.91 UC1.P32 ; UV12.H2 UV12.H1 154.31,135.76 v1(154.31,135.76) ; UV12.K13 155.91,145.93 v1(156.31,145.53) ; v1(150.71,137.52) 150.31,137.93 UV12.C3 ; v1(130.45,122.05) 130.53,122.13 130.53,122.98 UV1.H2 ; v1(59.48,93.16) 59.41,93.24 JDIMM2.68 ; JDIMM1.252 72.06,45.24 v1(72.15,45.33) ; UV12.D10 151.14,143.53 v1(151.49,143.18) ; JWLAN1.26 70.81,126.9 70.45,127.27 v1(70.35,127.27) ; JDIMM1.22 v1(72.29,104.74) ; v1(158.33,135.76) 158.31,135.78 UV12.N1 ; v1(151.72,135.76) 151.91,135.94 UV12.E1 ; UV1.AA27 120.14,142.19 v1(120.26,142.31) ; v1(60.04,45.21) 59.92,45.08 59.56,45.08 59.4,45.24 JDIMM2.252 ; JDIMM2.56 v1(59.48,96.24) ; JDIMM2.36 v1(59.48,101.24) ; v1(128.73,60.11) 129.13,59.71 UC1.AR12 ; v1(113.57,61.81) 113.93,61.45 UC1.AN32 ; v1(131.28,142.5) 131.28,141.86 UV1.G27 ; UV12.C4 149.91,138.33 v1(149.11,138.33) 148.71,137.93 UV12.A3 ; v1(59.61,53.92) 59.43,53.74 JDIMM2.218 ; UV1.K32 129.12,144.37 v1(129.65,144.37) 129.74,144.29 UV1.J31 ; UV1.AC24 UV1.AD25 117.74,140.26 v1(117.39,140.61) ; v1(156.71,140.09) 156.71,140.09 UV12.L5 ; v1(128.45,143.37) 128.45,143.35 128.7,143.09 128.7,142.9 128.94,142.66 UV1.K28 ; UV12.E3 151.91,137.93 v1(152.31,137.52) ; UV14.H13 v1(155.51,119.71) ; v1(161.88,118.94) 161.51,119.31 UV14.A14 ; v1(162.08,120.61) 161.81,120.61 161.51,120.91 UV14.A12 ; JDIMM1.238 v1(72.26,48.74) ; JDIMM1.98 v1(72.24,85.74) ; v1(133.75,124.72) 134.02,125 UV1.B6 ; UV1.R27 125.11,141.8 125.51,142.19 126.15,142.19 UV1.N27 ; UC1.AU20 121.93,58.41 121.91,58.41 v1(121.75,58.57) ; JDIMM2.6 v1(59.48,108.74) ; v1(111.19,141.77) v1(112.71,141.77) ; v1(69.57,92.24) JDIMM1.72 ; UV12.C11 150.31,144.32 v1(149.91,143.93) 149.51,143.53 UV12.B10 ; UV1.G8 131.44,126.49 131.86,126.49 131.96,126.6 UV1.F8 132.37,126.6 132.42,126.55 132.61,126.55 v1(132.63,126.53) ; UC1.AR5 UC1.AU5 UC1.AV5 ; v1(64.87,46.8) 65.55,47.49 JDIMM2.243 ; UV1.AD8 117.75,126.6 v1(118.11,126.24) ; JDIMM1.214 73.65,54.74 v1(74.52,53.87) ; UV1.J27 v1(129.74,142.45) ; UC1.AG11 129.98,66.26 129.98,66.03 129.73,65.78 v1(129.7,65.78) ; UV14.R3 v1(149.91,127.71) UV14.R4 ; v1(126.77,60.22) 127.23,59.76 UC1.AR14 ; v1(160.31,139.93) 160.71,139.53 UV12.T5 ; JDIMM2.94 v1(59.54,86.74) ; UV14.C3 v1(159.51,128.51) ; JDIMM2.103 v1(68.3,84.49) ; UV14.E3 v1(157.91,128.51) ; UC1.AV10 131.36,57.31 131.71,56.95 131.71,56.38 UC1.AY10 ; v1(72.18,95.32) 72.1,95.24 JDIMM1.60 ; v1(123.75,124.66) 124.08,125 UV1.T6 ; JDIMM2.90 v1(59.52,87.74) ; v1(134.15,122.23) 133.78,122.6 UV1.C1 ; JDIMM1.106 69.9,83.74 69.72,83.92 69.72,84.54 69.92,84.74 JDIMM1.102 v1(72.31,84.74) ; UV14.E14 158.32,119.3 158.32,119.03 158.32,119.04 v1(158.32,118.78) ; UC1.C3 135.84,85.71 v1(136.34,86.2) ; UX1.32 v1(101.03,32.37) ; UV1.AB32 v1(119.76,144.62) ; UV12.N14 158.31,146.73 v1(157.91,147.13) ; v1(131.02,127.83) 131.03,127.83 131.03,127.92 131.31,128.2 UV1.G10 UV1.F10 ; UV14.D10 159.08,122.51 v1(158.73,122.85) ; UV14.H14 v1(155.91,118.74) ; v1(72.16,53.92) 71.98,53.74 JDIMM1.218 ; UV1.L27 128.14,142.04 v1(127.86,142.32) ; UV1.P32 125.01,144.2 v1(124.8,144.41) ; UV14.T10 v1(149.91,122.11) ; v1(134.78,55.76) 135.17,55.36 135.85,55.36 136.31,54.91 UC1.BB1 136.61,54.83 136.69,54.83 137.28,54.24 137.4,54.24 v1(137.43,54.21) 137.59,54.21 138.38,53.42 138.38,51.52 140.5,49.4 141.58,49.4 142.78,50.6 v1(143.8,50.6) 144.05,50.86 148.24,50.86 v1(148.37,50.73) 148.37,46.73 148.18,46.54 v1(143.8,46.54) 143.53,46.54 142.2,47.87 140.11,47.87 137.45,50.54 137.45,52.7 136.88,53.27 v1(136.67,53.27) ; v1(59.87,102.43) 59.56,102.74 JDIMM2.30 ; v1(156.28,146.35) 156.28,146.36 UV12.K14 ; UV1.AH28 114.54,142.68 114.83,142.97 v1(114.83,143) ; JDIMM1.94 v1(72.24,86.74) ; v1(127.34,124.48) 127.34,124.49 UV1.M6 ; UV14.C12 v1(160.31,120.51) ; UV14.M5 v1(153.11,126.11) UV14.L5 ; UV12.A14 v1(148.34,147.1) ; v1(161.11,147.13) 161.51,146.73 UV12.U14 ; 80.37,84.49 JDIMM1.103 ; JDIMM1.9 80.28,107.99 80.46,108.17 80.46,108.96 v1(80.43,108.99) JDIMM1.5 ; UV12.H13 154.31,145.93 v1(154.71,146.33) 154.31,146.73 UV12.H14 ; v1(134.13,144.62) 134.13,144.59 UV1.C32 ; UV1.B10 135.08,128.2 135.12,128.16 v1(135.49,128.16) ; JDIMM1.210 v1(69.69,55.74) ; JDIMM2.10 v1(59.48,107.74) ; UV14.N12 v1(152.31,120.51) ; JDIMM1.64 v1(72.18,94.24) ; 80.36,83.5 80.35,83.49 JDIMM1.107 ; UV1.AE27 v1(117.33,141.4) ; v1(149.05,135.93) 148.71,136.28 UV12.A1 ; v1(65.01,104.1) 65.4,104.49 JDIMM2.23 ; UV14.N3 v1(152.31,127.71) ; v1(28.86,131.95) 28.42,131.95 28.16,131.69 UT10.5 ; v1(157.91,138.33) 158.31,137.93 UV12.N3 ; UV12.K2 155.91,137.12 v1(156.31,136.72) 155.91,136.32 UV12.K1 ; UV14.K13 v1(153.91,120.51) ; JDIMM2.52 v1(59.54,97.24) ; UV14.E12 v1(157.91,120.51) ; JDIMM2.22 v1(59.59,104.74)
  BOTTOM w0.3: UC1.T28 115.63,75.51 115.63,75.89 115.28,76.24 v1(115.28,76.31) ; UC1.G16 125.53,83.61 125.78,83.61 v1(125.83,83.66) ; v1(131.17,53.46) 131.17,53.49 131.19,53.51 131.19,53.97 UC1.BD10 ; UC1.BD16 125.23,53.55 v1(125.29,53.49) ; UC1.AY15 v1(126.23,55.36) ; v1(126.23,55.36) 126.32,55.36 126.67,55.71 127.03,55.71 UC1.AY14 127.39,55.75 127.75,55.75 128.14,55.36 v1(128.23,55.36) ; v1(126.23,55.36) 126.16,55.36 125.81,55.71 125.43,55.71 UC1.AY16 125.03,55.71 124.64,55.71 124.29,55.36 v1(124.23,55.36) ; v1(135.18,64.31) 135.18,64.23 134.87,63.92 134.87,63.55 UC1.AL5 ; v1(135.18,64.31) UC1.AK5 ; v1(135.18,64.31) 135.18,64.39 134.83,64.74 134.83,65.11 UC1.AJ5 134.81,65.48 134.81,65.85 135.18,66.22 v1(135.18,66.31) ; v1(136.99,63.52) 136.78,63.31 UC1.AL1 ; UC1.BD7 133.23,53.96 132.75,53.48 v1(132.65,53.48) ; UC1.F5 135.22,84.31 v1(135.24,84.28) ; v1(120.71,82.86) 121.16,83.31 UC1.G21 ; UC1.AA1 136.82,71.6 v1(136.95,71.6) ; v1(116.93,81.81) 117.08,81.66 117.08,81.46 UC1.K26 ; UC1.L25 118.03,80.41 v1(117.63,80.81) ; UC1.AP20 122.63,60.11 v1(122.73,60.11) ; UC1.AP15 126.48,60.51 v1(126.77,60.22) ; v1(128.84,78.9) 128.84,78.92 UC1.M12 ; UC1.N11 130.11,78.31 130.51,78.71 v1(130.51,78.74) ; v1(135.18,70.31) 135.18,70.25 134.83,69.9 134.83,69.51 UC1.AD5 134.83,69.11 134.83,68.73 135.18,68.38 v1(135.18,68.31) ; v1(135.18,70.31) UC1.AC5 ; v1(135.18,70.31) 135.18,70.38 134.87,70.69 134.87,71.07 UC1.AA5 134.79,71.46 134.79,71.85 135.18,72.24 v1(135.18,72.31) ; v1(129.75,57.67) 129.79,57.67 UC1.AU11 130.16,58.11 v1(129.75,58.52) ; v1(137.06,69.31) 136.92,69.31 136.92,69.31 UC1.AD1 ; v1(115.28,78.31) 115.28,78.25 115.62,77.91 115.62,77.77 115.83,77.56 UC1.P28 ; v1(115.28,78.31) UC1.N28 ; v1(115.28,78.31) 115.28,78.39 115.63,78.74 115.63,79.11 UC1.M28 115.63,79.51 115.63,79.88 115.28,80.23 v1(115.28,80.31) ; UC1.BD14 127.23,53.55 v1(127.15,53.47) ; UC1.N25 118.03,78.41 v1(117.63,78.81) ; UC1.R28 v1(115.28,76.31) ; v1(115.28,76.31) UC1.R30 ; UC1.T1 136.84,75.31 136.89,75.36 137.04,75.36 137.37,75.69 v1(137.46,75.69) ; v1(128.73,60.11) 128.63,60.11 UC1.AP13 ; UC1.E7 133.01,84.93 132.64,84.93 132.31,85.26 v1(132.23,85.26) ; v1(117.65,61.82) 117.65,61.83 118.03,62.21 UC1.AM25 ; v1(123.73,59.31) 123.48,59.56 123.33,59.71 UC1.AR19 ; UC1.E26 117.43,84.91 117.81,84.91 118.16,85.26 v1(118.23,85.26) ; UC1.AU13 v1(128.63,57.71) ; UC1.M26 117.23,79.51 v1(116.93,79.81) ; v1(128.23,55.36) 128.32,55.36 128.67,55.71 129.03,55.71 UC1.AY12 129.53,55.61 129.89,55.61 130.14,55.36 v1(130.23,55.36) ; v1(128.23,55.36) UC1.AY13 ; v1(116.93,62.81) 117.23,63.11 UC1.AL26 ; v1(124.75,57.78) 124.71,57.82 124.58,57.82 124.29,58.11 UC1.AU18 ; UC1.AG5 v1(135.18,66.31) ; v1(135.18,66.31) 135.18,66.4 134.75,66.83 134.75,67.19 UC1.AF5 134.83,67.51 134.83,67.86 135.18,68.21 v1(135.18,68.31) ; UC1.AU22 120.13,58.11 v1(119.73,57.71) ; v1(117.63,63.7) 118.03,64.1 UC1.AK25 ; UC1.AR7 133.55,58.99 v1(133.55,58.73) ; v1(115.28,80.31) UC1.L28 ; v1(115.28,80.31) 115.28,80.36 115.63,80.71 115.63,81.11 UC1.K28 115.63,81.51 115.63,81.88 115.28,82.23 v1(115.28,82.31) ; UC1.AK12 129.23,64.05 129.57,63.72 v1(129.69,63.72) ; v1(132.05,70.8) 132.05,70.69 UC1.AC8 ; UC1.A7 133.56,86.93 v1(133.56,87.22) ; v1(130.23,55.36) 130.33,55.36 130.58,55.61 130.93,55.61 UC1.AY10 131.53,55.61 131.9,55.61 132.15,55.36 v1(132.23,55.36) ; v1(130.23,55.36) UC1.AY11 ; UC1.H25 v1(117.73,82.81) UC1.G26 ; UC1.AC12 129.69,69.85 v1(129.7,69.85) 130.03,70.18 UC1.AC11 ; v1(135.18,72.31) UC1.Y5 ; v1(135.18,72.31) 135.18,72.38 134.93,72.63 134.93,73.01 UC1.W5 134.93,73.61 134.93,73.97 135.18,74.22 v1(135.18,74.31) ; v1(135.18,80.31) 135.18,80.38 134.83,80.73 134.83,81.11 UC1.K5 134.83,81.51 134.83,81.9 135.18,82.25 v1(135.18,82.31) ; v1(135.18,80.31) 135.18,80.24 134.83,79.89 134.83,79.51 UC1.M5 134.93,79.01 134.93,78.65 135.18,78.4 v1(135.18,78.31) ; v1(135.18,80.31) UC1.L5 ; v1(123.23,85.23) 123.41,85.41 UC1.D18 124.1,85.41 v1(124.23,85.27) ; v1(123.23,85.23) UC1.E19 ; v1(123.23,85.23) 123.06,85.41 UC1.D20 122.42,85.41 v1(122.23,85.22) ; v1(132.81,64.83) 132.81,64.69 UC1.AK8 132.43,64.11 UC1.AL7 ; UC1.AN15 126.3,61.31 126.67,60.94 v1(126.78,60.94) ; UC1.AV12 129.53,57.01 v1(129.76,57.01) ; v1(118.75,82.82) UC1.G23 ; UC1.E22 v1(120.23,85.26) ; v1(120.23,85.26) 120.31,85.26 120.66,84.91 121.03,84.91 UC1.E21 121.33,84.81 121.7,84.81 122.12,85.22 v1(122.23,85.22) ; v1(120.23,85.26) 120.16,85.26 119.81,84.91 119.43,84.91 UC1.E23 119.03,84.91 118.65,84.91 118.3,85.26 v1(118.23,85.26) ; UV1.F24 132.33,139.33 132.5,138.99 v1(132.5,138.98) ; v1(120.03,61.81) 120.43,62.21 UC1.AM22 ; v1(132.23,85.26) 132.16,85.26 131.8,84.89 131.73,84.89 131.64,84.8 131.53,84.8 131.43,84.71 UC1.E10 131.12,84.71 130.92,84.91 130.65,84.91 130.3,85.26 v1(130.23,85.26) ; v1(132.23,85.26) UC1.E8 ; v1(127.62,87.33) 127.23,86.94 UC1.A14 ; v1(120.21,76.82) 120.21,76.53 UC1.R22 ; UC1.AR32 113.2,59.31 v1(113.2,59.31) ; UC1.AV21 121.08,57.31 v1(120.73,56.96) ; UC1.Y12 129.23,72.28 v1(129.7,71.81) 130.03,72.14 UC1.Y11 ; v1(138.38,67.94) 138.33,67.94 137.7,67.31 UC1.AF1 ; v1(124.23,85.27) 124.23,85.27 UC1.E18 ; v1(124.23,85.27) 124.31,85.27 124.7,84.88 125.06,84.88 UC1.E16 125.23,84.91 UC1.D16 125.86,85.28 126.17,85.28 v1(126.23,85.22) 126.23,85.21 UC1.E15 ; UC1.AM28 115.31,62.31 v1(115.28,62.28) ; v1(122.23,55.36) 122.15,55.36 121.8,55.71 121.43,55.71 UC1.AY21 121.03,55.71 120.66,55.71 120.31,55.36 v1(120.23,55.36) ; v1(122.23,55.36) 122.31,55.36 122.66,55.71 123.03,55.71 UC1.AY19 123.43,55.71 123.79,55.71 124.14,55.36 v1(124.23,55.36) ; v1(122.23,55.36) UC1.BB20 ; v1(122.23,55.36) UC1.AY20 ; v1(115.28,82.31) 115.28,82.38 115.63,82.73 115.63,83.11 UC1.G28 ; v1(115.28,82.31) UC1.H28 ; v1(135.18,78.31) 135.18,77.96 UC1.N4 135.33,77.46 v1(135.17,77.29) ; v1(135.18,78.31) UC1.N5 ; UC1.H13 128.33,82.51 v1(128.73,82.91) ; v1(118.81,56.94) 118.82,56.94 118.89,57.01 118.93,57.01 UC1.AV23 ; UC1.M21 v1(120.83,79.71) ; UC1.N22 120.43,78.41 v1(120.03,78.81) ; v1(128.78,86.84) 129,86.84 UC1.A12 ; v1(137.07,73.36) 137.02,73.31 136.54,73.31 UC1.W1 ; UC1.L13 127.88,79.76 127.74,79.76 v1(127.67,79.69) ; v1(123.73,83.61) 123.43,83.31 UC1.G19 ; UC1.AL23 119.63,63.21 v1(119.23,62.81) ; v1(125.08,87.3) 125.23,87.16 UC1.A16 ; v1(132.23,55.36) 132.32,55.36 132.57,55.61 132.93,55.61 UC1.AY7 133.33,55.81 UC1.AY6 134.37,55.81 134.42,55.76 v1(134.78,55.76) 134.78,56.08 134.73,56.13 UC1.AW5 134.73,56.31 134.73,57.21 UC1.AV5 ; v1(132.23,55.36) UC1.AY8 ; UC1.AV19 123.43,57.31 v1(123.73,57.01) ; UC1.AN5 134.82,61.12 134.82,60.75 135.18,60.39 v1(135.18,60.31) ; UC1.BD12 129.24,54 129.24,53.5 v1(129.33,53.41) ; v1(119.23,55.3) UC1.AY23 119.32,55.91 119.48,55.75 119.77,55.75 120.16,55.36 v1(120.23,55.36) ; UC1.P1 136.55,77.33 136.98,77.33 137.18,77.53 137.3,77.53 v1(137.51,77.74) ; UC1.BD26 v1(117.23,53.31) ; v1(136.94,81.61) 136.83,81.61 UC1.K1 ; UC1.V12 129.23,74.25 129.7,73.78 130.03,74.11 UC1.V11 ; v1(135.18,82.31) 135.18,82.39 134.93,82.64 134.93,83.01 UC1.G5 ; v1(135.18,82.31) UC1.H5 ; v1(121.73,82.91) 122.13,82.51 UC1.H20 ; UC1.L15 126.49,80.11 v1(126.73,80.35) ; v1(135.18,60.31) 135.18,60.21 134.93,59.96 134.93,59.61 UC1.AR5 ; v1(135.18,60.31) UC1.AP5 ; v1(127.73,57.01) 127.43,57.31 UC1.AV14 126.8,57.74 126.53,57.74 126.23,58.04 UC1.AU15 ; v1(115.21,57.29) 115.27,57.29 115.33,57.23 115.76,57.23 UC1.AV28 115.83,57.46 115.64,57.66 115.64,58.11 UC1.AU28 ; v1(137.31,57.31) UC1.AV1 ; v1(135.18,74.31) 135.18,74.4 134.63,74.95 UC1.T5 134.68,75.36 134.68,76.25 UC1.R5 134.93,76.61 134.93,76.98 135.17,77.21 v1(135.17,77.29) ; v1(135.18,74.31) UC1.V5 ; v1(125.74,59.29) 125.69,59.29 125.28,59.71 UC1.AR16 ; v1(120.73,59.31) 121.13,59.71 UC1.AR21 ; v1(119.23,79.81) 119.63,79.41 UC1.M23 ; v1(125.71,57.02) 125.43,57.31 UC1.AV16 ; UC1.BD3 136.08,54.01 136.6,53.48 136.6,53.34 v1(136.67,53.27) ; UC1.AV32 113.55,57.31 v1(113.43,57.18) ; UC1.AG12 129.23,66.08 129.53,65.78 v1(129.7,65.78) ; UC1.K22 120.13,80.91 119.76,81.28 v1(119.76,81.34) ; v1(113.36,86.42) 113.93,85.85 UC1.C32 ; v1(116.86,75.73) 116.93,75.73 117.23,75.43 UC1.T26 ; v1(120.23,55.36) UC1.AY22 ; UC1.AG8 132.43,66.21 v1(132.83,65.81) ; v1(124.23,55.36) UC1.AY18 ; UC1.AY26 117.45,55.69 117.87,55.69 118.09,55.91 UC1.AY25 118.31,55.83 118.31,55.41 v1(118.27,55.37) ; UC1.AV26 v1(117.63,57.7) UC1.AU25 ; v1(131.27,63.7) 131.22,63.7 UC1.AL10 ; v1(137.03,60.89) 137.03,60.99 136.72,61.31 UC1.AN1 ; v1(123.57,144.59) 123.17,144.2 UV1.V32 ; UC1.K21 121.13,80.91 v1(120.73,81.31) ; UC1.H18 124.62,82.9 v1(124.62,82.91) ; v1(118.23,85.26) UC1.E25 ; v1(135.17,77.29) 134.64,77.29 UC1.P5 ; v1(132.57,129.3) 132.14,129.73 UV1.F12 ; v1(116.93,77.78) 117.23,77.48 UC1.P26 ; v1(114.79,128.7) 114.79,128.45 UV1.AH10 ; v1(122.23,85.22) UC1.E20 ; UC1.BD21 v1(121.23,53.31) ; UC1.AE5 v1(135.18,68.31) ; UC1.N8 132.12,77.99 132.12,77.83 v1(132.11,77.83) ; v1(121.73,60.91) 121.63,60.91 UC1.AN21 ; v1(117.21,87.27) 117.23,87.25 UC1.A26 ; v1(136.61,82.8) 136.61,82.88 136.53,82.97 UC1.G1 ; UC1.A19 123.23,87 122.93,87.3 v1(122.87,87.3) ; v1(124.73,60.11) 124.33,60.51 UC1.AP18 ; UC1.AN10 130.83,61.17 v1(131.23,60.77) ; v1(121.73,80.51) 121.79,80.45 121.89,80.45 UC1.L20 ; v1(120,74.76) 120,74.94 UC1.T23 ; UC1.AK22 120.43,64.21 ; UC1.A10 130.97,86.87 v1(130.97,87.07) ; v1(130.23,85.26) 130.14,85.26 129.79,84.91 129.43,84.91 UC1.E12 129.03,84.91 128.66,84.91 128.31,85.26 v1(128.23,85.26) UC1.E13 ; v1(130.23,85.26) UC1.E11 ; UC1.R12 129.23,76.52 v1(129.6,76.89) 129.6,76.77 130.03,76.34 UC1.R11 ; v1(116.88,73.76) 117.23,73.41 UC1.W26 ; v1(123.2,53.34) 123.2,53.98 UC1.BD19 ; UC1.K19 v1(123.63,81.3) ; UC1.AM8 132.43,62.21 132.74,61.9 v1(132.74,61.74) 132.79,61.74 UC1.AN7 ; UV1.K6 128.98,125 129.38,124.59 v1(129.38,124.61) ; UC1.AJ1 136.65,65.31 137.07,64.89 v1(137.07,64.83) ; v1(137.13,59.34) 137.09,59.31 UC1.AR1 ; UC1.M1 136.68,79.46 136.8,79.46 136.83,79.49 137.1,79.49 v1(137.24,79.63) ; UC1.V8 132.43,74.1 v1(132.11,73.78) ; v1(119.26,77.78) 119.26,77.78 119.63,77.41 UC1.P23 ; UC1.A21 v1(121.23,87.31) ; UC1.A5 134.61,86.73 134.61,87.19 v1(134.62,87.21) 135.03,87.21 UC1.A3 ; UC1.BD23 v1(119.23,53.31) ; v1(125.62,81.34) 125.62,81.21 125.32,80.91 UC1.K16 ; UC1.A23 v1(119.23,87.31)
  BOTTOM w0.305: JDIMM2.193 67.68,59.99 67.89,59.77 67.89,59.11 67.77,58.99 JDIMM2.197 63.6,58.99 63.09,59.49 v1(63.09,59.75) ; JFP1.1 221.02,30.62 v1(221.02,31.8) ; JDIMM2.226 60.05,51.74 60.36,51.43 v1(60.36,51.3) ; JDIMM2.251 66.46,45.5 67.77,45.5 67.98,45.72 67.98,46.14 67.63,46.49 JDIMM2.247 65.56,46.49 64.31,45.23 v1(63.69,45.23) ; JDIMM1.168 69.62,66.24 v1(69.57,66.29) 70.02,66.74 JDIMM1.166 ; JDIMM1.51 80.34,97.49 80.56,97.7 80.56,98.2 80.27,98.49 JDIMM1.47 78.17,98.49 77.59,97.91 v1(77.59,97.1) ; v1(76.31,50.01) 76.31,50.01 77.79,51.49 JDIMM1.227 80.13,51.49 80.44,51.18 80.44,50.79 80.13,50.49 JDIMM1.231 ; JDIMM2.175 64.89,64.49 v1(64.64,64.74) ; v1(63.66,53.46) 63.66,53.93 64.72,54.99 JDIMM2.213 ; JEDP1.32 213.01,44.95 213.02,44.96 v1(213.74,44.96) ; JDIMM1.205 76.59,56.99 76.14,56.54 76.14,56.11 v1(76.14,56.1) ; UV1.AC26 118.82,140.72 v1(119.01,140.72) ; v1(63.22,47.94) 64.37,49.09 65.15,49.09 65.55,49.49 JDIMM2.235 ; v1(61.88,105.85) 61.88,105.95 61.1,106.74 JDIMM2.14 ; v1(123.61,140.64) 123.68,140.64 124.12,140.2 UV1.T25 ; JWLAN1.39 80.67,130.15 v1(81.94,128.89) ; UC1.AK20 v1(122.83,64.71) UC1.AJ19 UC1.AH20 v1(122.83,66.31) UC1.AG19 UC1.AF18 v1(124.43,67.91) UC1.AE17 UC1.AD16 v1(126.03,69.51) UC1.AC15 UC1.AB14 v1(127.6,71.08) UC1.AA13 ; v1(59.51,100.24) JDIMM2.40 ; UC1.AK16 v1(126.03,64.71) 126.28,64.96 UC1.AJ15 UC1.AH16 v1(126.03,66.31) UC1.AG15 UC1.AF14 v1(127.6,67.88) UC1.AE13 ; UC1.V20 v1(122.83,74.31) UC1.U19 UC1.T18 v1(124.43,75.91) UC1.R17 UC1.P16 v1(126.03,77.51) UC1.N15 ; JDIMM2.51 67.55,97.49 67.85,97.18 67.85,96.44 67.4,95.99 JDIMM2.57 65.61,95.99 v1(64.42,94.8) ; JDIMM2.35 65.2,101.49 v1(65.17,101.46) ; v1(63.53,49.91) 63.53,50.03 64.79,51.29 65.43,51.29 65.62,51.49 JDIMM2.227 ; UC1.N19 v1(122.83,77.51) UC1.P20 ; v1(213.75,43.42) 213.74,43.41 213.04,43.41 213,43.45 JEDP1.35 ; JDIMM2.19 67.44,105.49 67.76,105.81 67.76,106.14 67.42,106.49 JDIMM2.15 65.15,106.49 64.9,106.23 v1(64.9,105.89) ; JDIMM1.82 v1(72.16,89.74) ; v1(76.74,90.85) 76.74,91.15 77.18,91.59 77.95,91.59 78.35,91.99 JDIMM1.73 ; JDIMM1.172 68.96,65.24 v1(68.87,65.15) 69.78,64.24 JDIMM1.176 ; v1(80.74,127.88) 79.98,128.65 JWLAN1.33 ; v1(76.58,45.17) 76.58,45.28 77.42,46.12 77.93,46.12 78.3,46.49 JDIMM1.247 80.26,46.49 80.56,46.18 80.56,45.79 80.26,45.49 JDIMM1.251 ; JDIMM1.175 77.59,64.49 v1(77.34,64.74) ; v1(72.34,43.18) 72.32,43.18 72.26,43.24 JDIMM1.260 ; v1(65.07,88.55) 65.5,88.99 JDIMM2.85 ; JDIMM1.31 77.86,102.49 76.51,101.14 v1(76.51,101) ; v1(68.06,65.13) 68.11,65.08 68.11,63.75 67.35,62.99 JDIMM2.181 ; v1(130.21,126.21) 129.8,125.8 UV1.J7 UV1.H6 ; UV1.W25 121.86,140.2 v1(121.41,140.65) 120.96,140.2 UV1.Y25 ; JSSD1.27 32.88,34.02 32.88,33.22 32.57,32.92 v1(32.53,32.92) ; UV1.AC27 118.29,142.04 118.21,142.04 v1(118.14,142.11) ; JDIMM1.2 v1(69.69,109.74) ; JDIMM2.47 65.48,98.49 64.69,97.7 v1(64.69,97.2) ; JDIMM1.35 77.96,101.49 77.66,101.18 v1(77.66,101) ; JSSD1.51 26.87,32.51 v1(26.88,32.51) ; v1(30.05,32.55) 29.87,32.72 JSSD1.39 ; v1(77.56,53.44) 78.11,53.99 JDIMM1.217 ; v1(77.81,134.97) 77.92,134.97 78.24,134.65 JWLAN1.57 ; UV1.U25 v1(122.71,140.62) ; UC1.G26 116.78,83.75 116.78,83.76 116.78,83.76 116.78,83.77 116.77,83.77 116.72,83.82 v1(116.72,83.82) ; JDIMM1.235 77.7,49.49 76.4,48.19 v1(76.4,47.96) ; JSSD1.45 v1(28.38,32.46) ; UV1.U27 123.55,141.59 123.55,141.4 v1(123.61,141.33) ; JDIMM2.252 57.13,45.24 56.98,45.38 56.98,46.02 57.2,46.24 JDIMM2.248 ; JDIMM2.205 63.89,56.99 63.44,56.54 63.44,56.11 v1(63.44,56.1) ; JDIMM1.14 72.55,106.74 v1(73.5,107.69) ; JWLAN1.45 80.18,131.65 80.69,132.16 v1(80.69,132.8) ; UC1.AF20 v1(122.83,67.91) UC1.AE19 UC1.AD18 v1(124.43,69.51) UC1.AC17 UC1.AB16 v1(126.03,71.11) UC1.AA15 UC1.Y14 v1(127.63,72.71) UC1.W13 ; JDIMM2.188 57.29,61.24 56.99,60.94 56.99,60.46 57.21,60.24 JDIMM2.192 ; v1(77.39,94.53) 77.39,95.16 78.22,95.99 JDIMM1.57 80.13,95.99 80.63,95.49 80.63,95.25 80.37,94.99 JDIMM1.61 ; v1(64.17,58.16) 64.51,57.82 65.25,57.82 65.42,57.99 JDIMM2.201 ; v1(68.3,84.49) 68.3,85.19 67.99,85.49 JDIMM2.99 ; RX6.1 106.07,32.74 105.53,33.28 v1(105.53,33.57) ; v1(121.37,142.18) 121.74,141.81 UV1.W27 ; JDIMM2.107 65.45,83.49 v1(65.19,83.75) ; v1(59.79,57.91) 59.62,57.74 JDIMM2.202 56.97,57.74 56.81,57.9 56.81,59.02 57.03,59.24 JDIMM2.196 ; JDIMM1.180 73.57,63.24 v1(74.39,62.42) ; v1(122.67,126.96) 123.1,127.4 UV1.U9 ; JDIMM2.260 59.22,43.24 v1(59.51,43.53) ; v1(192.15,36.06) 192.13,36.08 192.05,36.08 191.49,36.64 190.59,36.64 190.2,36.25 JHDD1.1 ; v1(59.6,91.18) 59.15,90.74 JDIMM2.78 ; JDIMM2.189 67.57,60.99 67.92,61.34 67.92,61.68 67.61,61.99 JDIMM2.185 65.33,61.99 v1(64.96,61.63) ; v1(60.87,48.64) 60.87,48.76 59.89,49.74 JDIMM2.234 ; UV1.AG12 114.79,129.25 v1(114.79,128.7) ; v1(77.89,137.65) JWLAN1.69 ; v1(211.31,41.36) 211.91,41.95 JEDP1.38 ; JSSD1.15 35.87,34.72 36.04,34.89 v1(36.04,35.43) ; JSSD1.9 37.38,32.85 v1(37.58,32.65) ; v1(72.21,100.24) JDIMM1.40 ; v1(59.69,109.74) JDIMM2.2 ; JDIMM2.77 67.78,90.99 67.99,90.78 67.99,90.39 67.59,89.99 JDIMM2.81 64.62,89.99 63.68,89.05 v1(63.68,88.46) ; v1(80.55,109.98) 80.55,109.99 JDIMM1.1 ; JDIMM2.72 59.68,92.24 60.02,92.58 v1(60.23,92.58) ; UC1.AK14 v1(127.63,64.71) UC1.AJ13 ; JSSD1.21 v1(34.38,35.49) ; JDIMM2.209 65.35,55.99 v1(65.22,56.12) ; v1(73,51.28) 72.89,51.38 72.89,52.08 72.24,52.74 JDIMM1.222 69.77,52.74 69.58,52.54 69.58,51.95 69.79,51.74 JDIMM1.226 ; JDIMM1.209 78.05,55.99 v1(77.92,56.12) ; UV1.R27 124.94,142.1 v1(124.63,142.41) ; v1(129.31,128.69) 129.31,128.82 UV1.K11 ; UC1.AK18 v1(124.43,64.71) UC1.AJ17 UC1.AH18 v1(124.43,66.31) UC1.AG17 UC1.AF16 v1(126.01,67.89) UC1.AE15 UC1.AD14 v1(127.63,69.51) UC1.AC13 ; v1(77.77,88.55) 78.2,88.99 JDIMM1.85 ; JDIMM1.189 80.36,60.99 80.57,61.21 80.57,61.81 80.39,61.99 JDIMM1.185 78.03,61.99 v1(77.66,61.63) ; v1(121.71,144.64) 121.38,144.64 UV1.Y32 ; JDIMM1.89 80.35,87.99 80.76,87.58 80.76,87 v1(80.6,86.84) 80.58,86.84 80.44,86.99 JDIMM1.93 ; v1(77.24,135.57) 77.82,136.15 JWLAN1.63 ; JDIMM2.86 v1(59.59,88.74) ; JDIMM1.18 72.21,105.74 v1(72.26,105.79) ; v1(67.85,66.29) 67.65,66.49 JDIMM2.167 ; v1(77.54,92.58) 77.54,93.29 78.24,93.99 JDIMM1.65 80.37,93.99 80.68,93.68 80.68,93.29 80.37,92.99 JDIMM1.69 ; v1(60.11,63.75) 60.11,63.93 59.8,64.24 JDIMM2.176 ; JDIMM2.210 59.26,55.74 59.42,55.58 61.72,55.58 v1(62.2,56.07) ; v1(213.77,49) 213.77,49 213.29,49 212.84,49.45 JEDP1.23 ; JDIMM1.81 80.46,89.99 80.69,90.22 80.69,90.77 80.48,90.99 JDIMM1.77 ; JDIMM2.69 67.35,92.99 67.63,92.7 67.63,92.26 67.36,91.99 JDIMM2.73 65.24,91.99 64.68,91.42 64.37,91.42 63.98,91.03 v1(63.98,90.86) ; v1(78.1,123.25) 77.97,123.12 77.97,122.37 78.19,122.15 JWLAN1.7 ; v1(120.17,140.85) 120.17,140.03 UV1.AB24 ; v1(77.25,62.57) 77.25,62.61 77.63,62.99 JDIMM1.181 ; UC1.P28 115.75,77.22 115.75,76.61 115.83,76.52 UC1.R28 ; JFP1.4 v1(219.5,29.57) 219.54,29.61 219.7,29.61 220,29.92 JFP1.3 ; v1(73.57,48.74) 73.57,48.77 72.6,49.74 JDIMM1.234 69.63,49.74 69.47,49.9 69.47,50.52 69.69,50.74 JDIMM1.230 ; JDIMM2.18 59.51,105.74 v1(59.56,105.79) ; JHDD1.7 187.2,36.17 187.56,36.53 187.56,36.64 v1(187.57,36.64) 188.39,36.64 188.7,36.34 JHDD1.4 ; v1(60.87,64.59) 60.02,65.43 59.26,65.43 59.07,65.24 JDIMM2.172 ; v1(64.86,53.44) 65.41,53.99 JDIMM2.217 67.59,53.99 67.97,53.61 67.97,52.81 67.64,52.49 JDIMM2.223 ; UV1.W26 122.26,141 v1(122.54,141.27) ; v1(63.72,92.51) 63.72,93.04 65.14,94.45 65.14,94.66 65.47,94.99 JDIMM2.61 67.52,94.99 67.83,94.68 67.83,94.28 67.54,93.99 JDIMM2.65 ; v1(64.84,49.96) 65.37,50.49 JDIMM2.231 ; UC1.AB20 122.83,71.11 123.02,71.3 UC1.AA19 UC1.Y18 v1(124.43,72.71) UC1.W17 UC1.V16 v1(126.03,74.31) UC1.U15 UC1.T14 v1(127.63,75.91) UC1.R13 ; v1(129.69,63.72) 129.71,63.72 130.03,64.03 UC1.AK11 ; v1(60.99,61.59) 60.99,61.86 60.61,62.24 JDIMM2.184 ; JDIMM1.184 69.9,62.24 v1(69.76,62.1) ; JDIMM1.192 69.83,60.24 69.61,60.02 69.61,59.37 69.75,59.24 JDIMM1.196 72.06,59.24 72.33,58.97 74.16,58.97 74.54,59.36 v1(74.54,59.76) ; UC1.AD20 v1(122.83,69.51) UC1.AC19 UC1.AB18 v1(124.42,71.09) UC1.AA17 UC1.Y16 v1(126.03,72.71) UC1.W15 UC1.V14 v1(127.63,74.31) UC1.U13 ; JDIMM2.43 67.45,99.49 67.76,99.8 67.76,100.4 v1(67.68,100.48) ; v1(81,100.01) 80.48,99.49 JDIMM1.43 ; UC1.AN18 UC1.AP18 ; JDIMM2.230 61.26,50.74 v1(61.82,51.3) ; v1(62.58,62.61) 61.95,63.24 JDIMM2.180 ; v1(76.91,58.11) 76.91,58.07 77.16,57.82 77.8,57.82 77.97,57.99 JDIMM1.201 80.49,57.99 80.66,58.16 80.66,58.77 80.45,58.99 JDIMM1.197 ; JDIMM2.93 68.08,86.99 v1(68.09,86.98) 68.09,87.55 67.65,87.99 JDIMM2.89 ; v1(76.35,53.45) 76.35,53.89 77.45,54.99 JDIMM1.213 ; v1(75.78,59.77) 75.78,59.93 76.2,60.36 77.9,60.36 78.27,59.99 JDIMM1.193 ; UV1.K22 129.39,138.05 v1(129.39,138.07) ; JWLAN1.51 77.88,133.15 v1(77.81,133.08) ; UC1.T20 v1(122.83,75.91) UC1.R19 UC1.P18 v1(124.43,77.51) UC1.N17 ; UC1.N13 v1(127.63,77.51) UC1.P14 UC1.R15 v1(126.03,75.91) UC1.T16 UC1.U17 v1(124.43,74.31) UC1.V18 UC1.W19 v1(122.83,72.71) UC1.Y20 ; UC1.AL12 129.23,63.3 129.67,62.86 v1(129.67,62.73) ; JDIMM2.1 66.45,109.98 v1(67.85,109.98) ; v1(77.86,138.74) 78.27,139.15 JWLAN1.75 ; v1(73.31,45.3) 73.31,45.79 72.87,46.24 JDIMM1.248 ; v1(76.44,51.37) 76.8,51.37 77.73,52.29 78.06,52.29 78.26,52.49 JDIMM1.223 ; v1(60.42,83.75) 60.41,83.74 JDIMM2.106 ; JDIMM2.166 59.49,66.74 v1(59.99,66.24) JDIMM2.168 ; UC1.AM20 v1(122.84,63.12) ; UC1.AL16 125.63,63.48 v1(126.01,63.1) 126.41,62.71 UC1.AM15 ; UV1.AE14 116.94,131.05 v1(116.88,131) ; UC1.AG13 v1(127.63,66.31) UC1.AH14 ; UV1.F16 132.16,133 132.47,132.69 v1(132.47,132.64) ; v1(65.1,108.16) 65.27,107.99 JDIMM2.9 ; JSSD1.33 v1(31.38,32.89) ; JDIMM2.82 v1(59.77,89.74) ; v1(74.77,64.64) 74.77,64.94 76.32,66.49 JDIMM1.167 ; JDIMM1.244 72.21,47.24 v1(72.41,47.44) ; v1(70.36,125.03) 70.49,124.9 JWLAN1.18 ; v1(118.16,127.77) UV1.AC9 ; v1(72.49,57.97) 72.26,57.74 JDIMM1.202 ; v1(25.38,32.47) JSSD1.57 ; JDIMM2.5 v1(64.77,108.99) ; JDIMM1.86 v1(72.29,88.74) ; JDIMM2.244 v1(59.72,47.24)
  BOTTOM w0.35: v1(129.56,78.76) 129.56,78.72 129.23,78.4 UC1.N12
  BOTTOM w0.381: UV2.3 108.1,122.12 v1(107.72,121.74) ; UV1.AB15 119.34,132.03 v1(119.78,132.48) 120.3,133 UV1.AA16 121.14,133.8 UV1.Y17 121.34,133.88 v1(121.75,134.3) 122.25,134.8 UV1.V18 UV1.U20 123.34,135.9 v1(123.74,136.3) 124.14,136.7 UV1.T21 ; UV1.R12 UV1.T13 124.14,131.06 v1(124.57,131.49) 125.08,132 UV1.R15 125.6,132.46 125.6,132.52 126.08,133 UV1.N16 126.66,132.48 v1(126.74,132.48) ; UV1.R12 125.14,129.86 124.27,129 UV1.T11 ; UV1.R12 125.67,130.53 v1(125.74,130.53) 126.14,130.93 UV1.N13 UV1.M12 UV1.N11 126.1,128.96 125.18,128.96 UV1.R11 ; UV1.AB10 120.17,128.2 v1(120.18,128.2) ; v1(124.75,80.51) 124.34,80.11 UC1.L18 ; v1(124.91,127.63) 125.31,127.63 UV1.P9 ; v1(120.18,128.2) 120.18,128.83 UV1.AA11 ; v1(120.18,128.2) 120.18,128.2 UV1.Y10 ; UV1.N18 UV1.R17 125.05,133.8 v1(124.64,133.39) 124.53,133.39 UV1.T16 123.34,132.2 UV1.U15 123.34,131.98 122.93,131.57 v1(122.93,131.51) 122.93,131.44 122.48,131 UV1.V13 ; UC1.V11 130.5,74.77 v1(130.53,74.77) ; UV1.N25 126.67,140.2 v1(126.15,140.72) 125.63,140.2 UV1.P25 ; UV1.AC17 118.25,133.71 v1(118.25,133.51) ; v1(121.79,136.25) UV1.Y20 ; v1(130.08,136.91) 130.07,136.91 130.07,136.87 UV1.H20 ; v1(122.88,129.46) 122.42,129 UV1.V11 ; v1(126.6,136.36) 126.58,136.36 UV1.N21 126.07,136.8 125.68,136.4 v1(125.68,136.34) UV1.R20 UV1.T18 124.14,134.6 UV1.U17 123.14,133.8 UV1.V16 122.29,133 121.34,132.05 UV1.Y15 121.26,132 120.8,131.53 120.8,131.45 UV1.AA13
  BOTTOM w0.4: v1(134.83,122.95) 134.8,122.95 134.8,123.14 UV1.A3
  BOTTOM w0.406: v1(12.76,121.69) 12.74,121.69 12.33,121.28 EU8.3 ; C58.2 176.08,65.87 176.08,65.53 176.88,64.73 U8.5 ; UC1.V25 118.03,74.34 ; EU7.3 26.28,130.42 v1(26.32,130.46)
  BOTTOM w0.457: v1(117.64,32.51) 117.46,32.51 117,32.05 C18.2 ; v1(144.69,45.36) 144.36,45.03 UC9.3
  BOTTOM w0.508: v1(66.96,117.52) 67.4,117.08 RW12.2 ; CV161.2 v1(165.76,126.86) ; CC1193.2 130.59,25.59 131.33,26.32 131.33,26.64 v1(131.61,26.92) 131.92,26.92 132.83,26.01 UC20.2 ; JIOB1.9 205.2,37.95 v1(205.28,38.03) 205.69,38.03 206.2,37.53 JIOB1.8 ; CC68.2 CC67.2 121.56,43.7 122.48,42.78 v1(122.54,42.78) ; v1(108.21,140.19) RV4.2 108.85,140.18 RV163.2 ; v1(111.19,141.77) 110.56,141.77 110.1,141.32 CV18.2 ; RT119.2 v1(29.6,131.96) ; UI1.2 19.85,56.56 19.9,56.61 CU10.2 19.47,57.27 v1(19.2,57.01) ; DU2.1 v1(219.49,37.1) ; v1(209.22,52.46) 208.86,52.46 208.52,52.12 PCB28.2 ; v1(118.93,36.52) 119.14,36.32 C636.2 ; C57.2 v1(178.36,67.42) ; PCZ01.1 v1(162.94,88.53) ; CL4.2 v1(18.78,79.56) ; v1(107.58,146.21) 107.58,146.21 107.4,146.21 106.66,145.47 YV1.4 ; v1(141.31,112.99) 141.64,112.66 PRW10.2 141.63,112.35 PCW10.2 ; JODD1.8 v1(188.2,66.1) ; RV21.1 123.38,117.7 v1(123.19,117.52) ; v1(214.07,36.63) 213.37,36.63 JIOB1.1 ; QT3.3 34.78,114.37 v1(34.73,114.32) ; v1(182,73.01) 180.82,74.19 JFAN1.5 ; JHDD1.13 192.77,31.33 v1(192.85,31.33) ; v1(126.02,121.02) 125.44,121.02 124.93,120.51 RV368.1 ; v1(213.94,35.6) 213.6,35.6 213.42,35.77 212.75,35.77 212.24,36.28 212.24,36.76 JIOB1.2 ; PRH09.2 168.09,45.15 PCH10.2 169.08,45.99 v1(169.69,46.6) ; v1(85.57,38.73) 85.57,39.35 87.05,40.83 JDIMM1.261 ; v1(164.88,135.38) 164.89,135.39 CV158.2 ; PBATT1.11 176.11,36.59 v1(176.02,36.68) ; PHV01.2 v1(91.17,122.31) ; v1(145.83,112.36) PRW04.2 144.31,112.36 PCW11.2 ; JODD1.7 188.2,63.29 187.69,62.78 v1(187.66,62.78) ; v1(185.56,68.27) 185.2,67.91 JODD1.2 ; v1(151.47,32.33) 151.91,32.77 PBATT1.12 ; v1(108.03,146.67) 108.85,146.67 109.65,145.87 CV17.2 ; PR100.2 90.29,152.23 v1(90.04,151.98) ; v1(84.37,111.12) 84.37,111.04 85,110.41 JDIMM1.262 ; v1(122.29,111.15) 122.54,111.39 C33.2 C32.2 ; CV155.2 164.89,139.64 v1(164.9,139.63) ; PC23.2 88.61,143.57 PQ18.3 89.27,144.16 89.82,144.72 v1(89.82,144.99) 89.34,145.47 PQ17.3 ; PC1808.2 176.19,61.86 PC1810.2 v1(175.38,61.88) ; CV230.2 160.31,150.59 v1(160.3,150.6) ; v1(108.68,137.73) CV66.2 108.77,137.07 CV123.2 ; RV83.2 v1(120.17,117.65) ; RV89.1 110.74,127.21 v1(111.25,127.72) ; CL19.2 v1(17.18,80.58) ; JSPK1.5 v1(12.12,3.36) ; v1(181.99,71.69) 181.99,71.14 182.6,70.53 JFAN1.4 ; v1(107.64,129.47) 107.66,129.45 107.66,129.4 108.13,128.94 RV88.1 ; CT28.2 CT27.2 v1(11.4,125.15) ; JIOB1.5 209.24,36.76 209.24,35.88 v1(209.39,35.73) ; v1(84.16,116.52) 84.16,117.09 84.74,117.67 CLIP2.1 ; CC95.2 141.12,45.54 140.54,44.96 v1(140.58,44.96) ; RV118.2 v1(165.76,123.62) ; v1(13.12,2.01) JSPK1.6 ; CLRP1.2 v1(132.74,36.22) ; RV38.2 148.53,115.36 v1(148.15,114.98) 148.1,115.03 148.09,115.03 147.87,115.25 147.87,115.26 147.64,115.48 CV97.2 ; CV216.2 CV153.2 165.24,121.93 v1(165.78,121.93) ; CV162.2 v1(165.76,127.94) ; PQ15.3 95.77,147.87 v1(96.93,149.03) ; v1(185.09,65.44) 185.2,65.32 JODD1.1 ; v1(209.94,42.65) 210.09,42.8 210.42,42.8 210.93,43.31 PCB40.2 ; PCW09.2 138.28,112.36 139.07,112.36 PRW02.2 139.1,112.38 139.1,113.13 v1(138.91,113.33) ; CC94.2 v1(142.97,42.24) ; v1(100.17,29.61) 100,29.78 99.79,29.78 99.03,30.54 CX2.2 ; EU4.1 29.61,39.49 30.12,38.98 30.12,38.4 v1(30.24,38.27) ; v1(100.82,29.61) 100.9,29.69 100.9,30.41 100.81,30.51 CX13.2 CX8.2 ; v1(58.34,29.75) 58.27,29.81 JKB1.32 ; v1(219.55,38.79) 219.1,39.25 JEDP1.41 ; v1(171.04,41.26) 171.01,41.23 PBATT1.2 ; v1(175.89,67.34) 175.89,66.06 C58.2 ; RT101.1 20.28,116.57 v1(20.28,116.01) ; JTP1.9 113.53,27.45 112.77,26.69 111.39,26.69 v1(111.15,26.93) ; JTP1.5 121.05,30.99 121.94,31.89 v1(121.94,32.54) ; v1(159.34,150.59) 159.3,150.55 CV233.2 ; v1(158.54,114.81) CV335.2 157.62,115.74 CV219.2 ; CV164.2 160.7,115.06 v1(160.63,115) ; v1(167.52,41.12) 167.01,40.61 PBATT1.4 ; v1(37.92,129.26) 37.92,129.04 38.18,128.77 PCS06.2 38.18,127.71 PCS05.2 38.17,127.65 v1(38.67,127.15) ; PCB47.2 190.37,61.59 189.76,62.2 v1(189.76,62.51) ; JFP1.9 v1(217.05,27.3) ; JTP1.10 129.51,27.45 v1(130.07,28.01) ; v1(40.31,125.94) 39.44,126.81 PCS08.2 PCS07.2 ; v1(33.74,116.24) 34.15,116.64 RT32.2 ; v1(214.58,33.66) 214.67,33.75 JIOB1.17 ; CV173.2 v1(165.15,130.82) ; RC703.1 108.49,116.37 v1(108.88,115.99) ; v1(92.77,150.85) 92.36,151.26 PQ5.3 92.36,151.99 92.91,152.53 PC7.2 ; JKB1.31 v1(84.42,29.32) ; PQ20.3 93.48,142.22 v1(93.48,143.35) 93.48,143.99 PQ6.3 ; v1(118.25,116.02) 118.71,115.57 C25.2 ; CT6.2 v1(34.51,129.79) ; CT7.2 v1(33.56,129.78) ; v1(158.38,150.59) 158.28,150.48 CV235.2 ; v1(151.93,114.98) CV221.2 RV121.2 RV120.2 CV391.2 ; JODD1.25 v1(198.45,63.83) ; RP1.2 R6.2 209.44,56.13 209.12,56.45 208.39,56.45 v1(207.76,55.82) ; JODD1.13 191.2,63.87 191,63.67 v1(191,63.13) ; PR303.2 19.03,46.99 PR308.2 19.83,47.89 v1(19.78,47.94) ; v1(127.07,117.94) 127.07,118.22 127.27,118.42 RV151.1 ; v1(160.55,94.42) 160.42,94.55 PHA02.1 ; CV160.2 v1(165.77,125.78) ; JIOB1.10 204.2,37.1 203.08,38.22 v1(203.08,38.4) ; v1(127.53,112.91) 127.19,112.58 C31.1 ; PCZ05.1 v1(163.68,89.5) ; CL20.2 21.29,79.19 v1(21.31,79.18) ; CU3.2 v1(19.12,60.83) ; v1(25.97,90.97) 26.21,91.21 PR508.2 PC516.2 PR511.2 ; CC100.1 v1(112.02,117.55) ; v1(42.22,127.17) 41.62,127.77 PRS07.2 ; JHDD1.14 182.9,32.29 181.78,33.42 v1(181.78,33.65) ; v1(149.58,41.46) PC18.2 PC12.2 PC17.2 ; v1(134.9,35.35) 134.73,35.19 CC91.2 CC90.2 ; v1(87.79,147.71) 88.37,148.28 PJPDC1.8 ; JKBBL1.6 89.85,29.5 v1(89.67,29.32) ; CV157.2 164.89,137.9 v1(164.88,137.92) ; C34.2 C26.1 126.58,113.53 v1(126.88,113.23) ; CC686.2 v1(143.6,54.81) ; RT63.2 v1(34.77,112.71) ; v1(190.89,68.03) 191.2,67.72 JODD1.14 ; CV96.2 v1(150.94,117.33) ; CV54.2 CV55.2 114.74,113.97 114.23,114.47 v1(114.23,114.74) ; v1(96.57,142.95) PR17.2 PC10.2 ; v1(210.64,46.58) 210.18,46.12 PCB42.2 209.19,46.12 PCB39.2 ; JDIMM2.262 51.04,42.81 51.79,43.56 v1(51.79,45.02) ; CV170.2 v1(165.77,124.7) ; CV334.2 v1(159.62,114.81) ; C797.2 v1(143.79,49.98) ; JH1.4 UC7.4 129.56,36.38 128.8,37.14 128.8,37.14 128.75,37.19 v1(128.75,37.23) ; PHZ01.1 160.8,71.36 160.94,71.5 v1(161.55,71.5) ; CU1.2 v1(22.81,60.92) ; CU37.2 v1(223.25,31.2) ; v1(21.52,52.13) 21.19,51.8 CU9.2 ; PCZ46.2 v1(148.62,90.93) ; SW2.1 28.61,60.96 v1(28.23,60.57) ; RC51.2 119.21,38.54 119.2,38.55 v1(119.17,38.59) ; JFAN1.6 176.84,70.23 176.33,70.74 v1(176.33,71.78) ; v1(221.9,25.2) 222.15,25.44 JFP.7 JFP1.10 ; CU5.2 v1(17.19,49.82) ; v1(172.75,41.21) 173.01,40.95 PBATT1.1 ; v1(196.77,31.33) 196.8,31.35 196.8,32.07 195.37,33.5 JIOB1.18 ; CU6.2 v1(17.32,52.57) ; v1(117.99,113.62) 118.03,113.66 C27.2 C24.2 ; v1(209.6,39.2) 209.6,39.73 DX3.1 210.15,40.19 v1(211.31,41.36) ; C796.2 v1(143.72,47.29) ; v1(145.97,33.58) 145.97,33.56 146.48,33.05 PC11.2 146.64,33.03 PCB33.2 ; RT115.2 RT65.2 30.39,120.44 v1(29.82,120.44) ; RV135.2 v1(164.9,141.85) ; JCCG4_T.2 v1(42.83,119.13) ; QC27.3 143.44,32.75 144.05,33.36 RC801.2 144.45,35.02 143.34,36.13 v1(143.34,36.77) ; PR1805.2 v1(173.21,58.82) ; v1(97.63,38.16) 97.25,37.78 JKBBL1.5 ; v1(155.53,150.64) 155.56,150.61 RV55.2 CV395.2 155.62,149.03 RV132.2 ; v1(80.11,140.25) JWLAN1.76 ; v1(39.02,116.85) RT117.2 RT118.2 ; CC682.2 v1(143.72,52.12) ; JODD1.26 182.95,66.58 v1(183.73,67.36) ; R21.2 v1(82.97,38.13)
  vias: v1(0.54,82.76) v1(0.54,65.75) v1(1.45,115.74) v1(1.36,81.79) v1(1.55,66.51) v1(1.62,83.41) v1(1.65,65.14) v1(1.95,105.07) v1(2.72,115.74) v1(2.68,107.36) v1(2.81,83.87) v1(2.94,87.68) v1(2.94,86.41) v1(2.94,85.14) v1(3.9,81.79) v1(4.09,66.51) v1(4.19,65.12) v1(4.49,105.04) v1(4.94,64.09) v1(4.94,62.82) v1(4.94,61.55) v1(4.94,44.72) v1(4.94,43.45) v1(4.94,38.37) v1(5.24,133.66) v1(5.16,81.9) v1(5.22,65.93) v1(5.76,105.04) v1(5.79,85.8) v1(5.89,41.2) v1(6.33,65.31) v1(6.51,133.66) v1(6.85,87.63) v1(6.85,83.97) v1(6.95,43.03) v1(6.95,39.37) v1(7.03,105.04) v1(7.55,88.66) v1(7.57,65.59) v1(7.78,133.66) v1(7.84,81.9) v1(7.75,45.96) v1(7.86,60.34) v1(8.3,105.04) v1(8.44,66.51) v1(8.44,22.06) v1(8.56,36.44) v1(8.95,87.63) v1(8.95,83.97) v1(9.02,45.96) v1(9.05,133.66) v1(9.1,81.79) v1(9.13,60.34) v1(9.05,43.03) v1(9.05,39.37) v1(9.57,105.04) v1(9.71,66.51) v1(9.71,22.06) v1(9.83,36.44) v1(10.01,85.8) v1(10.09,88.66) v1(10.11,41.2) v1(10.32,133.66) v1(10.29,45.96) v1(10.4,60.34) v1(10.49,90.73) v1(10.69,103.41) v1(10.65,63.71) v1(10.79,104.68) v1(10.94,4.38) v1(10.94,3.11) v1(10.94,1.84) v1(10.94,0.57) v1(10.99,89.56) v1(10.98,22.06) v1(11.1,36.44) v1(11.59,133.66) v1(11.64,81.78) v1(11.56,45.96) v1(11.67,60.34) v1(12.2,0.44) v1(12.42,116.26) v1(12.44,80.79) v1(12.48,131.88) v1(12.48,131.25) v1(12.54,42.34) v1(12.54,41.36) v1(12.52,39.67) v1(12.52,39.04) v1(12.56,40.51) v1(12.76,107.23) v1(12.86,133.66) v1(13.47,0.44) v1(13.94,24.11) v1(14.13,133.66) v1(14.2,58.78) v1(14.28,47.43) v1(14.36,110.83) v1(14.43,35.44) v1(14.44,22.94) v1(14.74,43.73) v1(14.74,0.44) v1(14.88,118.98) v1(15.4,133.66) v1(15.4,44.32) v1(15.38,43.73) v1(15.38,43.1) v1(15.72,124.84) v1(16.04,45.59) v1(16.04,44.95) v1(16.04,44.32) v1(16.01,0.44) v1(16.15,123.17) v1(16.21,118.55) v1(16.67,133.66) v1(17.28,0.44) v1(17.94,133.66) v1(17.98,40.22) v1(18.07,34.6) v1(18.07,33.97) v1(18.07,33.33) v1(18.07,32.7) v1(18.55,0.44) v1(19.21,133.66) v1(19.56,122.66) v1(19.77,40.28) v1(19.82,0.44) v1(19.89,43.04) v1(19.97,130.46) v1(20.07,93.02) v1(20.23,94.88) v1(20.24,90.8) v1(20.16,88.95) v1(20.48,133.66) v1(20.98,131.26) v1(21.09,0.44) v1(21.46,51.19) v1(21.46,50.55) v1(21.75,133.66) v1(21.98,53.27) v1(21.98,52.57) v1(22.04,51.76) v1(22.35,84.04) v1(22.35,82.93) v1(22.35,81.81) v1(22.45,96.58) v1(22.36,0.44) v1(22.59,92.96) v1(22.63,91.16) v1(22.87,94.86) v1(23.02,133.66) v1(23.02,78.41) v1(23.47,84.04) v1(23.47,82.93) v1(23.47,81.81) v1(23.59,116.96) v1(23.59,116.38) v1(23.63,104.15) v1(23.63,0.44) v1(23.72,53.26) v1(23.72,52.56) v1(24.21,104.15) v1(24.18,103.54) v1(24.18,102.95) v1(24.15,39.57) v1(24.29,133.66) v1(24.32,79.03) v1(24.51,105.83) v1(24.58,84.04) v1(24.58,82.93) v1(24.58,81.81) v1(24.85,37.18) v1(24.9,0.44) v1(25.03,76.82) v1(25.03,76.23) v1(25.14,105.83) v1(25.09,88.64) v1(25.21,58.71) v1(25.31,56.87) v1(25.31,15.24) v1(25.31,13.27) v1(25.31,11.3) v1(25.47,60.56) v1(25.56,133.66) v1(25.56,97.17) v1(25.68,88.64) v1(25.78,105.83) v1(25.88,120.84) v1(25.98,39.57) v1(26.17,0.44) v1(26.32,37.28) v1(26.41,105.83) v1(26.46,122.51) v1(26.48,119.41) v1(26.83,133.66) v1(26.79,37.63) v1(26.96,125.98) v1(27.05,105.83) v1(27.15,124.13) v1(27.09,45.59) v1(27.28,15.24) v1(27.28,13.27) v1(27.28,11.3) v1(27.44,0.44) v1(27.68,105.83) v1(27.88,71.45) v1(27.97,62.92) v1(28.1,133.66) v1(28.44,95.91) v1(28.44,95.28) v1(28.44,94.64) v1(28.44,94.01) v1(28.38,52.19) v1(28.38,51.56) v1(28.61,50.92) v1(28.61,50.29) v1(28.74,37.63) v1(28.71,0.44) v1(29.02,96.55) v1(29.02,95.91) v1(29.02,95.28) v1(29.02,94.64) v1(29.02,94.01) v1(29.13,32.14) v1(29.24,15.24) v1(29.24,13.27) v1(29.24,11.3) v1(29.33,84.5) v1(29.37,133.66) v1(29.38,85.54) v1(29.38,82.69) v1(29.56,129.22) v1(29.6,96.55) v1(29.6,95.91) v1(29.6,95.28) v1(29.6,94.64) v1(29.6,94.01) v1(29.83,37.68) v1(29.82,31.68) v1(29.82,30.98) v1(30.04,97.77) v1(30.04,97.13) v1(29.98,0.44) v1(30.08,86.91) v1(30.23,96.56) v1(30.23,95.92) v1(30.23,95.29) v1(30.23,94.65) v1(30.23,94.02) v1(30.64,133.66) v1(30.81,97.73) v1(30.81,97.14) v1(30.81,96.56) v1(30.81,95.92) v1(30.81,95.29) v1(30.81,94.65) v1(30.86,38.3) v1(31.14,85.64) v1(31.25,0.44) v1(31.91,133.66) v1(31.97,37.07) v1(32.18,12.62) v1(32.52,0.44) v1(33.04,38.15) v1(33.18,133.66) v1(33.79,0.44) v1(34.2,60.45) v1(34.32,125.37) v1(34.32,123.3) v1(34.32,121.23) v1(34.39,93.85) v1(34.45,133.66) v1(34.45,97.98) v1(34.67,37.65) v1(34.91,39.49) v1(35.01,42.68) v1(35.09,102.61) v1(35.06,0.44) v1(35.4,35.56) v1(35.72,133.66) v1(35.66,2.82) v1(35.66,1.55) v1(35.77,11.91) v1(35.77,10.12) v1(35.86,38.06) v1(36.03,42.1) v1(36.22,28.81) v1(36.23,3.96) v1(36.39,125.37) v1(36.39,123.3) v1(36.39,121.23) v1(36.7,39.48) v1(36.85,29.43) v1(36.85,28.19) v1(36.99,133.66) v1(37.54,37.56) v1(37.47,28.81) v1(37.5,4.04) v1(37.63,50.48) v1(38.26,133.66) v1(38.41,25.33) v1(38.41,24.75) v1(38.46,125.37) v1(38.46,123.3) v1(38.46,121.23) v1(38.63,40.99) v1(38.77,4.04) v1(39.53,133.66) v1(39.68,23) v1(40.04,4.04) v1(40.27,23) v1(40.39,40.88) v1(40.8,133.69) v1(40.76,20.32) v1(40.76,19.05) v1(40.76,17.78) v1(40.76,16.51) v1(40.76,15.24) v1(40.76,13.97) v1(40.76,12.7) v1(40.76,11.43) v1(40.76,10.16) v1(40.76,8.89) v1(40.76,7.62) v1(40.76,6.35) v1(40.76,5.08) v1(40.85,26.74) v1(40.85,23) v1(40.96,21.57) v1(41.06,97.47) v1(41.44,23) v1(41.5,35.68) v1(41.59,33.71) v1(41.8,134.48) v1(41.94,140.82) v1(41.94,139.55) v1(41.94,138.28) v1(41.94,137.01) v1(41.94,135.74) v1(42.01,84.65) v1(42.02,23) v1(42.13,35.68) v1(42.16,29.55) v1(42.18,21.94) v1(42.6,23) v1(42.77,29.55) v1(43.09,141.36) v1(43.21,87.88) v1(43.23,86.1) v1(43.19,23) v1(43.45,21.94) v1(44.36,141.36) v1(44.41,22.76) v1(44.66,24.67) v1(45.25,24.67) v1(45.63,141.36) v1(45.67,22.94) v1(45.83,24.67) v1(45.88,84.65) v1(46.41,24.62) v1(46.59,28.53) v1(46.72,25.13) v1(46.9,141.36) v1(46.94,22.94) v1(48.17,141.36) v1(48.21,22.94) v1(48.43,32.55) v1(49.07,32.55) v1(49.44,141.36) v1(49.48,22.94) v1(49.7,32.55) v1(50.34,32.55) v1(50.71,141.36) v1(50.75,22.94) v1(50.97,32.55) v1(51.42,124.06) v1(51.42,123.48) v1(51.46,112.54) v1(51.61,32.55) v1(51.98,141.36) v1(52.02,22.94) v1(53.25,141.36) v1(53.29,22.94) v1(54.52,141.36) v1(54.56,22.94) v1(55.71,130.03) v1(55.79,141.36) v1(55.83,22.94) v1(56.35,130.03) v1(56.45,123.1) v1(56.98,130.03) v1(57.06,141.36) v1(57.1,22.94) v1(57.44,123.07) v1(58.03,139.77) v1(58.02,138.5) v1(58.33,141.36) v1(58.37,22.94) v1(59.6,141.36) v1(59.64,139.72) v1(59.64,138.46) v1(59.64,22.94) v1(60.61,59.75) v1(60.68,107.69) v1(60.8,103.75) v1(60.87,141.36) v1(60.92,97.02) v1(60.87,95.37) v1(60.91,44.42) v1(60.91,22.94) v1(61.02,89.72) v1(61.06,99.12) v1(61.38,92.58) v1(61.5,90.93) v1(61.63,108.96) v1(61.57,101.4) v1(61.57,83.75) v1(61.63,57.91) v1(61.88,107.75) v1(61.88,59.75) v1(62.01,103.75) v1(62.14,141.36) v1(62.11,97.06) v1(62.14,95.37) v1(62.14,89.53) v1(62.07,64.64) v1(62.18,22.94) v1(62.26,61.59) v1(62.33,50.1) v1(62.39,45.27) v1(62.54,92.58) v1(62.71,90.8) v1(62.71,83.75) v1(62.84,46.54) v1(62.96,99.06) v1(63.09,108.96) v1(63.09,105.91) v1(63.34,97.03) v1(63.34,64.64) v1(63.41,141.36) v1(63.53,61.59) v1(63.45,22.94) v1(63.69,40.34) v1(63.79,104.14) v1(63.92,101.47) v1(64,110.22) v1(64.04,83.75) v1(64.68,141.36) v1(64.72,22.94) v1(65.95,141.36) v1(65.99,22.94) v1(67.22,141.36) v1(67.26,22.94) v1(68.49,141.36) v1(68.53,22.94) v1(68.93,112.33) v1(69.73,116.44) v1(69.76,141.36) v1(69.8,22.94) v1(70.37,116.44) v1(70.96,141.78) v1(71.07,22.94) v1(71.39,146.78) v1(71.39,145.51) v1(71.39,144.24) v1(71.39,142.97) v1(72.23,64.57) v1(72.34,22.94) v1(72.65,131.16) v1(72.65,129.64) v1(72.65,128.11) v1(73,40.09) v1(73.21,150.46) v1(73.3,103.46) v1(73.34,92.75) v1(73.34,59.77) v1(73.38,148.65) v1(73.38,148.01) v1(73.41,89.67) v1(73.36,53.88) v1(73.5,64.57) v1(73.55,95.35) v1(73.61,22.94) v1(73.73,98.93) v1(73.69,61.59) v1(74.01,148.65) v1(74.01,148.01) v1(73.99,97.05) v1(74.14,101) v1(74.13,91.61) v1(74.18,131.16) v1(74.18,129.64) v1(74.18,128.11) v1(74.33,57.98) v1(74.48,150.46) v1(74.46,108.96) v1(74.53,47.4) v1(74.65,148.65) v1(74.65,148.01) v1(74.58,105.85) v1(74.84,95.37) v1(74.82,40.05) v1(74.9,107.69) v1(74.88,22.94) v1(75.03,61.65) v1(75.12,97.05) v1(75.12,88.55) v1(75.21,122.89) v1(75.28,148.65) v1(75.28,148.01) v1(75.26,92.58) v1(75.28,62.57) v1(75.44,103.37) v1(75.59,94.48) v1(75.7,131.16) v1(75.7,129.64) v1(75.7,128.11) v1(75.69,119.67) v1(75.68,116.15) v1(75.65,98.93) v1(75.75,150.46) v1(75.79,105.85) v1(75.92,148.65) v1(75.92,148.01) v1(76.04,109.02) v1(76.11,64.64) v1(76.15,22.94) v1(76.26,116.15) v1(76.35,97.03) v1(76.3,61.65) v1(76.38,92.59) v1(76.55,103.5) v1(76.84,116.15) v1(77.02,150.46) v1(77.17,121.43) v1(77.36,127.2) v1(77.42,22.94) v1(77.76,121.43) v1(78.29,150.46) v1(78.69,22.94) v1(79.56,150.46) v1(79.96,22.94) v1(80.68,138.87) v1(80.68,138.17) v1(80.68,137.54) v1(80.68,136.9) v1(80.7,133.41) v1(80.83,150.46) v1(81.15,84.24) v1(81.19,66.16) v1(81.23,22.94) v1(81.25,149.3) v1(81.25,148.61) v1(81.44,127.39) v1(81.94,149.28) v1(81.9,148.62) v1(82.03,127.39) v1(82.1,150.46) v1(82.46,116.14) v1(82.5,22.94) v1(82.7,149.65) v1(82.94,114.6) v1(83.37,150.46) v1(83.66,149.65) v1(83.77,22.94) v1(83.88,122.07) v1(84.46,139.09) v1(84.64,150.46) v1(84.64,127.24) v1(84.64,126.65) v1(84.68,149.65) v1(84.65,133.55) v1(84.65,132.79) v1(84.67,130.75) v1(84.67,129.99) v1(84.67,129.23) v1(85.04,22.94) v1(85.1,139.09) v1(85.28,130.75) v1(85.28,129.99) v1(85.28,129.23) v1(85.4,148.48) v1(85.73,139.09) v1(85.91,150.46) v1(85.89,130.75) v1(85.89,129.99) v1(85.89,129.23) v1(86.04,148.48) v1(86.31,22.94) v1(86.42,149.68) v1(86.5,130.75) v1(86.5,129.99) v1(86.5,129.23) v1(86.83,29.36) v1(87.11,130.75) v1(87.11,129.99) v1(87.11,129.23) v1(87.18,150.46) v1(87.58,22.94) v1(87.71,130.75) v1(87.71,129.99) v1(87.71,129.23) v1(88.32,130.75) v1(88.32,129.99) v1(88.32,129.23) v1(88.39,150.86) v1(88.9,152.02) v1(88.93,130.75) v1(88.93,129.99) v1(88.93,129.23) v1(88.85,22.94) v1(89.19,153.26) v1(89.43,124.53) v1(89.48,132.58) v1(89.54,130.75) v1(89.54,129.99) v1(89.54,129.23) v1(89.47,127.22) v1(89.76,136.03) v1(89.98,122.23) v1(90.12,22.94) v1(90.24,153.96) v1(90.15,130.75) v1(90.15,129.99) v1(90.15,129.23) v1(90.56,136.77) v1(90.76,130.75) v1(90.76,129.99) v1(90.76,129.23) v1(91.14,136.77) v1(91.37,130.75) v1(91.37,129.99) v1(91.37,129.23) v1(91.39,123.67) v1(91.39,22.94) v1(91.51,153.96) v1(91.73,136.77) v1(91.98,130.75) v1(91.98,129.99) v1(91.98,129.23) v1(92.02,123.67) v1(92.31,136.77) v1(92.59,130.75) v1(92.59,129.99) v1(92.59,129.23) v1(92.66,22.94) v1(92.78,153.96) v1(93.2,130.75) v1(93.2,129.99) v1(93.93,22.94) v1(95.2,22.94) v1(96.47,22.94) v1(97.62,127.67) v1(97.57,125.92) v1(97.74,22.94) v1(97.86,126.84) v1(99.01,22.94) v1(100.28,22.94) v1(100.43,143.31) v1(101.25,36.05) v1(101.25,34.52) v1(101.49,23.31) v1(102.29,119.88) v1(102.29,119.25) v1(102.63,23.89) v1(102.73,144.84) v1(102.78,37.57) v1(102.78,36.05) v1(102.78,34.52) v1(102.93,119.88) v1(102.93,119.25) v1(103.56,119.88) v1(103.56,119.25) v1(103.9,23.89) v1(104.2,119.88) v1(104.2,119.25) v1(104.3,37.57) v1(104.3,36.05) v1(104.3,34.52) v1(105,142.49) v1(105.17,23.89) v1(105.92,88.33) v1(106.31,49.93) v1(106.44,23.89) v1(106.49,153.96) v1(106.71,87.48) v1(107.35,50.34) v1(107.55,86.63) v1(107.63,60.05) v1(107.71,23.89) v1(107.76,153.96) v1(107.95,58.38) v1(107.92,46.85) v1(108.12,149.4) v1(108.3,54.73) v1(108.58,86.29) v1(108.57,50.21) v1(108.7,47.79) v1(108.81,59.98) v1(109.03,153.96) v1(108.98,23.89) v1(109.13,58.38) v1(109.3,50.83) v1(109.36,55.21) v1(109.5,48.64) v1(110,149.51) v1(110.05,60.05) v1(110.25,23.89) v1(110.3,153.96) v1(110.39,58.3) v1(110.54,55.2) v1(110.89,149.55) v1(111.25,60.05) v1(111.52,23.89) v1(111.57,153.96) v1(111.56,58.22) v1(111.7,55.16) v1(112.38,46.4) v1(112.75,149.6) v1(112.84,153.96) v1(112.8,53.16) v1(112.79,23.89) v1(113.97,52.92) v1(114.06,23.89) v1(114.18,46.81) v1(114.48,155.01) v1(114.97,47.66) v1(115.17,149.33) v1(115.17,53.04) v1(115.33,23.89) v1(115.39,147.9) v1(115.75,155.06) v1(116.11,44.95) v1(116.6,23.89) v1(116.68,149) v1(117.02,155.06) v1(117.08,147.33) v1(117.57,122.5) v1(117.73,148.91) v1(117.87,23.89) v1(118.09,122.23) v1(118.18,129.77) v1(118.29,155.06) v1(118.28,147.14) v1(119.14,23.89) v1(119.21,146.58) v1(119.51,119.22) v1(119.56,155.06) v1(119.71,147.91) v1(120.41,23.89) v1(121.48,38.29) v1(121.68,23.89) v1(122.04,63.86) v1(122.84,114.1) v1(122.95,23.89) v1(124.22,23.89) v1(125.31,32.15) v1(125.49,23.89) v1(126.76,23.89) v1(127.44,106.08) v1(128.03,23.89) v1(129.3,23.89) v1(129.72,155.06) v1(130.59,82.91) v1(130.57,23.89) v1(130.78,80.84) v1(130.89,154.56) v1(131.26,69.77) v1(131.84,23.89) v1(132.01,67.81) v1(132.16,154.56) v1(132.75,76.83) v1(132.83,67.78) v1(133.11,23.89) v1(133.43,154.56) v1(133.5,69.82) v1(134.19,51.96) v1(134.38,23.89) v1(134.53,50.26) v1(134.7,154.56) v1(135.09,107.08) v1(135.65,23.89) v1(135.97,154.56) v1(136.11,89.15) v1(136.22,85.18) v1(136.92,23.89) v1(137.24,154.56) v1(137.41,62.26) v1(137.71,127.15) v1(137.89,89.15) v1(138.12,72.58) v1(138.27,131) v1(138.31,83.28) v1(138.44,154.97) v1(138.64,65.35) v1(138.74,63.47) v1(139.04,89.21) v1(139.42,71.17) v1(139.44,27.1) v1(139.6,72.23) v1(139.71,155.06) v1(139.81,73.97) v1(139.87,75.07) v1(140.08,67.47) v1(140.5,28.93) v1(140.5,25.27) v1(140.78,70.84) v1(140.86,107.46) v1(140.86,106.88) v1(140.98,155.06) v1(141.39,104.14) v1(141.5,107.46) v1(141.5,106.88) v1(141.69,69.02) v1(142.08,107.46) v1(142.08,106.88) v1(142.25,155.06) v1(142.29,68.63) v1(142.6,28.93) v1(142.6,25.27) v1(142.67,107.46) v1(142.67,106.88) v1(142.67,37.94) v1(142.78,101.48) v1(142.82,39.77) v1(142.96,93.1) v1(142.96,92.46) v1(143.25,107.46) v1(143.25,106.88) v1(143.33,77.97) v1(143.52,155.06) v1(143.65,101.72) v1(143.65,101.09) v1(143.65,100.45) v1(143.65,99.82) v1(143.65,99.18) v1(143.65,98.55) v1(143.59,93.1) v1(143.59,92.46) v1(143.66,27.1) v1(144.1,75.69) v1(144.48,78.01) v1(144.74,79.41) v1(144.79,155.06) v1(145.45,88.6) v1(145.4,86.83) v1(145.44,85.07) v1(145.7,83.31) v1(145.7,81.47) v1(145.66,78.05) v1(145.81,23.89) v1(146.06,155.06) v1(146.75,150.65) v1(147.08,23.89) v1(147.23,45.91) v1(147.33,155.06) v1(147.6,150.65) v1(147.89,72.51) v1(147.94,57.91) v1(147.99,45.91) v1(147.99,45.14) v1(148.29,73.81) v1(148.35,23.89) v1(148.43,75.04) v1(148.6,155.06) v1(148.74,77.57) v1(148.85,76.28) v1(149.01,109.01) v1(149.62,23.89) v1(149.87,155.06) v1(150.05,54.43) v1(150.4,70.86) v1(150.4,70.23) v1(150.4,69.59) v1(150.4,68.96) v1(150.89,23.89) v1(151.14,155.06) v1(152.16,23.89) v1(152.41,155.06) v1(152.57,103.04) v1(152.57,102.41) v1(152.57,101.77) v1(152.75,112.81) v1(153.05,88.86) v1(153.05,87.33) v1(153.05,85.81) v1(153.21,103.04) v1(153.21,102.41) v1(153.21,101.77) v1(153.39,112.81) v1(153.43,23.89) v1(153.45,82.89) v1(153.68,155.06) v1(153.84,103.04) v1(153.84,102.41) v1(153.84,101.77) v1(153.77,48.89) v1(154.28,48.38) v1(154.57,88.86) v1(154.57,87.33) v1(154.57,85.81) v1(154.72,47.94) v1(154.7,23.89) v1(154.95,155.06) v1(155.04,43.11) v1(155.04,42.48) v1(155.16,107.81) v1(155.16,107.17) v1(155.8,107.81) v1(155.8,107.17) v1(155.97,23.89) v1(156.09,88.86) v1(156.09,87.33) v1(156.09,85.81) v1(156.22,155.06) v1(156.23,32.72) v1(156.43,150.6) v1(156.47,83.35) v1(156.65,102.04) v1(156.65,101.43) v1(156.87,32.72) v1(157.24,23.89) v1(157.3,74.96) v1(157.3,74.35) v1(157.3,73.69) v1(157.49,155.03) v1(157.64,71.05) v1(157.64,70.46) v1(157.64,69.86) v1(157.64,67.7) v1(157.64,67.11) v1(157.92,103.87) v1(157.87,103.26) v1(157.87,102.65) v1(157.93,74.96) v1(157.93,74.35) v1(157.93,73.69) v1(158.23,73.03) v1(158.23,72.37) v1(158.23,71.71) v1(158.23,71.05) v1(158.23,70.46) v1(158.23,67.85) v1(158.23,67.19) v1(158.34,99.06) v1(158.3,69.79) v1(158.3,69.07) v1(158.3,68.46) v1(158.53,103.21) v1(158.53,102.6) v1(158.54,74.96) v1(158.54,74.35) v1(158.54,73.69) v1(158.51,23.89) v1(158.58,103.82) v1(158.57,84.08) v1(158.66,154.56) v1(158.72,47.62) v1(158.72,46.99) v1(158.72,46.35) v1(158.72,45.72) v1(158.72,45.08) v1(158.72,44.45) v1(158.72,43.81) v1(158.72,43.18) v1(158.83,73.03) v1(158.83,72.37) v1(158.83,71.71) v1(158.83,71.05) v1(158.83,70.46) v1(158.83,67.85) v1(158.83,67.19) v1(158.83,66.58) v1(158.83,65.97) v1(158.83,65.36) v1(158.83,64.75) v1(158.83,64.14) v1(158.83,63.53) v1(158.83,62.92) v1(158.91,69.79) v1(158.91,69.07) v1(158.91,68.46) v1(159.13,74.96) v1(159.13,74.35) v1(159.13,73.69) v1(159.24,103.21) v1(159.24,102.6) v1(159.15,52.79) v1(159.15,52.15) v1(159.15,51.52) v1(159.15,50.88) v1(159.29,103.82) v1(159.44,73.03) v1(159.44,72.37) v1(159.44,71.71) v1(159.44,71.05) v1(159.44,70.46) v1(159.44,67.85) v1(159.44,67.19) v1(159.44,66.58) v1(159.44,65.97) v1(159.44,65.36) v1(159.44,64.75) v1(159.52,69.79) v1(159.52,69.07) v1(159.52,68.46) v1(159.5,64.09) v1(159.5,63.33) v1(159.5,62.72) v1(159.71,74.96) v1(159.71,74.35) v1(159.71,73.69) v1(159.78,23.89) v1(159.93,154.56) v1(160,103.21) v1(160,102.6) v1(160.04,63.83) v1(160.05,103.82) v1(160.05,86.89) v1(160.05,67.85) v1(160.05,67.19) v1(160.05,66.58) v1(160.61,31.4) v1(160.71,103.21) v1(160.71,102.6) v1(160.77,103.82) v1(160.8,49.64) v1(160.8,49) v1(160.8,48.37) v1(160.94,38.46) v1(161.02,63.33) v1(161.02,62.67) v1(161.05,23.89) v1(161.2,154.56) v1(161.43,103.82) v1(161.37,103.21) v1(161.37,102.6) v1(161.44,49.64) v1(161.44,49) v1(161.44,48.37) v1(161.96,53.48) v1(162.05,31.54) v1(162.09,70.95) v1(162.09,70.24) v1(162.07,49.64) v1(162.07,49) v1(162.07,48.37) v1(162.28,93.95) v1(162.32,23.89) v1(162.47,154.56) v1(162.58,51.11) v1(162.62,47.86) v1(163.14,47.19) v1(163.14,46.55) v1(163.14,45.92) v1(163.2,53.48) v1(163.22,51.11) v1(163.25,47.86) v1(163.59,23.89) v1(163.74,154.56) v1(164.4,53.46) v1(164.47,96.3) v1(164.58,100.77) v1(164.86,23.89) v1(165.01,154.56) v1(165.24,100.77) v1(165.45,86.61) v1(165.45,85.97) v1(165.6,53.49) v1(165.63,50.26) v1(165.79,100.21) v1(165.94,109.5) v1(166.09,87.24) v1(166.09,85.97) v1(166.13,23.89) v1(166.28,154.56) v1(166.45,100.21) v1(166.9,53.46) v1(167.04,153.79) v1(167.4,23.89) v1(167.49,112.19) v1(167.49,106.81) v1(167.72,64.8) v1(167.71,63.22) v1(168.06,152.52) v1(168.33,64.8) v1(168.32,63.22) v1(168.3,38.37) v1(168.56,37.84) v1(168.67,23.89) v1(169.01,41.3) v1(168.99,38.35) v1(169.06,151.95) v1(169.06,150.68) v1(169.06,149.41) v1(169.06,148.14) v1(169.06,146.87) v1(169.06,145.6) v1(169.06,144.33) v1(169.06,143.06) v1(169.06,141.79) v1(169.09,140.52) v1(169.11,70.79) v1(169.11,70.12) v1(169.11,69.46) v1(169.11,68.75) v1(169.17,139.25) v1(169.25,137.98) v1(169.33,136.71) v1(169.41,135.45) v1(169.49,134.18) v1(169.57,132.91) v1(169.63,58.49) v1(169.63,57.86) v1(169.57,41.54) v1(169.65,131.64) v1(169.73,130.38) v1(169.81,129.11) v1(169.89,127.84) v1(169.94,23.89) v1(169.97,126.57) v1(170.03,41.16) v1(170.05,125.31) v1(170.14,124.04) v1(170.22,122.77) v1(170.3,121.5) v1(170.26,58.49) v1(170.26,57.86) v1(170.38,120.24) v1(170.46,118.97) v1(170.54,117.7) v1(170.62,116.44) v1(170.7,115.17) v1(170.9,58.49) v1(170.9,57.86) v1(171.21,23.89) v1(171.43,103.76) v1(171.51,102.49) v1(171.59,101.23) v1(171.67,99.96) v1(171.75,98.69) v1(171.83,97.42) v1(171.91,96.16) v1(171.99,94.89) v1(172.07,93.62) v1(172.15,92.35) v1(172.24,91.09) v1(172.38,89.82) v1(172.48,23.89) v1(172.59,88.57) v1(172.75,50.35) v1(172.88,87.34) v1(173.25,86.12) v1(173.2,49.97) v1(173.68,84.93) v1(173.75,23.89) v1(174.19,83.76) v1(174.76,82.63) v1(175.02,23.89) v1(175.28,45.44) v1(175.4,81.53) v1(175.84,58.65) v1(175.84,57.48) v1(176.1,80.47) v1(176.18,45.33) v1(176.29,23.89) v1(176.56,45.78) v1(176.85,58.07) v1(176.86,79.46) v1(177.56,23.89) v1(177.68,78.49) v1(177.76,55.71) v1(177.85,58.65) v1(177.85,57.48) v1(178.56,77.57) v1(178.83,23.89) v1(178.93,33.64) v1(178.96,55.93) v1(179.33,43.63) v1(179.33,43) v1(179.49,76.71) v1(179.46,55.48) v1(179.98,39.98) v1(180.1,23.89) v1(180.47,75.9) v1(180.62,65.73) v1(180.56,39.98) v1(181.06,55.95) v1(181.37,23.89) v1(181.5,75.15) v1(181.64,55.95) v1(181.71,27.65) v1(181.71,26.38) v1(181.71,25.11) v1(181.77,49.14) v1(181.77,48.51) v1(181.9,28.91) v1(182.36,49.14) v1(182.36,48.51) v1(182.57,74.47) v1(183.04,49.14) v1(183.04,48.51) v1(183.11,29.29) v1(183.68,73.85) v1(183.74,48.51) v1(183.8,34.48) v1(183.8,32.82) v1(184.38,29.29) v1(184.63,33.65) v1(184.72,73.12) v1(185.52,72.13) v1(185.45,34.48) v1(185.45,32.82) v1(185.65,29.29) v1(186.52,71.35) v1(186.92,29.29) v1(187.61,39.11) v1(187.67,70.81) v1(187.79,68.65) v1(188.25,39.11) v1(188.19,29.29) v1(188.73,68.16) v1(188.82,70.27) v1(189.46,29.29) v1(189.97,69.74) v1(190.73,29.29) v1(190.98,54.1) v1(191.12,69.2) v1(192,29.29) v1(192.29,68.7) v1(192.69,43.05) v1(193.27,29.29) v1(193.55,68.88) v1(194.39,47.18) v1(194.39,46.55) v1(194.39,45.91) v1(194.54,29.29) v1(194.81,69) v1(194.84,45.34) v1(195.03,46.55) v1(195.03,45.91) v1(195.22,44.83) v1(195.66,47.18) v1(195.66,46.55) v1(195.66,45.91) v1(195.81,29.29) v1(196.06,68.77) v1(196.07,45.32) v1(196.3,47.18) v1(196.3,46.55) v1(196.3,45.91) v1(196.39,44.81) v1(196.71,45.32) v1(196.95,60.56) v1(196.95,59.92) v1(197.02,44.81) v1(197.08,29.29) v1(197.29,68.46) v1(197.34,45.32) v1(197.34,44.3) v1(197.58,60.56) v1(197.66,44.81) v1(197.98,44.3) v1(198.22,60.56) v1(198.35,29.29) v1(198.53,68.2) v1(198.61,38.39) v1(199.62,29.29) v1(199.78,67.97) v1(199.75,30.54) v1(200.04,38.73) v1(200.89,29.29) v1(201.04,67.79) v1(201.52,56.24) v1(201.52,55.6) v1(201.52,54.97) v1(201.52,54.33) v1(202.16,29.29) v1(203.45,47.01) v1(203.43,29.29) v1(204.57,45.89) v1(204.7,29.29) v1(205.34,63.85) v1(205.97,29.29) v1(206.4,65.68) v1(206.4,62.02) v1(206.7,35.75) v1(207.24,29.29) v1(207.58,32.43) v1(208.5,65.68) v1(208.5,62.02) v1(208.51,29.29) v1(209.16,50.68) v1(209.39,32.95) v1(209.56,63.85) v1(209.78,29.29) v1(211.05,29.29) v1(212.32,29.29) v1(213.47,51.24) v1(213.47,50.66) v1(213.46,28.73) v1(213.54,27.46) v1(213.54,26.19) v1(213.54,24.92) v1(214.05,51.24) v1(214.05,50.66) v1(214.28,23.89) v1(215.55,23.89) v1(216.15,68.8) v1(216.82,23.89) v1(217.14,54.67) v1(217.14,52.83) v1(217.41,68.96) v1(217.94,57.13) v1(217.97,55.94) v1(218.09,23.89) v1(218.4,54.43) v1(218.68,68.96) v1(219.36,23.89) v1(219.95,68.96) v1(220.63,23.89) v1(220.95,58.63) v1(220.95,57.06) v1(221.22,68.96) v1(221.9,23.89) v1(222.49,68.96) v1(223.17,23.89) v1(223.76,68.96) v1(224.44,23.89) v1(225.03,68.96) v1(225,47.9) v1(224.96,46.63) v1(224.96,45.36) v1(224.96,44.09) v1(224.96,42.82) v1(224.96,41.55) v1(224.96,40.28) v1(224.96,39.01) v1(224.96,37.74) v1(224.96,36.47) v1(224.96,35.2) v1(224.96,33.93) v1(224.96,32.66) v1(224.96,31.39) v1(224.96,30.12) v1(224.96,28.85) v1(224.96,27.58) v1(224.96,25.04) v1(225.3,49.14) v1(225.86,50.27) v1(226.3,68.96) v1(226.52,51.36) v1(227.17,52.45) v1(227.55,68.74) v1(227.73,53.59) v1(227.96,67.54) v1(227.96,66.27) v1(227.96,65) v1(227.96,63.73) v1(227.96,62.46) v1(227.96,61.19) v1(227.96,59.92) v1(227.96,58.65) v1(227.96,57.38) v1(227.96,56.11) v1(227.96,54.84) v4(27.59,105.02) v4(29.18,50.35) v4(29.31,105.28) v4(36.29,34.54) v4(37.94,124.26) v4(82.65,131.12) v4(84.26,91.59) v4(87.28,107.12) v4(97.25,45.14) v4(103.86,54.92) v4(144.5,150.3) v4(149.7,72.39) v4(149.7,50.54) v4(150.15,46.22) v4(153.26,105.02) v4(153.51,104.96) v4(155.32,88.13) v4(156.41,107.41) v4(160.37,52.07) v4(162.59,103.82) v4(166.4,102.42) v4(171.87,57.84) v4(179.99,38.86) v4(196.92,46.57) v4(202.35,57.4)
