# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_ATX_DRX_P1: length 128
  TOP w0.112: CS18.1 187.91,63.59 187.91,63.28 188.02,63.17 188.57,63.17 188.68,63.05 188.68,61.25 189.47,60.47 189.47,59.39 192.61,56.25 192.61,53.87 197,49.48 197,46.33 199.3,44.03 199.3,40.83 197.91,39.44 197.91,38.27 v1(197.59,37.96)
  IN3 w0.135: v1(143.3,75.78) 143.32,75.78 143.62,76.08 143.93,76.08 143.94,76.08 144.48,76.08 145.94,74.63 145.94,72.78 148.94,69.78 148.94,63.51 149.16,63.29 149.16,62.97 149.7,62.43 149.7,59.01 151.81,56.9 151.81,50.83 152.03,50.61 152.03,49.34 151.29,48.6 151.29,43.2 152.38,42.11 152.38,41.91 152.84,41.45 163.16,41.45 164.12,40.5 165.38,40.5 166.38,39.49 172.69,39.49 173.68,38.5 175.98,38.5 176.66,39.17 180.95,39.17 181.28,39.51 188.98,39.51 189.07,39.42 196.96,39.42 197.89,38.49 197.89,38.27 197.59,37.97 v1(197.59,37.96)
  BOTTOM w0.102: UC1.U2 136.31,74.81 136.32,74.81 136.34,74.79 137.55,74.79 138.12,75.36 138.12,75.92 138.78,76.58 139.85,76.58 140.33,76.11 142.97,76.11 143.08,76 143.08,75.88 143.18,75.78 v1(143.3,75.78)
SATA_ATX_RD_DRX_N0: length 2.1
  TOP w0.112: CS8.1 188.17,33.35 187.84,33.68 187.69,33.68 187.21,34.15 US1.14
SATA_ATX_RD_DRX_P0: length 2
  TOP w0.112: US1.15 186.99,34.65 187.23,34.41 187.32,34.41 187.8,33.94 187.96,33.94 CS7.1
SATA_LED#_R: length 34.1
  TOP w0.089: RE39.1 R36.1 31.92,72.59 v1(31.66,72.32) ; Q17.2 v3(43.34,94.56) 42.44,94.56 41.64,93.76 v1(40.4,93.76)
  IN2 w0.089: v1(31.66,72.32) 31.66,72.43 32.75,73.52 35.06,73.52 36.2,74.66 36.2,78.29 37.53,79.62 37.53,79.74 36.36,80.91 36.36,81.71 36.93,82.28 36.93,84.47 36.16,85.25 36.16,88.52 37.21,89.57 37.21,90.08 40.58,93.45 40.58,93.58 v1(40.4,93.76)
SATA_ODD_PRSNT#: length 349.3
  TOP w0.089: v1(42.53,77.03) 42.53,77.04 42.17,77.4 41.24,77.4 40.23,78.41 39.02,78.41 37.32,80.1 36.64,80.1 36.54,80.21 UE1.101
  TOP w0.099: RC6122.2 131.1,49.42 133.07,51.39 133.07,52.87 134.03,53.83 134.03,54.81 132.68,56.16 v1(132.68,56.17)
  TOP w0.254: v1(191.75,67.93) 191.14,67.32 191.14,65.2 191.32,65.02 191.32,64.59 191.68,64.23 191.68,63.2 v1(191.65,63.17)
  IN2 w0.089: v1(136.34,110.97) 139.48,110.97 141.51,108.95 143.69,108.95 145.31,107.32 153.13,107.32 153.66,106.8 164.47,106.8 164.6,106.66 164.99,106.66 165.68,106.66 169.49,102.85 169.49,98.38 170.52,97.35 170.52,96.18 170.52,88 170.96,87.56 171.01,87.51 171.01,72.8 172.05,71.76 172.05,70.54 178.79,63.8 186.67,63.8 186.86,63.61 191.18,63.61 191.62,63.17 v1(191.65,63.17) ; v1(150.49,63.61) 149.8,64.3 145.17,64.3 144.73,63.86 142.96,63.86 142.74,63.65 142.74,63.51 142.22,63 141.47,63 140.9,63.57 139.63,63.57 138.96,62.9 136.56,62.9 135.37,61.71 133.79,61.71 133.25,61.17 133.25,61.04 132.64,60.43 131.75,60.43 131.23,59.9 131.23,59.43 131.3,59.36 131.3,58.01 132.14,57.18 132.14,56.71 v1(132.68,56.17) 132.88,55.98 132.88,55.17 135.71,52.33 135.71,51.61 135.91,51.41 135.91,49.27 136.43,48.76 136.43,48.19 136.24,47.99 136.24,43.91 134.45,42.13 133.65,40.2 129.52,36.07 128.35,36.07 125.41,33.14 124.84,33.14 123.63,31.92 116.12,31.92 115.64,31.44 109.38,31.44 108.83,30.89 104.16,30.89 103.25,31.8 102.15,31.8 102.1,31.75 97.18,31.75 97.1,31.83 80.39,31.83 80,32.22 67.95,32.22 67.7,32.47 63,32.47 61.6,33.87 61.6,34.1 61.06,34.65 59.63,34.65 53.28,40.99 52.15,40.99 50.04,43.11 50.04,45.45 47.53,47.95 47.53,51.67 45.49,53.71 45.49,54.76 44.54,55.71 44.54,56.77 42.82,58.5 42.82,58.77 40.82,60.78 40.82,62.41 42.16,63.75 42.16,65.08 42.71,65.63 42.71,67.42 42.19,67.95 42.19,69.4 42.57,69.78 42.57,71.78 42.78,72 42.78,72.31 42.48,72.61 42.48,76.98 v1(42.53,77.03)
  IN3 w0.089: v1(150.49,63.61) 149.89,64.21 149.89,77.79 149,78.68 147.26,78.68 145.55,80.4 145.14,80.4 143.04,82.49 143.04,85.56 141.15,87.45 141.15,102.34 136.11,107.38 136.11,110.74 v1(136.34,110.97)
  BOTTOM w0.1: v1(132.68,56.17) 132.67,56.17 UC1.AW8
  BOTTOM w0.254: v1(191.75,67.93) 192.2,67.48 JODD1.16 ; JODD1.15 192.2,63.78 191.65,63.23 v1(191.65,63.17)
SATA_RX_N0: length 23.4
  TOP w0.089: CS17.1 191.7,31.92 191.9,31.92 193.13,33.16 193.55,33.16 193.7,33.3 193.7,33.42 v1(193.36,33.76) ; v1(176.67,33.02) 176.93,32.77 177.1,32.77 177.38,33.04 RS27.2
  IN1 w0.089: v1(193.36,33.76) 193.72,33.4 193.72,33.2 193.5,32.98 188.6,32.98 187.9,32.29 179.77,32.29 179.52,32.03 178.37,32.03 177.74,32.66 177.03,32.66 v1(176.67,33.02)
SATA_RX_P0: length 23.5
  TOP w0.089: v1(193.94,33.76) 193.94,33.2 193.65,32.91 193.23,32.91 192,31.68 191.56,31.68 CS16.1 ; RS26.2 177.17,32.53 176.76,32.53 v1(176.67,32.44)
  IN1 w0.089: v1(176.67,32.44) 177.64,32.44 178.27,31.81 179.61,31.81 179.87,32.06 187.99,32.06 188.69,32.76 193.59,32.76 193.94,33.11 v1(193.94,33.76)
SATA_TX_N0: length 23.3
  TOP w0.089: RS25.2 177.06,34.48 176.62,34.48 176.54,34.57 v2(176.11,34.57) 175.3,34.57 v1(175.11,34.37) ; v1(192.1,33.7) 192.01,33.79 191.88,33.79 191.79,33.7 191.66,33.7 191.31,33.35 CS15.1
  IN1 w0.089: v1(192.1,33.7) 191.91,33.9 191.02,33.9 190.12,34.79 189.45,34.79 187.86,33.2 185.23,33.2 185.06,33.03 184.26,33.03 184.07,33.22 183.54,33.22 183.26,32.94 181.36,32.94 180.06,34.24 180.06,34.32 179.17,35.21 178.64,35.21 177.97,34.54 175.28,34.54 v1(175.11,34.37)
SATA_TX_P0: length 23.3
  TOP w0.089: v1(192.1,34.28) 191.71,33.89 191.58,33.89 CS11.1 ; v1(175.11,34.95) 175.3,34.76 175.62,34.76 175.65,34.78 176.45,34.78 176.48,34.76 176.61,34.76 176.7,34.67 177.06,34.67 RS22.2
  IN1 w0.089: v1(192.1,34.28) 191.91,34.09 191.1,34.09 190.2,34.98 189.38,34.98 187.78,33.39 185.15,33.39 184.98,33.22 184.34,33.22 184.15,33.41 183.46,33.41 183.18,33.13 183.14,33.16 181.45,33.16 180.29,34.33 180.29,34.41 179.27,35.43 178.55,35.43 177.88,34.76 175.3,34.76 v1(175.11,34.95)
SERIRQ: length 144.5
  TOP w0.099: v1(129.05,50.27) 129.38,49.94 T108.1
  TOP w0.112: UE1.3 38.15,68.52 38.11,68.57 38.11,70.05 37.93,70.23 v1(37.87,70.23)
  IN3 w0.135: v1(128.06,40.04) 128.37,39.74 128.37,38.16 126.13,35.92 121.58,35.92 119.64,33.99 116.57,33.99 116.08,33.5 107.93,33.5 107.52,33.08 105.23,33.08 v1(105.01,33.3) 104.81,33.5 103.92,33.5 103.29,34.12 97.16,34.12 96.8,34.49 67.21,34.49 64.28,37.42 62.61,37.42 62.17,37.86 61.43,37.86 56.05,43.24 42.75,43.24 38.13,47.86 38.13,57.52 36.35,59.3 36.35,67.4 37.2,68.25 37.2,68.33 37.54,68.67 37.54,69.46 37.7,69.62 37.7,70.06 v1(37.87,70.23)
  BOTTOM w0.089: v1(129.05,50.27) 129.05,49.7 127.86,48.51
  BOTTOM w0.1: UC1.BC12 128.75,54.38 128.75,51.69 128.79,51.66 128.79,50.54 v1(129.05,50.27)
  BOTTOM w0.112: v1(105.01,33.3) 105.01,32.79 104.54,32.32 RX35.1 ; 127.86,48.51 127.42,48.07 127.42,43.96 126.84,43.38 126.84,41.75 128.06,40.54 v1(128.06,40.04)
SKU_ID: length 14
  TOP w0.099: RC42.2 131.54,46.87 131.54,48.4 RC41.1 131.69,49.13 131.69,49.74 133.27,51.31 133.27,52.78 134.23,53.75 134.23,55.26 v3(133.78,55.7) 133.4,56.09 133.4,56.85 133.55,57.01 v1(133.55,57.73)
  BOTTOM w0.089: UC1.AU6 133.93,58.16 133.55,57.78 v1(133.55,57.73)
SLEEVE:
  vias: v1(16.66,15.94) v1(16.66,15.24) v1(27.59,18.09) v1(27.59,17.46) v3(15.85,15.63)
SLEEVE_R: length 18.1
  IN1 w1.016: 15.08,11.62 15.08,14.79 15.53,15.24 15.53,16.89 13.81,18.6 6.19,18.6 4.99,17.4 JHP1.3
  vias: v1(15.46,10.6) v1(15.46,9.96) v1(15.97,12.7) v1(16.67,12.7) v3(15.97,12)
SMU_ZVDDP: length 10.6
  TOP w0.089: v1(144.15,73.07) 144.36,73.27 RC13.1
  BOTTOM w0.102: v1(144.15,73.07) 144.15,73.2 v3(143.28,74.07) 140.23,74.07 139.96,74.34 137.94,74.34 137.81,74.21 136.85,74.21 136.63,73.99 136.43,73.99 136.33,74.1 136.01,74.1 135.72,73.81 UC1.V4
SNUB1_CHG: length 1.2
  TOP w0.089: PCB36.1 v3(186.04,51.51)
SNUB2_CHG: length 1
  TOP w0.089: PCB37.1 v3(188.48,43.4)
SNUB_+1.35VGPU: length 0.4
  TOP w0.089: 150.91,111.37 v3(151.29,111.37)
SNUB_+VDDP:
  vias: v3(159.29,42.71)
SPI_IRQ#: length 41.1
  TOP w0.089: RX16.2 105.93,38.27 v3(106.8,39.15) v1(107.7,40.05)
  IN1 w0.089: v1(132.69,52.31) 132.62,52.31 131.77,51.47 131.61,51.47 130.78,50.65 128.9,50.65 128.33,50.07 126.53,50.07 126.2,50.41 125.53,50.41 125.45,50.32 125.45,49.3 124.42,48.27 ; 121.72,43.54 121.72,42.98 120.65,41.92 120.5,41.76 118.07,41.76 117.77,41.47 116.49,41.47 114.55,43.41 110.86,43.41 108.12,40.67 108.12,40.46 v1(107.7,40.05)
  IN1 w0.099: 124.42,48.27 123.45,47.3 123.45,46.5 121.72,44.77 121.72,43.54
  BOTTOM w0.089: v1(107.7,40.05) RX3.1
  BOTTOM w0.1: v1(132.69,52.31) 132.29,52.72 132.29,53.6 132.32,53.64 132.32,53.68 132.52,53.89 132.52,54.18 132.42,54.29 132.42,54.57 132.73,54.88 UC1.BA8
SPK_L+_CONN: length 0.5
  TOP w0.102: v1(14.39,4.63) v3(14.89,4.63)
  vias: v1(14.39,4) v1(25.5,2.98) v1(25.5,2.4)
SPK_L-_CONN: length 0.5
  TOP w0.102: v1(13.43,4.63) v3(12.92,4.63)
  vias: v1(13.43,4) v1(29.18,2.73) v1(29.18,2.09)
SPK_R+_CONN: length 0.5
  TOP w0.102: 16.94,5.44 v3(16.43,5.44)
  vias: v1(17.12,5.71) v1(17.12,5.08)
SPK_R-_CONN: length 0.5
  TOP w0.102: 16.91,3.63 v3(16.37,3.63)
  vias: v1(17.05,3.93) v1(17.05,3.3)
SSD_DEVSLP: length 157.5
  TOP w0.099: v1(136.05,48.37) v3(135.1,48.37) 134.77,48.37 134.3,48.84 RC663.2
  IN1 w0.089: v1(50.44,45.03) 49.59,44.18 47.24,44.18 46.47,44.95 43.14,44.95 42.87,45.21 41.87,45.21 41,46.07 37.56,46.07 v1(37.56,46.07)
  IN2 w0.089: v1(37.56,46.07) 37.56,45.27 36.96,44.67 36.96,42.78 37.34,42.4 37.34,40.43 38.09,39.68 38.09,37.02 37.22,36.14 35.08,36.14 34.84,35.91 34.84,34.55 31.65,31.36 31.65,30.92 31.26,30.54 31.05,30.54 30.15,29.64 30.15,28.58 30.03,28.45 v1(29.93,28.45) ; v1(130.91,58.81) 130.91,58.07 131.94,57.04 131.94,56.31 132.36,55.89 132.43,55.89 132.69,55.62 132.69,55.09 135.53,52.26 135.53,51.4 135.69,51.25 135.69,48.74 v1(136.05,48.37) 136.05,43.99 134.3,42.23 133.5,40.3 129.45,36.25 128.27,36.25 125.34,33.32 124.77,33.32 123.55,32.11 116.04,32.11 115.56,31.63 109.3,31.63 108.75,31.07 104.34,31.07 103.32,32.09 102.18,32.09 102.02,31.93 97.26,31.93 97.18,32.01 80.46,32.01 80,32.48 67.95,32.48 67.77,32.65 63.16,32.65 61.78,34.03 61.78,34.18 61.13,34.83 59.93,34.83 50.44,44.31 v1(50.44,45.03)
  BOTTOM w0.089: JSSD1.38 30.13,27.33 30.14,27.34 30.14,28.11 29.93,28.32 v1(29.93,28.45)
  BOTTOM w0.1: UC1.AU10 131.23,58.49 v1(130.91,58.81)
SUSCLK_WLAN: length 223.2
  TOP w0.099: v1(127.07,52.88) 127.22,52.88 127.54,53.2 RC1689.2
  IN3 w0.135: v1(127.07,52.88) 127.73,52.22 127.73,51.32 126.49,50.08 126.49,49.24 126.37,49.12 126.37,49.12 125.93,48.68 125.93,46.91 124.47,45.44 124.47,44.35 124.47,44.34 124.47,43.34 123.86,42.73 123.86,42.01 124.31,41.56 124.31,40.9 124.06,40.66 121.95,40.66 121.7,40.91 121.15,40.91 119.99,39.75 119.99,39.3 119.69,39.01 118.36,39.01 114.73,35.38 111.27,35.38 109.92,36.73 109.11,37.95 108.9,38.09 107.02,38.09 106.62,37.69 105.61,37.69 104.83,36.91 98.55,36.91 98.31,36.66 90.04,36.66 89.32,37.38 89.01,37.38 88.29,36.66 66.95,36.66 64.84,38.77 63.17,38.77 62.73,39.21 62.04,39.21 56.65,44.59 56.03,44.59 55.03,45.6 42.63,45.6 40.59,47.64 40.59,52.29 39.75,53.13 39.75,62.15 38.77,63.13 38.77,65.24 38.55,65.46 38.55,67.77 39.18,68.4 39.18,70.47 38.76,70.89 38.76,71.4 38.33,71.83 38.33,76.09 37.43,76.99 37.43,78.59 37.85,79.01 37.85,81.31 37.49,81.66 37.49,82.02 38.59,83.12 41.21,83.12 41.88,83.79 46.24,83.79 48.17,85.72 50.45,85.72 57.11,92.38 57.11,108.92 61.21,113.01 67.49,113.01 68.2,113.73 v1(68.2,113.84)
  BOTTOM w0.112: v1(68.2,113.84) 68.2,114.48 67.05,115.63 66.83,115.63 65.25,117.21 65.25,118.44 66.58,119.77 66.58,122.65 67.97,124.04 67.97,128.2 67.7,128.47 67.7,129.31 69.35,130.96 69.35,132.08 70.17,132.9 JWLAN1.50
SUSP#: length 89.1
  TOP w0.089: R26.1 R27.1 31.42,47.43 v1(31.37,47.49) ; v1(36.96,74.55) 36.61,74.21 UE1.116 ; v1(40.59,95.31) v3(39.34,95.31) 38.33,95.31 R24.1
  TOP w0.254: v1(31.07,31.04) 31.18,30.92 PRM09.1
  IN1 w0.089: v1(37.21,46.64) 37.05,46.64 36.39,47.3 31.55,47.3 v1(31.37,47.49)
  IN2 w0.089: v1(40.59,95.31) 40.77,95.12 40.77,89.82 37.54,86.59 37.54,81.37 37.99,80.92 37.99,79.47 36.8,78.28 36.8,77.19 37.3,76.7 37.3,74.89 v1(36.96,74.55) 36.61,74.55 33.97,71.91 33.97,71.02 33.03,70.07 33.03,62.34 34.97,60.4 34.97,57.16 38.48,53.65 38.48,52.44 38.93,51.98 38.93,48.37 v1(37.21,46.64) 37.16,46.6 37.16,45.93 37.37,45.72 37.37,45.34 36.78,44.75 36.78,42.71 37.16,42.33 37.16,40.35 37.91,39.6 37.91,37.09 37.15,36.33 34.53,36.33 32.16,33.95 32.16,32.13 v1(31.07,31.04)
SVI2_SVC: length 56.8
  TOP w0.089: v1(108.39,126.44) 105.89,126.44 104.33,124.88 104.33,122.76 101.26,119.69 101.26,119.36 v3(99.81,117.91) 99.23,117.34 92.26,117.34 90.66,118.94 v1(90.66,120.34)
  TOP w0.102: PUV01.3 71.14,130.64 70.38,131.39 v1(70.27,131.39)
  IN1 w0.089: v1(90.66,120.34) 90.21,120.79 86.36,120.79 86.06,121.08 83.16,121.08 78.23,126.01 77.29,126.01 76.24,127.06 71.93,127.06 69.86,129.13 69.86,131.11 70.14,131.39 v1(70.27,131.39)
  BOTTOM w0.102: v1(108.39,126.44) 108.75,126.44 109.08,126.77 RV84.1 RV89.2 RV157.2
SVI2_SVD: length 58.7
  TOP w0.089: PUV01.5 71.22,129.84 71.16,129.9 ; v1(91.84,120.34) 91.84,118.28 92.41,117.71 98.76,117.71 v3(100.2,119.16) 103.96,122.91 103.96,125.03 108.1,129.17 108.1,129.92 v1(107.98,130.04)
  TOP w0.102: 71.16,129.9 71.16,129.98 71.03,130.11 71.03,130.36 70.57,130.81 v1(70.32,130.81)
  IN1 w0.089: v1(91.84,120.34) 91.02,121.15 86.51,121.15 86.22,121.45 83.31,121.45 78.38,126.38 77.44,126.38 76.39,127.42 72.32,127.42 70.77,128.96 70.77,130.49 70.45,130.81 v1(70.32,130.81)
  BOTTOM w0.089: RV87.1 109.07,128.88 RV88.2 108.89,128.91 108.47,129.34 108.33,129.34 108,129.66 108,130.03 v1(107.98,130.04)
  BOTTOM w0.102: RV155.2 108.26,130.1 108.21,130.04 v1(107.98,130.04)
SVI2_SVT: length 53.8
  TOP w0.089: PUV01.7 71.03,129.04 70.85,129.22 ; v1(91.25,120.36) v3(91.25,119.18) 91.25,118.61 92.33,117.53 98.99,117.53 100.75,119.28 100.75,119.44 104.14,122.84 104.14,124.95 108.48,129.29 v1(108.48,129.71)
  TOP w0.102: v1(70.32,129.24) 70.32,129.24 70.43,129.34 70.72,129.34 70.85,129.22
  IN1 w0.089: v1(91.25,120.36) 90.64,120.97 86.43,120.97 86.14,121.26 83.23,121.26 78.3,126.2 77.36,126.2 76.32,127.24 72.24,127.24 70.34,129.13 70.34,129.18 70.32,129.2 v1(70.32,129.24)
  BOTTOM w0.102: v1(108.48,129.71) 109.31,129.71 109.77,129.25 RV156.2
SYS_RESET_L: length 24.8
  TOP w0.089: RC48.1 CC14.1 RC52.1 143.44,58.16 v3(142.82,58.78) 142.5,59.1 140.72,59.1 140.19,59.62 140.19,60.84 141.45,62.09 141.45,62.75 v1(142.07,63.37)
  IN2 w0.089: v1(130.83,59.75) 130.83,59.87 131.17,60.2 131.19,60.2 131.6,60.61 132.57,60.61 133.07,61.11 133.07,61.24 133.71,61.89 135.29,61.89 136.49,63.08 138.88,63.08 139.55,63.75 141.69,63.75 v1(142.07,63.37)
  BOTTOM w0.1: UC1.AP10 v1(130.83,59.75)
SYSON: length 130.2
  TOP w0.089: UE1.95 37.75,82.01 v1(37.91,81.84)
  TOP w0.102: v3(78.14,108.9) 78.14,109.69 v1(77.96,109.87)
  TOP w0.254: PRM08.1 32.37,28.63 32.34,28.63 32.12,28.85 31.14,28.85 v1(30.93,29.07) ; PR2501.1 77.77,110.04 77.94,109.87 v1(77.96,109.87)
  IN1 w0.089: v1(41.72,99.37) 42.17,99.37 44.06,101.26 51.47,101.26 56.17,105.96
  IN1 w0.102: 56.17,105.96 59.56,109.36 59.84,109.36 59.89,109.41 63.79,109.41 63.83,109.44 65.51,109.44 66.04,108.92 68.49,108.92 68.51,108.95 69.71,108.95 70.16,109.41 76.56,109.41 77.03,109.87 v1(77.96,109.87)
  IN2 w0.089: v1(41.72,99.37) 41.72,96.91 41.52,96.72 41.52,94.75 41.91,94.37 41.91,90.7 37.89,86.68 37.89,81.86 v1(37.91,81.84) 38.17,81.59 38.17,79.39 36.98,78.2 36.98,77.27 37.48,76.77 37.48,74.54 37.11,74.18 36.5,74.18 34.16,71.83 34.16,71.09 34.61,70.64 34.61,69.87 33.21,68.47 33.21,62.42 35.15,60.48 35.15,57.37 38.71,53.82 38.71,52.47 39.16,52.01 39.16,46.61 37.14,44.59 37.14,42.86 37.52,42.48 37.52,40.51 38.28,39.75 38.28,36.94 37.3,35.96 35.15,35.96 35.02,35.83 35.02,34.47 31.83,31.28 31.83,30.85 31,30.01 31,29.14 v1(30.93,29.07)
T-GND_L: length 9.5
  TOP w0.508: v1(21.5,75.36) 21.5,76.27 20.43,77.34 RL19.2 RL7.2 RL20.2 RL9.2
  BOTTOM w0.089: CL10.1 20.38,77.76 v3(20.1,77.76)
  BOTTOM w0.508: CL10.1 v1(21.5,75.36)
T_CRIT#: length 2.9
  BOTTOM w0.089: v3(180.64,60.32) 180.58,60.38 R34.2 180.29,61.18 180.29,61.31 U8.4
TESTEN: length 6.6
  TOP w0.102: RV154.2 RV17.2 129.06,121.34 129.26,121.55 129.26,123.56 129.9,124.19 v4(129.9,124.29) 129.9,124.91 v1(129.4,125.4)
  BOTTOM w0.102: UV1.K7 129.34,125.4 v1(129.4,125.4)
THERMTRIP#: length 143.5
  TOP w0.089: v1(45.44,69.21) 45.13,69.52 44.1,69.52 43.75,69.18 UE1.17
  TOP w0.099: RC664.2 126.65,48.91 v1(126.07,49.5) 126.35,49.78 v3(126.35,49.96)
  IN2 w0.089: v1(45.44,69.21) 45.44,68.47 45.25,68.28 45.25,65.56 44.85,65.16 44.85,62.84 44.45,62.44 44.45,61.08 45.03,60.5 45.03,59.46 45.28,59.21 47.4,59.21 51.91,54.71 51.91,49.66 56.17,45.4 ; 57.6,42.35 57.6,42.19 61.96,37.83 64.69,37.83 66.09,36.42 79.07,36.42 79.57,35.92 81.58,35.92 81.88,35.63 94.34,35.63 95.05,36.33 98.67,36.33 99.08,35.92 99.54,35.92 100.26,36.65 105.06,36.65 105.25,36.83 106.61,36.83 107.76,35.68 108.69,35.68 108.8,35.8 109.81,35.8 110.68,35.18 112.1,34.64 114.61,34.64 114.88,34.91 115.79,34.91 116.46,35.58 117.13,35.58 118.63,37.08 119.64,37.08 119.85,36.88 121.59,36.88 122.58,37.87 122.58,38.49 123.92,39.82 125.36,39.82 126.98,41.44 126.98,42.5 127.45,42.97 128.58,42.97 129.72,44.11 130.82,44.11 131.02,44.3 131.02,45.4 130.02,46.4 128.52,46.4 127.53,47.39 127.53,47.81 126.07,49.27 v1(126.07,49.5) 126.21,49.64 126.21,50.68 124.04,52.85 124.04,53.78 125.66,55.4 125.66,56.18 126.15,56.66 126.15,59.07 126.34,59.25 126.34,59.56 125.74,60.15 v1(125.74,60.16)
  IN2 w0.102: 56.17,45.4 57.6,43.97 57.6,42.35
  BOTTOM w0.1: v1(125.74,60.16) 125.39,60.51 UC1.AP16
THM_SML1_CLK: length 9.3
  TOP w0.112: v1(182.98,68) R32.2 182.29,67.05 Q11.4
  BOTTOM w0.112: C57.1 177.59,66.9 177.59,66.77 U8.8 178.27,66.1 178.91,65.46 179.25,65.46 179.36,65.58 179.36,65.74 180.39,66.77 v3(181.1,66.77) 181.58,66.77 182.81,68 v1(182.98,68)
THM_SML1_DATA: length 6
  TOP w0.112: R31.2 181,65.15 Q11.1 179.97,65.15 v1(179.9,65.21)
  BOTTOM w0.112: v1(179.9,65.21) 179.78,65.34 179.57,65.34 179.46,65.23 178.22,65.23 U8.7 177.11,66.33 177.01,66.33 177.01,66.33 176.91,66.33 C58.1
TON_1.2V: length 2.2
  TOP w0.203: PRM07.2 33.97,27.79 33.98,27.79 34.1,27.91 34.1,27.91 34.13,27.95 34.13,28.2 34.34,28.41 PUM01.9
TOP_MUX_N: length 4.2
  BOTTOM w0.112: RT10.1 23.35,131.67 LT1.3 24.1,131.5 24.18,131.42 EU7.9 EU7.1 26.48,131.42 26.73,131.17 UT10.4
TOP_MUX_N_R: length 25
  TOP w0.102: JUSBC1.A7 7.35,120.83 7.83,120.83 7.98,120.97 8.15,120.97 v1(8.31,120.81)
  IN3 w0.135: v1(21.54,131.54) 21.7,131.38 22.03,131.38 22.31,131.1 22.31,130.2 20.57,128.46 16.81,128.46 16.47,128.79 13.02,128.79 10.54,126.31 10.54,121.51 10,120.98 8.48,120.98 8.32,120.81 v1(8.31,120.81)
  BOTTOM w0.112: RT10.2 22.44,131.67 LT1.4 22,131.5 21.86,131.36 21.72,131.36 v1(21.54,131.54)
TOP_MUX_P: length 4.2
  BOTTOM w0.112: RT9.1 23.35,130.83 LT1.2 24.22,131 24.3,130.92 EU7.8 EU7.2 26.59,130.92 26.84,130.67 UT10.3
TOP_MUX_P_R: length 24.3
  TOP w0.102: JUSBC1.A6 7.79,121.32 7.93,121.18 8.1,121.18 v1(8.31,121.39)
  IN3 w0.135: v1(21.54,130.96) 21.72,131.14 21.93,131.14 22.07,131 22.07,130.3 20.47,128.7 16.91,128.7 16.57,129.04 12.92,129.04 10.3,126.41 10.3,121.61 9.9,121.22 8.49,121.22 v1(8.31,121.39)
  BOTTOM w0.102: 22.4,130.87 22.44,130.83 RT9.2
  BOTTOM w0.112: v1(21.54,130.96) 21.72,131.14 21.86,131.14 22,131 LT1.1 22.4,130.87
TP_CLK: length 155.4
  TOP w0.112: UE1.87 40.95,84.27 v1(41.35,84.67) 41.35,85.16 41.44,85.25 R13.1 ; v1(124.73,31.9) 124.73,31.88 124.73,31.88 124.73,31.67 125.31,31.09 v2(125.31,29.68) 125.31,29.33 125.81,28.83 127.41,28.83 C20.1
  IN3 w0.135: v1(41.35,84.67) 41.35,84.5 40.85,84 38.23,84 36.06,81.83 36.06,72.87 36.09,72.84 36.09,69.58 35.61,69.1 35.61,68.22 35.13,67.74 35.13,61.98 33.51,60.36 33.51,58.8 35.48,56.83 35.48,52.28 35.11,51.91 35.11,49.86 35.52,49.45 35.52,47.24 35.02,46.74 35.02,44.71 34.35,44.04 34.35,41.21 34.59,40.97 37.35,40.97 38.02,40.3 49.32,40.3 49.7,40.68 54.9,40.68 60.28,35.3 61.11,35.3 61.55,34.86 63.22,34.86 67.18,30.9 96.92,30.9 97.33,30.5 103.09,30.5 103.58,30.01 109.16,30.01 109.7,30.55 117.08,30.55 117.1,30.57 120.63,30.57 121.49,31.42 123.04,31.42 123.77,32.15 124.17,32.15 124.42,31.9 v1(124.73,31.9)
  BOTTOM w0.112: JTP1.1 125.05,30.8 124.73,31.11 124.73,31.85 124.73,31.86 v1(124.73,31.9)
TP_DATA: length 155.2
  TOP w0.112: v1(124.32,31.46) 124.38,31.41 124.65,31.41 125.07,30.99 125.07,29.23 125.71,28.59 v2(126.74,28.59) 127.41,28.59 C21.1 ; R14.1 40.62,85.28 40.62,84.81 v1(40.76,84.67) 40.55,84.46 UE1.88
  IN3 w0.135: v1(124.32,31.46) 124.32,31.63 124.06,31.89 123.87,31.89 123.15,31.16 121.59,31.16 120.74,30.31 117.21,30.31 117.19,30.29 109.81,30.29 109.27,29.75 103.47,29.75 102.98,30.24 97.22,30.24 96.81,30.64 67.07,30.64 63.12,34.6 61.44,34.6 61,35.04 60.17,35.04 54.79,40.42 49.81,40.42 49.43,40.04 37.92,40.04 37.24,40.71 34.48,40.71 34.09,41.1 34.09,44.15 34.76,44.81 34.76,46.85 35.26,47.35 35.26,49.34 34.85,49.75 34.85,52.02 35.22,52.39 35.22,56.72 33.25,58.69 33.25,60.46 34.87,62.08 34.87,67.85 35.34,68.33 35.34,69.2 35.83,69.69 35.83,72.73 35.8,72.76 35.8,81.94 38.12,84.26 40.63,84.26 40.76,84.4 v1(40.76,84.67)
  BOTTOM w0.112: JTP1.2 124.05,30.72 124.48,31.15 124.48,31.3 v1(124.32,31.46)
TP_EN: length 121.6
  TOP w0.089: UE1.82 42.95,82.35 42.71,82.1 42.27,82.1 40.87,80.7 40.29,80.7 40.15,80.56 v1(39.93,80.56) ; R17.1 105.29,29.35 103.5,27.55 100.87,27.55 99.47,26.16 v3(73.44,26.16) 62,26.16 v1(61.73,26.42)
  IN2 w0.089: v1(61.73,26.42) 61.54,26.23 59.25,26.23 58.73,26.75 58.73,28.32 57.76,29.28 57.76,30.96 55.03,33.7 52.59,33.7 52.1,34.19 48.54,34.19 43.88,38.84 43.88,49.78 40.79,52.88 40.79,54.25 36.87,58.17 36.87,61.09 36.01,61.96 36.01,66.51 36.23,66.73 36.23,68.33 36.09,68.47 36.09,68.78 36.77,69.45 36.77,71.27 38.94,73.44 38.94,76.74 39.17,76.97 39.17,78.12 39.74,78.69 39.74,80.12 39.93,80.31 v1(39.93,80.56)
TP_I2C_INT#: length 16.3
  TOP w0.089: RP4.3 120.81,28.06 120.98,28.23 122.32,28.23 122.55,28.46 v1(122.55,29.07) ; R12.2 R10.2 115.97,28.11 115.9,28.19 115.9,29.01 v1(115.89,29.02) 115.9,29.03 115.9,29.75 116.16,30.02 Q1.3
  IN2 w0.089: v1(115.89,29.02) 115.9,29.03 116.38,29.03 117.04,29.69 120.62,29.69 120.92,29.39 122.26,29.39 122.55,29.1 v1(122.55,29.07)
  BOTTOM w0.089: v1(122.55,29.07) 122.55,29.43 122.05,29.93 JTP1.4
TP_I2C_INT#_APU: length 30
  TOP w0.089: v1(118.08,27.74) 117.89,27.55 117.31,27.55 117.12,27.36 R10.1 116.89,27.82 116.95,27.88 117.13,28.06 Q1.1 ; v1(129.59,42.12) 129.4,41.93 129.4,41.21 129.05,40.86 128.13,40.86 v3(125.02,37.76) 124.33,37.07 124.33,33.62 123.49,32.78 123.49,29.83 123.72,29.6 v1(123.72,29.05)
  IN1 w0.089: v1(118.08,27.74) 118.08,27.79 118.78,28.49 123.15,28.49 v1(123.72,29.05)
  BOTTOM w0.089: v1(129.59,42.12) 129.46,42.25 129.46,43.46 129.97,43.97 129.97,45.21 130.29,45.52 RC36.1
TP_ON#_GATE: length 9.7
  TOP w0.089: Q2.2 112.23,29.73 111.84,30.11 110.41,30.11 108.4,28.1 Q4.2 107.45,28.43 C22.2 R17.2 v3(105.32,27.43)
TPM_20: length 5
  TOP w0.089: RX13.2 105.01,37.85 v3(105.61,37.24) 106.11,36.74 v1(106.11,36.19)
  BOTTOM w0.089: UX1.20 106.01,36.3 v1(106.11,36.19) 106.18,36.25 RX5.2 RX34.2
TPM_24: length 38.3
  TOP w0.089: v1(106.75,33.48) 106.52,33.7 106.52,35.24 104.94,36.83 104.94,37.52 104.24,38.22 RX14.2 ; v1(126.36,38.13) 126.46,38.03 v3(131.86,38.03) 132.46,38.03 132.75,37.74 132.75,37.75 v1(132.76,37.75)
  IN1 w0.089: v1(106.75,33.48) 106.93,33.3 108.95,33.3 109.29,32.96 115.91,32.96 116.53,33.59 119.83,33.59 120.65,34.41 121.73,34.41 122.55,35.22 122.89,35.22 123.61,35.94 124.17,35.94 v1(126.36,38.13)
  BOTTOM w0.089: UX1.24 105.93,34.3 v1(106.75,33.48) 106.75,33.47 RX29.2 ; v1(132.76,37.75) 132.75,37.75 131.88,38.62 RX1.2
TS_EN_R: length 244.8
  TOP w0.089: v1(42.41,72.15) 42.11,72.45 38.35,72.45 37.3,71.4 37.3,68.85 37.1,68.66 37.1,67.86 35.41,66.17 D1.2 ; RX25.2 211.92,42.16 212.22,41.86 213.15,41.86 213.48,41.52 213.48,41.4 213.57,41.31 215.4,41.31 216.09,40.62 v3(216.09,40.44) 216.09,39.85 216.31,39.63 216.72,39.63 v1(217.09,40)
  IN2 w0.089: v1(42.41,72.15) 42.39,72.13 42.39,69.86 42,69.48 42,67.87 42.53,67.35 42.53,65.71 41.97,65.15 41.97,63.83 40.63,62.49 40.63,59.89 42.04,58.48 42.32,58.48 44.18,56.62 44.18,55.55 45.12,54.61 45.12,53.56 47.16,51.52 47.16,47.71 49.66,45.21 49.66,42.97 52.35,40.28 53.41,40.28 59.41,34.28 60.82,34.28 61.24,33.87 61.24,33.72 61.95,33.01 61.95,32.92 62.75,32.11 67.54,32.11 67.89,31.76 79.94,31.76 80.24,31.46 96.95,31.46 97.57,30.84 98.51,30.84 99.02,31.35 103.04,31.35 103.87,30.53 108.98,30.53 109.54,31.08 115.79,31.08 116.27,31.56 123.78,31.56 124.99,32.77 126.37,32.77 129.12,35.52 129.75,35.52 131.21,36.99 134.8,36.99 135.61,36.18 144.62,36.18 145.7,37.26 146.73,37.26 147.46,36.53 147.66,36.53 150.31,36.53 150.97,35.87 152.9,33.94 160.72,33.94 160.87,33.78 161.83,32.83 162.94,32.83 163.08,32.7 163.95,32.7 164.56,32.09 165.75,32.09 165.75,32.1 165.76,32.1 166.36,32.7 167.97,32.7 168.07,32.8 168.67,32.8 169.69,31.77 172.64,31.77 172.82,31.95 174.51,31.95 175.36,31.09 177.96,31.09 178.76,31.89 179.15,31.89 180.35,33.09 182.25,33.09 182.36,33.2 184.29,33.2 184.4,33.09 184.96,33.09 185.17,33.3 186.86,33.3 188.78,35.22 189.13,35.57 190.41,35.57 191.3,34.68 193.86,34.68 195.29,33.25 201.92,33.25 202.36,33.69 203.45,33.69 204.73,32.41 205.82,32.41 206.35,32.95 206.69,32.95 207.47,33.73 213.16,33.73 213.61,33.27 214.72,33.27 216.75,35.3 216.75,35.78 217.09,36.12 v1(217.09,40)
TS_EN_RR: length 3
  TOP w0.089: v1(213.91,41.69) 213.32,42.29 RX25.1
  BOTTOM w0.089: v1(213.91,41.69) 213.68,41.45 JEDP1.39
TYPEC_CFG0: length 2.8
  TOP w0.089: RT45.1 18.77,126.36 v1(18.53,126.6)
  BOTTOM w0.089: 18.63,126.5 v1(18.53,126.6) 18.45,126.68 RT22.2
  BOTTOM w0.102: 18.63,126.5 18.96,126.17 UT9.3
TYPEC_CFG1: length 2.9
  TOP w0.089: RT44.1 19.53,125.85 19.1,126.28 v1(19.1,126.72)
  BOTTOM w0.089: 19.1,126.5 v1(19.1,126.72) 19.21,126.83 RT21.2
  BOTTOM w0.102: UT9.4 19.36,126.21 19.1,126.47 19.1,126.5
TYPEC_CLK: length 68.4
  TOP w0.089: UE1.85 41.75,82.63 41.23,82.11 40.64,82.11 39.99,81.46 39.99,81.4 39.45,80.86 37.98,80.86 37.05,81.78 37.05,82.01 36.59,82.47 36.03,82.47 v1(35.9,82.6)
  IN3 w0.089: v1(36.35,90.37) 36.65,90.08 47.38,90.08 50.08,92.77 50.08,106.01 48.47,107.62 48.47,111.3 46.32,113.45 43.69,113.45 38.68,118.45 36.24,118.45 35.75,118.94 v1(35.75,119.06)
  BOTTOM w0.089: v1(35.9,82.6) 35.9,89.92 v1(36.35,90.37) ; RT72.2 35.75,118.72 v1(35.75,119.06) 35.75,119.41 35.64,119.52 UT1.17
TYPEC_CTL0: length 17.2
  TOP w0.089: RT53.1 22.07,119.07 v1(21.64,118.64)
  IN2 w0.089: v1(21.64,118.64) 24.79,121.79 24.79,125.47 26.31,127 27.23,127 v1(27.26,127.02)
  BOTTOM w0.089: RT30.2 22.06,118.22 v1(21.64,118.64) 21.34,118.93 20.81,118.93 ; v1(27.26,127.02) 27.86,127.02 v3(28.04,126.84) RT55.1
  BOTTOM w0.102: 20.81,118.93 20.56,119.18 UT9.22
TYPEC_CTL1: length 4.2
  TOP w0.089: RT43.1 21.31,119.36 20.99,119.04 v1(20.99,118.56) 20.53,118.56 v3(20.47,118.61)
  BOTTOM w0.089: RT20.2 21.23,117.85 20.99,118.1 v1(20.99,118.56) 20.84,118.7 20.67,118.7 20.54,118.83
  BOTTOM w0.102: 20.54,118.83 20.16,119.21 UT9.23
TYPEC_DEQ0: length 2.7
  TOP w0.089: RT25.2 17.05,124.7 17.05,124.44 16.74,124.13 v1(16.74,124.09) 16.74,124 16.85,123.88 RT48.1
  BOTTOM w0.089: 16.85,124.06 16.76,124.06 v1(16.74,124.09)
  BOTTOM w0.102: UT9.38 16.85,124.06
TYPEC_DEQ1: length 5.9
  TOP w0.089: RT47.1 17.21,121.28 16.67,120.74 v1(16.67,120.41) 17.11,120.41 v3(17.19,120.33)
  BOTTOM w0.089: 16.67,120.28 16.67,119.87 17.18,119.37 17.18,117.87 RT24.2
  BOTTOM w0.102: 16.67,120.28 v1(16.67,120.41) 16.73,120.46 UT9.29
TYPEC_DIR0: length 3.7
  TOP w0.089: v3(22.75,125.8) RT51.1 21.81,126.22 v1(21.5,126.54)
  BOTTOM w0.089: UT9.8 20.96,126 v1(21.5,126.54) RT28.2
TYPEC_DIR1: length 3.6
  TOP w0.089: RT50.1 v1(22.7,124.01) v3(23.34,124.01) 24.09,124.01 RT27.2
  BOTTOM w0.089: v1(22.7,124.01) 22.65,124.06 22.61,124.06
  BOTTOM w0.102: UT9.11 22.61,124.06
TYPEC_FLIP: length 13.6
  TOP w0.089: RT52.1 22.83,119.1 v1(22.37,118.64)
  BOTTOM w0.089: RT54.1 29.69,121.98 v3(29.45,121.74) 25.98,118.27 23.54,118.27 RT29.2 22.86,117.61 22.37,118.09 v1(22.37,118.64) 21.4,119.61 UT9.21
TYPEC_I2C_EN#: length 3.7
  TOP w0.089: RT17.2 23.58,121.34 v3(23.34,121.34) 22.78,121.34 v1(22.53,121.6) RT40.1
  BOTTOM w0.102: v1(22.53,121.6) 22.45,121.6 22.39,121.66 UT9.17
TYPEC_ID: length 3.2
  TOP w0.089: RE8.1 RE11.2 33.64,82.57 33.73,82.48 33.9,82.48 34.58,81.81 UE1.97
TYPEC_SDA: length 47.9
  TOP w0.089: UE1.86 41.35,82.49 41.16,82.29 40.56,82.29 39.81,81.54 39.81,81.48 39.37,81.04 38.06,81.04 37.25,81.85 37.25,82.08 36.35,82.97 v1(36.35,83.06)
  IN2 w0.089: v1(36.34,119.08) 35.14,117.88 35.14,115.35 36.41,114.08 36.41,109.58 37.42,108.57 37.42,103.21 35.79,101.58 35.79,85.09 36.24,84.64 36.24,83.17 36.35,83.06 v1(36.35,83.06)
  BOTTOM w0.089: RT73.2 36.34,118.48 v1(36.34,119.08) 36.14,119.28 UT1.16
TYPEC_SWAP: length 3.3
  TOP w0.089: v3(19.65,127.04) v1(19.65,126.52) 20.29,125.89 RT49.1
  BOTTOM w0.089: RT26.2 v3(19.65,127.04) v1(19.65,126.52) 19.65,126.5
  BOTTOM w0.102: 19.65,126.5 19.65,126.39 19.76,126.28 19.76,126.28 UT9.5
TYPEC_TI_EN#: length 4.5
  TOP w0.089: v3(21.55,127.36) CT46.1 20.61,126.91 v1(20.87,126.64) 20.87,126.29 21.05,126.11 RT61.1
  BOTTOM w0.089: RT31.1 20.74,126.78 v1(20.87,126.64) 20.56,126.32 UT9.7
TYPEC_UEQ0/A0: length 3.9
  TOP w0.089: RT19.2 16.48,124.46 16.36,124.34 16.36,123.62 16.67,123.31 v1(16.67,122.86) 16.68,122.87 RT42.1
  BOTTOM w0.089: 16.85,122.86 v1(16.67,122.86)
  BOTTOM w0.102: UT9.35 16.85,122.86
TYPEC_UEQ1/A1: length 4.3
  TOP w0.089: RT41.1 18,126.56 v1(17.95,126.62)
  BOTTOM w0.089: UT9.2 18.56,126 v1(17.95,126.62) 17.69,126.88 RT18.2 17.39,127.36 16.84,127.92 v3(16.48,127.92)
TYPEC_USBC_SCL: length 1.9
  BOTTOM w0.089: QT6.1 31.29,122.87 RT36.2 RT54.2
TYPEC_USBC_SDA: length 4.1
  BOTTOM w0.089: QT6.4 29.99,126.24 RT37.2 29.28,126.42 28.98,126.12 v3(28.98,125.47) 28.98,125.15 28.74,124.91 RT55.2
TYPEC_VIO_SEL: length 3.7
  TOP w0.089: RT23.2 24.02,122.68 v3(23.34,122.68) 22.89,122.68 v1(22.77,122.8) RT46.1
  BOTTOM w0.089: v1(22.77,122.8) 22.71,122.86 22.61,122.86
  BOTTOM w0.102: UT9.14 22.61,122.86
UART0_CTS#: length 8.1
  BOTTOM w0.089: UC1.BA18 123.73,54.86 124.02,54.57 124.02,54.26 123.95,54.18 123.95,52.69 124.46,52.17 124.46,51.51 123.08,50.13 123.08,48.32 T118.1
UART0_INTR: length 7.5
  BOTTOM w0.089: T119.1 124.42,48.05 123.3,49.17 123.3,50.1 124.64,51.44 124.64,52.25 124.16,52.72 124.16,53.94 UC1.BD18
UART0_RTS#: length 2.1
  TOP w0.099: T117.1 124.84,52.37 124.84,52.85 v1(124.79,52.91)
  BOTTOM w0.089: v1(124.79,52.91) 124.71,52.99 124.71,54.38 UC1.BC17
UART0_RXD: length 6.3
  BOTTOM w0.099: T101.1 125.03,50.02 125.92,50.91 125.92,52.88 125.86,52.94 125.86,54.05 126.04,54.23 126.04,54.51 125.73,54.82 UC1.BA16
UART0_TXD: length 4
  BOTTOM w0.102: T102.1 124.93,52.22 124.42,52.73 124.42,53.73 124.52,53.83 124.52,54.19 124.23,54.49 UC1.BB18
UG1_APU: length 8.9
  TOP w0.089: v1(152.33,67.06) v3(152.33,66.54)
  IN3 w1.016: 151.84,74.34 151.84,75.26 151.32,75.78 151.32,82.48
  vias: v1(151.35,73.54) v1(151.35,72.88) v1(152.23,83.55) v1(152.33,67.67) v1(152.69,83.96)
UG1_CHG: length 15
  IN3 w0.508: v1(194.41,54.27) 195.42,53.25 198.68,53.25 201.07,50.86 v1(201.07,45.29)
  BOTTOM w0.203: PUB01.11 v1(201.07,45.29)
UG1_VGA: length 12.4
  TOP w0.089: v1(90.25,122.84) v3(90.76,122.84)
  IN3 w0.635: 83.17,122.89 81.11,124.95 80.46,124.95 78.27,127.15 78.25,127.15 78.13,127.27 ; 85.2,122.89 85.84,123.53 89.95,123.53
  vias: v1(77.72,127.71) v1(83.88,122.66) v1(84.46,122.66) v1(89.67,122.84)
UG2_APU: length 15.9
  IN3 w1.016: 166.35,71.32 166.35,74.61 157.82,83.14
  BOTTOM w0.089: v1(156.97,83.71) v3(156.97,84.27)
  vias: v1(156.43,83.98) v1(166.28,64.37) v1(166.66,70.24) v1(166.66,69.63) v1(166.89,64.37)
UG2_CHG: length 5.8
  IN3 w0.508: v1(204.21,42.65) 204.21,42.59 202.95,41.33 200.96,41.33 v1(200.4,40.77)
  BOTTOM w0.203: v1(204.21,42.65) 204.27,42.71 204.27,43.32 204.37,43.42 PUB01.5
  vias: v3(199.55,39.99)
UG2_VGA: length 10.3
  TOP w0.089: 89.51,137.85 v3(89.51,138.49)
  IN3 w0.635: 78.29,131.83 78.47,132.01 80.82,132.01 81.34,132.53 81.34,132.59 81.39,132.64 81.39,136.09 82.55,137.25 83.64,137.25
  vias: v1(77.66,131.63) v1(84.4,137.56) v1(84.4,136.95) v1(89.73,137.35) v1(89.73,136.76)
UG_1.2V: length 6.7
  TOP w0.089: v1(44.03,28.76) v3(44.55,28.76)
  TOP w0.203: v1(39.21,28.19) 38.99,28.41 PUM01.17
  IN1 w0.635: v1(44.03,28.76) 41.77,28.76 40.52,27.51 39.23,27.51
UG_NB: length 15.6
  TOP w0.089: v1(163.31,96.25) v3(163.93,96.25)
  IN1 w0.762: 159.6,84.77 159.7,84.67 162.04,84.67 164.27,86.9 164.27,87.87 165.29,88.89 165.29,93.44 164.07,94.66 164.07,95.33
  vias: v1(157.97,85.73) v1(158.58,85.73) v1(163.31,95.64)
USB3_ARX_C_DTX_0_N1: length 1.5
  TOP w0.112: CU39.1 23.32,57.71 22.98,57.71 22.86,57.59 LU1.3 22.69,57.57 RU2.1
USB3_ARX_C_DTX_0_N2: length 3.4
  TOP w0.112: CU40.1 21.9,38.83 21.43,39.3 21.22,39.3 20.56,38.64 20.56,38.24 20.66,38.13 20.75,38.13 20.79,38.09 LU4.3 20.82,37.58 RU7.1
USB3_ARX_C_DTX_0_P1: length 1.4
  TOP w0.112: RU1.1 22.69,58.12 LU1.2 22.86,58.09 22.98,57.98 23.44,57.98 CU38.1
USB3_ARX_C_DTX_0_P2: length 3.4
  TOP w0.112: CU41.1 21.81,39.57 21.11,39.57 v2(20.63,39.09) 20.29,38.75 LU4.2 20.27,37.58 RU8.1
USB3_ARX_DTX_0_N1: length 149.6
  TOP w0.112: CU39.2 24.89,57.6 25.2,57.6 v1(25.29,57.51)
  IN1 w0.099: 123.96,48.72 124.26,49.02 124.3,49.02 124.37,49.09
  IN1 w0.119: 124.37,49.09 124.89,49.61 124.89,50.54 125.28,50.94 127.86,50.94 127.98,51.05 129.4,51.05 130.12,51.77 130.12,54.39 129.34,55.17 129.34,59.68 129.47,59.81 129.47,60.28 129.28,60.47 129.28,62.66 129.07,62.87 129.07,63.97 129.2,64.11 130.9,64.11 130.92,64.09 131.68,64.09 131.95,64.36 131.95,64.6 v1(132.12,64.77) ; 123.96,48.72 123.61,48.37 121.95,48.37 121.08,47.49 121.08,43.07 120.29,42.27 117.35,42.27 117.27,42.35 116.43,42.35 115.44,43.34 115.44,43.39 114.9,43.92 110.65,43.92 108.18,41.45 107.45,41.45 104.74,38.74 99.32,38.74 97.93,37.36 73.84,37.36 73.16,38.04 73.15,38.04 72.87,38.32 65.34,38.32 64.92,38.75 62.74,38.75 62.38,39.11 61.52,39.11 59.34,41.29 58.23,41.29 57.83,41.68 56.68,41.68 55.17,43.2 43.8,43.2 42.56,44.44 41.55,44.44 40.69,45.31 37.72,45.31 37.23,44.82 31.31,44.82 30.7,45.43 30.7,49.66 31.15,50.11 31.15,51.28 31.34,51.47 31.34,56.76 30.32,57.78 26.23,57.78 26.05,57.6 25.39,57.6 v1(25.29,57.51)
  BOTTOM w0.1: v1(132.12,64.77) 132.12,64.96 132.43,65.27 UC1.AJ8
USB3_ARX_DTX_0_N1_R: length 14.8
  TOP w0.112: RU2.2 21.61,57.43 LU1.4 20.94,57.59 20.82,57.71 20.49,57.71 20.38,57.61 EU3.1 EU3.9 18.85,57.61 18.74,57.72 18.45,57.72 18.04,57.31 18.04,56.37 v2(16.93,55.26) 16.56,54.89 15.66,54.89 15.17,54.4 15.17,53.64 15.3,53.52 15.3,52.63 15.2,52.53 15.2,51.72 15.5,51.43 15.5,50.53 15,50.04 14.52,50.04 14.38,49.9 JUSB1.5
USB3_ARX_DTX_0_N2: length 145
  TOP w0.112: v1(25.33,39.57) 25.26,39.49 25.26,39.08 24.88,38.71 23.75,38.71 23.55,38.91 22.96,38.91 CU40.2
  IN1 w0.099: 123.5,43.54 123.5,43.57 123.48,43.6 123.48,44.68 123.48,45.12 124.49,46.13 124.52,46.13 124.58,46.19
  IN1 w0.119: 124.58,46.19 125.18,46.19 125.64,46.64 125.64,48.07 126.87,49.31 130.13,49.31 131.68,50.86 132.68,50.86 133.34,51.51 133.34,53.84 132.75,54.43 132.38,54.43 131.81,55 131.81,55.88 131.92,56 131.92,57.61 132.5,58.18 132.5,59.14 132.89,59.53 132.89,60.95 133.51,61.57 133.51,61.74 134.3,62.53 134.3,64 134.37,64.08 134.37,65.26 134.11,65.52 134.11,65.69 v1(134.23,65.81) ; v1(25.33,39.57) 25.22,39.69 25.22,40.25 25.34,40.37 28.53,40.37 32.2,44.04 37.56,44.04 38.04,44.52 40.37,44.52 41.23,43.66 42.23,43.66 43.48,42.42 54.85,42.42 56.36,40.9 57.51,40.9 57.91,40.51 59.01,40.51 61.19,38.33 62.06,38.33 62.41,37.97 64.59,37.97 65.02,37.54 72.54,37.54 72.83,37.26 72.83,37.26 73.91,36.18 98.13,36.18 99.03,37.08 100.21,37.08 101.09,37.96 105.56,37.96 106.15,38.54 109.26,38.54 110.79,37.01 110.81,36.99 111.39,36.61 112.37,36.2 114.56,36.2 117.66,39.3 117.66,39.81 118.36,40.51 120.69,40.51 121.01,40.83 121.5,40.83 123.5,42.83 123.5,43.54
  BOTTOM w0.1: UC1.AG6 133.93,66.11 v1(134.23,65.81)
USB3_ARX_DTX_0_N2_R: length 15.2
  TOP w0.112: JUSB2.5 14.38,25.91 14.46,25.98 15.03,25.98 15.64,26.59 17.03,26.59 v2(17.76,27.32) 18.21,27.76 18.21,28.71 18.59,29.1 20.6,31.1 20.6,33.24 20.72,33.35 EU5.9 EU5.1 20.72,35.06 20.71,35.07 20.71,35.91 20.79,36 LU4.4 20.96,36.5 RU7.2
USB3_ARX_DTX_0_P1: length 149.6
  TOP w0.112: v1(25.29,58.09) 25.07,57.87 24.85,57.87 24.62,58.1 CU38.2
  IN1 w0.119: v1(25.29,58.09) 25.53,57.86 25.94,57.86 26.12,58.03 30.43,58.03 31.59,56.87 31.59,51.37 31.4,51.18 31.4,50 30.95,49.55 30.95,45.54 31.42,45.07 37.13,45.07 37.62,45.56 40.79,45.56 41.66,44.7 42.66,44.7 43.91,43.45 55.27,43.45 56.79,41.94 57.94,41.94 58.34,41.54 59.44,41.54 61.62,39.36 62.48,39.36 62.84,39 65.02,39 65.45,38.58 72.97,38.58 73.26,38.29 73.94,37.61 97.83,37.61 99.21,38.99 104.64,38.99 107.35,41.7 108.07,41.7 110.09,43.72 110.14,43.72 110.56,44.14 114.99,44.14 116.53,42.6 117.38,42.6 117.46,42.53 120.18,42.53 120.82,43.17 120.82,43.54 120.86,43.58 120.86,47.58 121.86,48.59 123.52,48.59 124.23,49.3 124.23,49.31 124.63,49.72 124.63,50.65 125.18,51.19 127.76,51.19 127.87,51.3 129.29,51.3 129.87,51.88 129.87,54.28 129.09,55.06 129.09,59.79 129.22,59.92 129.22,60.17 129.02,60.36 129.02,62.56 128.81,62.77 128.81,64.08 129.09,64.36 131.01,64.36 131.02,64.35 131.57,64.35 131.69,64.47 131.69,64.63 131.56,64.77 v1(131.32,64.77)
  BOTTOM w0.1: v1(131.32,64.77) 131.32,64.99 UC1.AJ9
USB3_ARX_DTX_0_P1_R: length 14.8
  TOP w0.112: RU1.2 21.61,58.26 LU1.1 20.94,58.09 20.82,57.98 20.59,57.98 20.46,58.11 EU3.2 EU3.8 18.89,58.11 18.77,57.98 18.34,57.98 17.78,57.42 v2(17.78,56.82) 17.78,56.48 16.74,55.45 16.45,55.15 15.55,55.15 14.91,54.51 14.91,53.53 15.03,53.41 15.03,52.74 14.94,52.64 14.94,51.61 15.24,51.32 15.24,50.64 14.89,50.3 14.49,50.3 14.38,50.41 JUSB1.6
USB3_ARX_DTX_0_P2: length 144.9
  TOP w0.112: CU41.2 22.84,39.56 23.22,39.17 23.66,39.17 23.86,38.97 v2(24.13,38.97) 24.77,38.97 24.99,39.19 24.99,39.33 v1(24.75,39.57)
  IN1 w0.099: 123.25,43.54 123.28,43.6 123.28,44.68 123.28,45.2 124.31,46.23 124.31,46.25 124.33,46.27 124.33,46.29 124.47,46.43 124.55,46.43 124.56,46.44 124.58,46.44
  IN1 w0.119: v1(24.75,39.57) 24.96,39.79 24.96,40.35 25.24,40.63 28.43,40.63 32.09,44.29 37.45,44.29 37.94,44.78 40.47,44.78 41.33,43.92 42.34,43.92 43.58,42.67 54.95,42.67 56.47,41.16 57.62,41.16 58.01,40.76 59.12,40.76 61.3,38.58 62.16,38.58 62.52,38.22 64.7,38.22 65.12,37.8 72.65,37.8 72.94,37.51 72.94,37.51 74.02,36.43 98.02,36.43 98.93,37.33 100.1,37.33 100.99,38.21 105.46,38.21 106.04,38.8 109.36,38.8 110.96,37.19 110.97,37.19 111.51,36.83 112.42,36.45 114.46,36.45 117.41,39.4 117.41,39.91 118.26,40.76 120.58,40.76 120.9,41.08 121.39,41.08 123.25,42.94 123.25,43.54 ; 124.58,46.44 125.08,46.44 125.38,46.74 125.38,48.18 126.23,49.03 126.27,49.06 126.77,49.56 130.03,49.56 131.58,51.11 132.58,51.11 133.08,51.62 133.08,53.74 132.65,54.17 132.28,54.17 131.56,54.9 131.56,55.99 131.67,56.1 131.67,57.72 132.24,58.29 132.24,59.24 132.63,59.64 132.63,61.05 133.26,61.67 133.26,61.84 134.04,62.63 134.04,64.11 134.12,64.18 134.12,65.15 133.77,65.51 133.77,65.57 v1(133.53,65.81)
  BOTTOM w0.1: v1(133.53,65.81) 133.23,66.11 UC1.AG7
USB3_ARX_DTX_0_P2_R: length 15.1
  TOP w0.112: JUSB2.6 14.38,26.36 14.49,26.25 14.92,26.25 15.53,26.86 16.93,26.86 17.57,27.5 17.94,27.87 17.94,28.82 v2(18.41,29.28) 20.34,31.21 20.34,33.24 20.22,33.35 EU5.8 EU5.2 20.22,35.04 20.45,35.27 20.45,35.85 20.29,36 LU4.1 20.29,36.38 20.18,36.5 RU8.2
USB3_ATX_C_DRX_0_N1: length 1.5
  TOP w0.112: RU3.1 22.53,59.14 LU2.3 23.05,59.31 23.24,59.5 23.4,59.5 23.71,59.19 CU7.1
USB3_ATX_C_DRX_0_N2: length 1.5
  TOP w0.112: RU9.1 19.25,37.41 LU5.3 19.08,37.89 18.97,38.01 18.97,38.16 CU15.1
USB3_ATX_C_DRX_0_P1: length 1.5
  TOP w0.112: CU8.1 23.71,60.03 23.44,59.76 23.07,59.76 23.03,59.81 LU2.2 22.53,59.98 RU4.1
USB3_ATX_C_DRX_0_P2: length 1.5
  TOP w0.112: RU10.1 18.41,37.41 LU5.2 18.58,37.85 18.7,37.97 18.7,38.27 CU16.1
USB3_ATX_DRX_0_N1: length 182.6
  TOP w0.112: CU7.2 24.54,59.26 24.54,59.42 24.76,59.65 25.09,59.65 v1(25.35,59.39)
  IN1 w0.119: v1(25.35,59.39) 25.35,59.3 25.22,59.17 25.05,59.17 24.93,59.29 24.93,59.6 24.81,59.72 23.84,59.72 22.89,58.76 22.89,56.77 23.75,55.9 25.63,55.9 30.17,51.36 30.17,43.11 28.21,41.15 24.76,41.15 23.76,40.16 23.76,39.28 23.88,39.16 26.26,39.16 26.95,39.85 28.75,39.85 32.27,43.37 37.56,43.37 37.88,43.05 42.1,43.05 43.26,41.89 54.63,41.89 56.14,40.38 57.29,40.38 57.69,39.98 58.8,39.98 60.98,37.8 61.84,37.8 62.19,37.44 64.37,37.44 64.8,37.02 72.33,37.02 72.77,36.57 72.77,36.57 73.69,35.65 99.76,35.65 100.97,36.86 106.39,36.86 106.53,36.72 107.7,36.72 108.03,37.05 109.19,37.05 111.09,35.15 115,35.15 115.66,35.81 116.83,35.81 118.32,37.3 119.43,37.3 121.07,38.93 122.53,38.93 124.91,41.32 125.4,41.32 125.83,41.74 125.83,42.83 127.16,44.16 127.16,46.27 126.92,46.51 126.92,47.81 127.37,48.26 133.11,48.26 134.99,50.14 134.99,51.12 134.6,51.5 134.6,52.21 133.86,52.96 133.86,54.06 133.15,54.78 133.15,56.74 133.97,57.56 133.97,59.3 134.54,59.87 134.54,60.57 134.79,60.83 134.79,62.24 135.14,62.58 135.14,63.39 135.91,64.16 137.87,64.16 137.99,64.28 137.99,64.44 137.86,64.56 137.71,64.56 137.65,64.62 v1(137.65,64.82)
  BOTTOM w0.102: UC1.AG1 136.39,66.31 136.29,66.21 136.29,66.06 136.46,65.89 136.6,65.89 136.9,66.19 137.44,66.19 138.03,65.59 138.03,65.26 137.93,65.16 137.66,65.16 137.56,65.06 137.56,64.91 v1(137.65,64.82)
USB3_ATX_DRX_0_N2: length 158.9
  TOP w0.112: CU15.2 19.19,39.29 19.03,39.29 18.92,39.4 18.92,39.99 v1(19.19,40.26)
  IN1 w0.119: v1(139.7,64.77) 139.47,64.99 139.31,64.99 139.19,64.87 139.19,64.28 139.42,64.05 139.42,63.24 138.97,62.78 136.94,62.78 135.87,61.71 135.87,59.45 135,58.58 135,57.14 134.9,57.04 134.9,56.43 134.37,55.9 134.37,55.11 134.9,54.59 134.9,53.45 135.64,52.7 135.64,51.94 136.02,51.56 136.02,49.11 130.81,43.9 128.37,43.9 126.97,42.51 126.97,40.62 126.29,39.94 126.29,39.75 123.95,37.41 122.25,37.41 120.4,35.56 118.62,35.56 117.8,34.74 116.06,34.74 115.43,34.11 109.76,34.11 109.43,34.45 108.69,34.45 107.98,35.16 105.47,35.16 105.22,34.91 100.48,34.91 99.86,34.29 91.85,34.29 91.78,34.22 73.67,34.22 72.4,35.49 71.9,35.98 64.37,35.98 63.95,36.41 61.77,36.41 61.41,36.77 60.55,36.77 58.37,38.95 57.26,38.95 56.86,39.34 55.71,39.34 54.2,40.86 42.83,40.86 41.67,42.02 38.44,42.02 37.82,41.4 31.76,41.4 29.07,38.71 27.33,38.71 26.75,38.12 22.61,38.12 19.72,41.02 18.98,41.02 18.86,40.9 18.86,40.71 18.93,40.64 19.11,40.64 19.23,40.52 19.23,40.31 v1(19.19,40.26)
  BOTTOM w0.102: UC1.AG2 136.14,66.81 137.7,66.81 139.54,64.97 139.54,64.93 v1(139.7,64.77)
USB3_ATX_DRX_0_P1: length 182.7
  TOP w0.112: CU8.2 24.84,59.91 25.3,59.91 v1(25.35,59.97)
  IN1 w0.119: v1(138.24,64.82) 138.24,64.82 138.24,64.17 137.98,63.91 136.02,63.91 135.39,63.28 135.39,62.48 135.05,62.13 135.05,60.7 135.04,60.7 135.02,60.7 134.79,60.47 134.79,59.77 134.22,59.2 134.22,57.46 133.4,56.64 133.4,54.88 134.12,54.17 134.12,53.06 134.86,52.32 134.86,51.61 135.24,51.22 135.24,50.03 133.21,48 127.47,48 127.17,47.71 127.17,46.62 127.42,46.37 127.42,44.06 126.08,42.72 126.08,41.64 125.51,41.07 125.02,41.07 122.63,38.68 121.17,38.68 119.53,37.04 118.42,37.04 116.94,35.56 115.77,35.56 115.1,34.89 110.98,34.89 109.08,36.8 108.13,36.8 107.81,36.47 106.42,36.47 106.29,36.6 101.07,36.6 99.87,35.4 73.59,35.4 72.67,36.32 72.22,36.76 64.69,36.76 64.27,37.19 62.09,37.19 61.73,37.55 60.87,37.55 58.69,39.73 57.59,39.73 57.19,40.12 56.04,40.12 54.52,41.64 43.16,41.64 42,42.8 37.77,42.8 37.46,43.11 32.37,43.11 28.86,39.59 27.05,39.59 26.36,38.9 23.78,38.9 23.51,39.17 23.51,40.26 24.65,41.41 28.1,41.41 29.92,43.22 29.92,51.26 25.53,55.65 23.65,55.65 22.63,56.66 22.63,58.87 23.74,59.97 v1(25.35,59.97)
  BOTTOM w0.089: UC1.AG3 136.39,66.61 136.8,66.61 136.84,66.57
  BOTTOM w0.102: 136.84,66.57 137.01,66.39 137.52,66.39 138.24,65.68 v1(138.24,64.82)
USB3_ATX_DRX_0_P2: length 159
  TOP w0.112: CU16.2 18.65,39.77 18.65,40.21 v1(18.6,40.26)
  IN1 w0.119: v1(18.6,40.26) 18.6,41 18.87,41.27 19.82,41.27 22.71,38.38 26.64,38.38 27.22,38.96 28.97,38.96 31.66,41.65 37.71,41.65 38.33,42.27 41.78,42.27 42.94,41.11 54.3,41.11 55.82,39.6 56.97,39.6 57.37,39.2 58.47,39.2 60.65,37.02 61.51,37.02 61.87,36.66 64.05,36.66 64.48,36.24 72,36.24 72.5,35.74 73.77,34.47 91.68,34.47 91.75,34.54 99.75,34.54 100.38,35.17 105.12,35.17 105.36,35.41 108.09,35.41 108.79,34.7 109.53,34.7 109.87,34.37 115.32,34.37 115.95,35 117.69,35 118.51,35.81 120.3,35.81 122.15,37.66 123.85,37.66 126.04,39.85 126.04,40.04 126.72,40.72 126.72,42.61 128.26,44.16 130.71,44.16 135.77,49.22 135.77,51.45 135.38,51.84 135.38,52.6 134.64,53.34 134.64,54.49 134.12,55.01 134.12,56.01 134.65,56.53 134.65,57.15 134.75,57.25 134.75,58.69 135.61,59.56 135.61,61.81 136.84,63.04 138.86,63.04 139.17,63.35 139.17,63.94 138.93,64.18 138.93,64.98 139.2,65.25 139.6,65.25 139.7,65.35 v1(139.7,65.35)
  BOTTOM w0.089: UC1.AG4 136.07,67.1
  BOTTOM w0.102: 136.07,67.1 136.24,67.1 136.48,67.01 137.79,67.01 139.45,65.35 v1(139.7,65.35)
USB3_ATX_L_DRX_0_N1: length 11.1
  TOP w0.112: JUSB1.8 14.38,55.82 14.56,56 14.92,56 15.25,55.67 16.24,55.67 17.17,56.6 17.17,58.61 v2(17.55,58.99) 17.78,59.22 18.54,59.22 18.66,59.11 EU3.7 EU3.4 20.35,59.11 20.46,59.22 20.72,59.22 20.92,59.43 21.06,59.43 21.18,59.31 LU2.4 21.61,59.14 RU3.2
USB3_ATX_L_DRX_0_N2: length 9.9
  TOP w0.112: JUSB2.8 14.39,31.26 14.39,31.82 14.5,31.94 15.15,31.94 15.34,31.75 18.2,31.75 v2(18.7,32.25) 19.1,32.65 19.1,33.24 19.22,33.35 EU5.7 EU5.4 19.22,35.04 19.1,35.16 19.1,35.59 19,35.7 19,35.97 19.08,36.06 LU5.4 19.25,36.5 RU9.2
USB3_ATX_L_DRX_0_P1: length 11.1
  TOP w0.112: RU4.2 21.61,59.98 LU2.1 21.18,59.81 21.06,59.69 20.81,59.69 20.61,59.49 20.49,59.49 20.37,59.61 EU3.5 EU3.6 18.66,59.61 18.54,59.49 17.67,59.49 16.9,58.72 v2(16.9,57.88) 16.9,56.71 16.13,55.94 15.36,55.94 15.03,56.27 14.56,56.27 14.38,56.45 JUSB1.9
USB3_ATX_L_DRX_0_P2: length 9.9
  TOP w0.112: RU10.2 18.41,36.5 LU5.1 18.58,36.06 18.73,35.91 18.73,35.59 18.84,35.49 18.84,35.12 18.72,35 EU5.5 EU5.6 18.72,33.35 18.84,33.24 18.84,32.76 18.52,32.44 18.09,32.01 v2(17.24,32.01) 15.45,32.01 15.26,32.2 14.5,32.2 14.39,32.31 14.39,33.24 JUSB2.9
USB3_DP3_MRX_C_RD_DTX_N0: length 3
  BOTTOM w0.102: 22.83,124.77 22.81,124.75 22.81,124.75 22.59,124.53 22.08,124.53 22.01,124.46 UT9.10
  BOTTOM w0.112: CT38.2 23.96,125.03 v2(23.31,125.03) 23.09,125.03 22.83,124.77
USB3_DP3_MRX_C_RD_DTX_N3: length 3.3
  BOTTOM w0.102: UT9.18 22.23,121.26 22.3,121.19 22.55,121.19 22.77,120.97 22.78,120.97 22.79,120.96
  BOTTOM w0.112: 22.79,120.96 23.74,120.01 24.02,120.01 CT40.2
USB3_DP3_MRX_C_RD_DTX_P0: length 3
  BOTTOM w0.102: UT9.9 21.98,124.86 22.05,124.79 22.49,124.79 22.63,124.93 22.63,124.93 22.64,124.95 22.64,124.95
  BOTTOM w0.112: 22.64,124.95 22.98,125.29 23.97,125.29 CT37.2
USB3_DP3_MRX_C_RD_DTX_P3: length 3.3
  BOTTOM w0.102: 22.61,120.77 22.59,120.79 22.59,120.79 22.45,120.93 22.3,120.93 22.23,120.86 UT9.19
  BOTTOM w0.112: CT39.2 24.28,119.38 23.91,119.75 23.63,119.75 v2(22.95,120.42) 22.61,120.77
USB3_DP3_MRX_DTX_N0: length 167.3
  IN1 w0.119: v1(142.18,69.92) 142.38,69.92 142.5,69.8 142.5,69.69 142.6,69.59 142.72,69.59 142.84,69.71 142.84,70.84 142.73,70.95 142.73,73.22 141.84,74.11 141.84,76.86 141.73,76.97 141.73,80.46 142.61,81.33 142.61,90.7 136.99,96.32 135.92,96.32 130.8,101.44 127.17,101.44 121.71,106.9 121.71,108.17 117.64,112.24 117.28,112.24 117.13,112.39 114.1,112.39 114.02,112.48 112.62,112.48 112.2,112.9 108.25,112.9 105.05,116.1 100.84,116.1 99.48,117.47 92.19,117.47 91.58,118.08 87.29,118.08 87.16,118.21 86.56,118.21 85.47,119.31 81.62,119.31 80.68,120.25 76.95,120.25 76.28,120.91 73.55,120.91 72.35,119.72 70.59,119.72 69.92,120.38 67.52,120.38 67.12,120.77 61.41,120.77 60.23,119.59 57.21,119.59 56.42,118.8 54.7,118.8 53.25,117.34 52.6,117.34 51.92,118.02 38.97,118.02 38.67,118.32 34.33,118.32 31.85,120.8 31.85,121.13 27.83,125.15 27.21,125.15 27.09,125.03 27.09,124.77 26.95,124.64 26.71,124.64 26.59,124.76 v1(26.59,124.82)
  BOTTOM w0.089: UC1.AE1 136.6,68.31 136.78,68.49
  BOTTOM w0.102: 136.78,68.49 137.52,68.49 138.54,69.52 139.88,69.52 140.35,69.98 141.41,69.98 141.78,69.6 141.92,69.6 142.02,69.7 142.02,69.82 142.12,69.92 v1(142.18,69.92)
  BOTTOM w0.112: v1(26.59,124.82) 26.27,125.14 25.94,125.14 25.86,125.06 25.86,124.5 25.75,124.39 25.43,124.39 25.19,124.63 CT38.1
USB3_DP3_MRX_DTX_N3: length 159.7
  IN1 w0.119: v1(25.8,120.12) 25.98,119.95 26.08,119.95 26.19,120.06 27.28,120.06 29.21,118.13 29.63,118.13 32.7,115.07 37.28,115.07 37.78,115.56 42.96,115.56 43.68,114.85 56.69,114.85 58.39,116.54 58.75,116.54 59.2,117 63.2,117 64.41,118.21 67.76,118.21 68.73,117.24 70.92,117.24 71.78,116.39 73.76,116.39 75.03,117.65 78.28,117.65 78.52,117.41 79.17,117.41 79.64,116.93 81.21,116.93 81.5,117.22 84.6,117.22 86.77,115.06 92.24,115.06 92.43,115.25 98.46,115.25 99.69,114.02 103.71,114.02 108.32,109.41 115.29,109.41 115.57,109.69 117.24,109.69 119.06,107.86 119.06,106.42 120.26,105.22 121.82,101.31 123.78,99.36 129.93,99.36 130.39,98.9 135.05,94.24 136.12,94.24 140.52,89.83 140.52,82.2 139.64,81.32 139.64,76.86 138.91,76.12 138.91,74.67 139.39,74.19 139.39,72.57 138.41,71.59 138.41,70.99 138.59,70.81 138.69,70.81 v1(138.87,70.99)
  BOTTOM w0.102: UC1.AC4 135.99,70.1 136.32,70.1 136.5,69.92 137.07,69.92 138.14,70.99 v1(138.87,70.99)
  BOTTOM w0.112: v1(25.8,120.12) 25.66,119.98 25.48,119.98 CT40.1
USB3_DP3_MRX_DTX_P0: length 167.3
  IN1 w0.119: v1(26.59,125.41) 27.94,125.41 32.11,121.24 32.11,120.9 34.43,118.58 38.77,118.58 39.07,118.27 52.03,118.27 52.7,117.6 53.14,117.6 54.6,119.06 56.32,119.06 57.11,119.85 60.13,119.85 61.31,121.03 67.23,121.03 67.62,120.63 70.03,120.63 70.69,119.97 72.25,119.97 73.44,121.17 76.39,121.17 77.05,120.5 80.79,120.5 81.73,119.56 85.57,119.56 86.67,118.47 87.26,118.47 87.39,118.34 91.69,118.34 92.3,117.72 99.58,117.72 100.95,116.36 105.15,116.36 108.36,113.15 112.31,113.15 112.73,112.73 114.12,112.73 114.2,112.65 117.23,112.65 117.39,112.49 117.74,112.49 121.96,108.27 121.96,107.01 127.27,101.7 130.91,101.7 136.03,96.58 137.09,96.58 142.86,90.8 142.86,81.23 141.98,80.35 141.98,77.07 142.1,76.96 142.1,74.22 142.99,73.33 142.99,71.05 143.09,70.95 143.09,69.61 142.83,69.34 v1(142.18,69.34)
  BOTTOM w0.102: v1(142.18,69.34) 142.12,69.4 141.7,69.4 141.32,69.78 140.43,69.78 139.97,69.31 138.63,69.31 137.6,68.28 136.92,68.28 136.65,68.01 136.4,68.01 UC1.AE3
  BOTTOM w0.112: v1(26.59,125.41) 26.58,125.41 25.39,125.41 CT37.1
