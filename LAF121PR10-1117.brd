# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
APU_TEST5: length 1.3
  TOP w0.099: v1(127.73,60.91) 127.56,60.91 T6.1
  BOTTOM w0.25: v1(127.73,60.91) 127.33,61.31 UC1.AN14
APU_TEST6: length 2.3
  TOP w0.089: T7.1 129.12,85.71
  TOP w0.099: 129.12,85.71 128.81,85.4 128.81,84.39 v1(128.73,84.31)
  BOTTOM w0.1: v1(128.73,84.31) 128.43,84.01 UC1.F13
APU_TEST14: length 14
  TOP w0.089: RPC30.8 124.21,92.91 124.36,92.76 T8.1 125.1,93.18 v1(125.1,93.22)
  IN2 w0.089: v1(124.66,83.69) 125,84.03 125,85.04 126.11,86.15 126.11,88.93 126.65,89.47 126.65,90.84 126.02,91.47 126.02,92.46 125.26,93.22 v1(125.1,93.22)
  BOTTOM w0.089: UC1.G18 124.28,83.31 v1(124.66,83.69)
APU_TEST15: length 15.3
  TOP w0.089: v1(125.28,92.66) 125.07,92.45 123.61,92.45 T9.1 123.35,93.21 123.71,93.57 RPC30.7
  IN2 w0.089: v1(125.28,92.66) 125.81,92.13 125.81,89.36 125.93,89.24 125.93,86.23 124.76,85.06 124.68,85.06 124.11,84.48 124.11,83.33 v1(123.66,82.88)
  BOTTOM w0.1: UC1.H19 123.33,82.51 123.66,82.83 v1(123.66,82.88)
APU_TEST16: length 11.9
  TOP w0.089: 123.42,85.71 122.24,86.9 122.24,92.73 123.21,93.7 RPC30.6
  TOP w0.099: 123.42,85.71 123.8,85.34 T10.1 124.42,84.33 124.56,84.33 v1(124.63,84.4)
  BOTTOM w0.1: v1(124.63,84.4) 124.63,84.2 124.43,84.01 UC1.F18
APU_TEST17: length 11.6
  TOP w0.089: 122.72,85.71 T11.1 121.95,86.48 121.95,92.71 122.71,93.46 RPC30.5
  TOP w0.099: 122.72,85.71 122.78,85.66 122.78,85.02 123.49,84.31 v1(123.73,84.31)
  BOTTOM w0.1: UC1.F19 123.43,84.01 v1(123.73,84.31)
APU_TEST31: length 1.8
  TOP w0.099: T12.1 119.22,74.55 119.23,74.54 v1(119.23,73.81)
  BOTTOM w0.102: v1(119.23,73.81) 118.83,73.41 UC1.W24
APU_TEST41: length 1.4
  TOP w0.099: T13.1 129.42,58.97 v1(129.76,59.3)
  BOTTOM w0.1: v1(129.76,59.3) 130.11,59.3 130.23,59.43 UC1.AR11
APU_TEST470: length 1.4
  TOP w0.099: v1(120.83,64.81) 120.83,65.01 T14.1
  BOTTOM w0.1: UC1.AJ21 121.23,65.21 v1(120.83,64.81)
APU_TEST471: length 1.3
  TOP w0.099: T15.1 121.23,64.21 v1(120.83,63.81)
  BOTTOM w0.1: v1(120.83,63.81) 121.23,64.21 T15.1
APU_TMS: length 135.3
  TOP w0.089: v1(222.55,59.92) 223.33,60.7 223.33,63.35 RH27.1 223.33,63.77 223.33,64.31 223.37,64.35 RPH1.2
  IN2 w0.089: v1(140.08,57.91) 139.87,58.11 139.32,58.11 138.98,57.77 138.98,56.49 139.25,56.22 139.71,56.22 142.1,53.83 142.1,46.09 142.83,45.37 142.83,45.02 149.43,38.41 151.24,38.41 153.64,36.02 161.91,36.02 163.95,33.98 167.44,33.98 167.53,34.08 169.62,34.08 170.41,33.29 175.08,33.29 177.91,36.12 179.79,36.12 180.51,35.4 187.14,35.4 188.59,36.85 190.25,36.85 190.58,37.18 191.65,37.18 192.04,36.8 193.3,36.8 195.57,34.53 198.82,34.53 199.45,35.16 201.37,35.16 201.52,35 203.69,35 204.14,34.55 207,34.55 207.2,34.75 211.01,34.75 214.65,38.39 214.92,38.39 215.86,39.33 215.86,42.12 216.11,42.38 216.11,42.9 218.41,45.2 220.2,45.2 220.69,45.69 220.69,49.81 219.7,50.8 219.7,54.56 222.31,57.18 222.31,59.68 v1(222.55,59.92)
  BOTTOM w0.089: UC1.AU3 136.07,58.31 136.37,58.61 136.64,58.61 136.75,58.49 139.5,58.49 v1(140.08,57.91)
APU_TRST#: length 143.3
  TOP w0.089: v1(220.84,53.41) 220.98,53.27 225.65,53.27 226.3,53.92 v4(226.3,55.37) CC251.1 CH2.1 RH26.1 RH21.1
  IN2 w0.089: v1(140.04,58.67) 139.91,58.8 139.38,58.8 138.4,57.82 138.4,55.54 138.67,55.26 138.67,53.94 141.25,51.37 141.25,45.62 142.07,44.79 142.07,44.52 148.91,37.68 150.94,37.68 153.49,35.13 160.3,35.13 162.05,33.38 163.17,33.38 163.3,33.25 167.74,33.25 167.84,33.35 168.89,33.35 169.68,32.56 175.38,32.56 178.21,35.39 179.49,35.39 180.21,34.67 183.08,34.67 183.65,34.1 183.98,34.1 184.32,34.44 184.96,34.44 185.3,34.1 186.88,34.1 188.9,36.12 190.55,36.12 190.88,36.45 191.35,36.45 191.59,36.21 191.59,35.68 192.21,35.05 194.01,35.05 195.45,33.61 201.77,33.61 202.21,34.05 203.6,34.05 203.86,33.8 207.28,33.8 207.5,34.02 211.5,34.02 212.14,34.66 215,34.66 216.59,36.25 216.59,41.82 216.84,42.07 216.84,42.6 217.61,43.36 220.86,43.36 221.42,43.93 221.42,50.11 221.17,50.36 221.17,53.08 v1(220.84,53.41)
  BOTTOM w0.089: UC1.AV3 136.12,57.31 136.54,56.89 138.28,56.89 138.96,56.21 139.9,56.21 140.75,57.06 140.75,58.29 140.27,58.77 140.13,58.77 v1(140.04,58.67)
APU_TRST#_R: length 1.5
  TOP w0.089: T100.1 224.79,59.94 RH21.2
APU_USBC_SCL: length 23.3
  TOP w0.089: QC3.4 145.85,69.72 RC94.2 146,69.87 146.68,69.87 147.23,69.32 v3(147.23,66.87) 147.23,65.91 v1(147.79,65.35)
  IN2 w0.089: v1(147.79,65.35) 147.79,65.3 147.16,64.68 142.63,64.68 142.19,64.23 136.7,64.23 134.83,62.37 134.04,62.37 133.57,62.84 v1(133.57,62.9)
  BOTTOM w0.089: UC1.AM6 133.93,62.35 133.57,62.71 v1(133.57,62.9)
APU_USBC_SDA: length 15.1
  TOP w0.089: QC3.1 144.55,66.6 144.36,66.42 RC95.2 144.28,65.96 v3(142.86,65.96) 140.87,63.97 136.78,63.97
  TOP w0.099: 136.78,63.97 136.09,63.28 134.49,63.28 133.73,62.52 133.37,62.52 133.02,62.87 132.92,62.87 v1(132.86,62.92)
  BOTTOM w0.1: UC1.AM7 133.23,62.37 132.89,62.71 132.89,62.89 v1(132.86,62.92)
APU_VDD_RUN_FB_L: length 33.8
  TOP w0.089: v1(123.89,89.77) 123.73,89.62 RC19.1
  BOTTOM w0.089: v1(123.89,89.77) 123.89,89.71 125.01,88.58 129.19,88.58 129.85,89.24 130.75,89.24 132.92,91.41 147.39,91.41 147.67,91.69 148.29,91.69 148.58,91.41 149.14,91.41 150.12,90.43 150.76,90.43 151.47,89.72 PRZ43.1
  BOTTOM w0.254: T17.1 150.28,89.8 PRZ40.2 150.29,89.09 PRZ43.1
APU_VDDCR_SEN: length 66.9
  TOP w0.099: T18.1 125.13,81.58 v1(124.81,81.26)
  TOP w0.254: v1(146.3,82.37) PRZ37.1 147,82.39 PRZ38.2
  IN2 w0.089: v1(127.77,105.57) 127.78,105.58 129.19,105.58 130.63,107.02 132.47,107.02 135.18,104.31 138.85,104.31 140.92,102.24 140.92,98.94 145.6,94.25 145.6,89.73 147.2,88.13 147.2,84.66 147.11,84.56 147.11,84.18 146.75,83.82 146.75,83.48 146.3,83.03 v1(146.3,82.37)
  IN3 w0.089: 125.63,86.1 126.23,86.7 126.23,89.01 126.63,89.4 126.63,90.87 126.95,91.19 126.95,92.27 127.66,92.98 127.66,105.46 v1(127.77,105.57)
  IN3 w0.099: 125.63,86.1 125.19,85.66 125.19,81.72 124.81,81.34 v1(124.81,81.26)
  BOTTOM w0.127: UC1.K18 124.33,80.91 124.66,81.24 124.79,81.24 v1(124.81,81.26)
APU_VDDSOC_SEN: length 72.2
  TOP w0.089: v1(128.71,104.29) 128.71,104.68 128.66,104.73 128.66,104.92 128.89,105.15 135.14,105.15 v1(135.73,105.74)
  TOP w0.099: PRZ02.2 123.06,82.67 v1(123.68,82.05) 124.04,82.42 T16.1
  IN2 w0.089: v1(135.73,105.74) 135.92,105.55 139.31,105.55 139.52,105.34 139.55,105.34 142.09,102.8 142.09,99.56 147.74,93.91 151.67,93.91 152.17,93.41 158.97,93.41 159.74,92.64 162.66,92.64 v1(162.86,92.85) ; v1(123.68,82.05) 124.07,82.05 124.54,82.53 125,82.53 125.19,82.72 125.19,84.97 126.3,86.08 126.3,87.41 127.43,88.54 127.43,91.08 127.23,91.28 127.23,92.12 126.79,92.55 126.37,92.55 125.75,93.17 125.75,94.03 128.71,96.98 v1(128.71,104.29)
  BOTTOM w0.127: UC1.J19 123.33,81.71 v1(123.68,82.05)
  BOTTOM w0.254: PRZ06.1 v1(162.86,92.85)
AUD_HP1_JACK_L1: length 24.2
  TOP w0.254: v1(22.64,22.02) 22.7,21.95 22.7,21.85
  TOP w0.305: RA25.2 22.7,21.85 ; RA26.2 RA24.2 19.9,11.3 19.72,11.3 19.4,10.98 v1(19.4,10.66)
  IN1 w0.254: v1(19.4,10.66) 18.89,11.17 18.89,12.06 20.23,13.39 20.8,13.39 21.62,14.22 21.62,18.09 22.64,19.11 v1(22.64,22.02)
  BOTTOM w0.254: v1(22.64,22.02) 22.64,21.86 22.18,21.39 20.28,21.39 19.52,20.63 15.77,20.63 15.52,20.38 LA7.1
AUD_HP1_JACK_R1: length 23.6
  TOP w0.254: v1(23.53,22.02) 23.47,21.95 23.47,21.92 ; RA27.2 v1(20.02,10.03)
  TOP w0.305: RA29.2 19.85,12.95 19.4,12.5 v1(19.4,11.74) ; RA28.2 23.47,21.47 23.47,21.92
  IN1 w0.254: v1(23.53,22.02) 23.28,21.76 23.28,18.35 22.26,17.33 22.26,14.03 20.99,12.76 20.42,12.76 v1(19.4,11.74) 19.97,11.17 19.97,10.08 v1(20.02,10.03)
  BOTTOM w0.254: v1(23.53,22.02) 23.53,21.46 22.86,20.79 20.53,20.79 19.81,20.06 LA8.1
AUD_PORTA_L_R_B: length 14.9
  IN3 w0.254: v1(16.48,16.89) 14.45,14.85 14.45,8.15 14.19,7.9 JHP1.1
  BOTTOM w0.254: LA7.2 RA32.1 CA40.1 16.43,17.8 17.12,17.12 v1(17.12,16.89)
  vias: v3(16.54,17.97)
AUD_PORTA_R_R_B: length 16
  IN3 w0.254: JHP1.2 8.23,17.4 9.24,18.41 13.94,18.41 14.83,17.52 18.07,17.52 18.59,17 v1(18.59,16.87)
  BOTTOM w0.254: v1(18,16.89) 17.29,17.6 CA39.1 RA31.1 LA8.2
  vias: v3(18.2,18.03)
AUD_SENSE_A: length 4.4
  TOP w0.089: CA48.1 31.3,18.52 v3(31.64,18.18)
  TOP w0.203: UA1.13 29.48,17.32 RA10.1 29.8,18.11 29.71,18.2 29.71,18.48 RA41.1 CA48.1
BATGONE_CHG: length 5.1
  TOP w0.254: PRB25.1 208.19,45.44 PCB34.1 PRB24.1 v3(206.74,47.25) 207.22,47.73 v1(207.38,47.73)
  BOTTOM w0.203: v1(207.38,47.73) 206.94,47.29 PUB01.25
BATT_CHG_LED: length 69.8
  TOP w0.089: Q16.1 48.93,93.98 49.31,94.36 49.31,95.75 49.68,96.12 v1(50.95,96.12) ; v1(20.04,131.69) v3(20.04,131.05)
  IN3 w0.089: v1(20.04,131.69) 21.03,132.69 35.87,132.69 42.24,126.32 45.59,126.32 46.68,125.23 46.68,122.84 47.49,122.02 47.49,118.18 49.94,115.74 49.94,107.13 50.26,106.8 50.26,96.96 50.95,96.27 v1(50.95,96.12)
  BOTTOM w0.089: R69.2 19.34,132.39 v1(20.04,131.69)
BATT_CHG_LED#: length 38.9
  TOP w0.089: v3(47.52,96.35) 47.11,96.35 46.47,97 Q14.4 46.47,98.1 46.26,98.31 v1(45.9,98.31) ; v1(45.63,66.49) 45.52,66.49 45.35,66.66 UE1.21
  IN2 w0.089: v1(45.63,66.49) 45.56,66.55 45.56,67.66 45.81,67.91 45.81,71.82 45.94,71.95 45.94,72.26 45.68,72.53 45.58,72.53 45.19,72.92 45.19,74.09 45.24,74.14 45.24,75.02 44.2,76.06 44.2,79.16 43.96,79.41 43.96,82.12 43.81,82.27 43.81,84.84 44.57,85.61 44.57,87.98 45.21,88.62 45.21,93.6 44.57,94.24 44.57,96.49 45.8,97.73 45.8,98.21 v1(45.9,98.31)
BATT_CHG_LED_R#: length 8.2
  TOP w0.089: Q14.3 46.47,94.83 46.3,94.66 Q17.1 47.2,93.01 Q16.2 v3(52.22,93.01)
BATT_I: length 262.1
  TOP w0.089: v1(217.75,42.5) 217.67,42.58 216.21,42.58 216.06,42.73 213.65,42.73 213.3,43.08 213.04,43.08 212.9,43.22 211.83,43.22 211.65,43.4 211.65,46.33 211.54,46.44 v1(211.47,46.44) ; v1(40.75,80.33) 40.84,80.42 41.71,80.42 42.75,81.46 45.65,81.46 46.05,81.85 46.05,82.4 45.75,82.7 UE1.75
  IN2 w0.089: v1(40.75,80.33) 40.75,80.13 40.19,79.57 40.19,77.21 39.68,76.71 39.68,75.5 40.42,74.76 40.42,73.3 39.46,72.35 39.46,71.66 39.06,71.26 39.06,68.23 38.56,67.73 38.56,64.52 38.64,64.44 38.64,58.26 42.27,54.64 42.27,53.59 45.16,50.69 45.16,39.46 48.31,36.32 54.29,36.32 59.75,30.86 59.75,29.72 60.7,28.78 61.97,28.78 62.71,29.51 65.96,29.51 67.46,28.02 83.29,28.02 83.97,27.34 96.84,27.34 97.62,28.12 99.55,28.12 99.75,27.91 110.04,27.91 110.61,28.48 111.86,28.48 112.42,27.91 116.56,27.91 117.42,28.78 120.24,28.78 121.11,27.91 125.18,27.91 128.81,31.54 135.85,31.54 137.71,33.4 145.1,33.4 146.47,32.03 146.47,31.65 148.92,29.2 150.99,29.2 151.32,28.87 163.36,28.87 163.79,29.29 168.79,29.29 169,29.5 172.98,29.5 173.51,28.96 175.18,28.96 175.8,29.58 178.79,29.58 180.62,31.41 181.37,31.41 181.48,31.3 186.85,31.3 188.59,33.04 190.31,33.04 191.64,31.71 197.64,31.71 197.81,31.88 202.44,31.88 202.68,32.12 203.18,32.12 203.62,31.68 204.28,31.68 204.51,31.45 211.07,31.45 211.84,32.22 213.71,32.22 214.22,32.73 215.07,32.73 217.3,34.96 217.3,35.55 217.83,36.08 217.83,40.34 217.38,40.79 217.38,41.23 217.79,41.64 217.79,42.45 217.75,42.49 v1(217.75,42.5)
  BOTTOM w0.102: PRB34.2 211.65,45.1 211.65,46.26 v1(211.47,46.44)
BATT_LOW_LED: length 66.6
  TOP w0.089: v1(19.4,131.69) 19.4,132.08 v3(19.64,132.32) ; Q15.1 50.8,97.98 v1(50.94,97.84)
  IN3 w0.089: v1(50.94,97.84) 50.69,98.09 50.69,115.27 47.68,118.28 47.68,122.1 46.86,122.92 46.86,125.31 45.67,126.5 42.31,126.5 35.94,132.87 20.58,132.87 v1(19.4,131.69)
  BOTTOM w0.089: R68.2 16.68,131.76 19.34,131.76 v1(19.4,131.69)
BATT_LOW_LED#: length 17.1
  TOP w0.089: Q14.1 45.17,89.38 v3(44.53,88.74) 44.4,88.6 40.88,88.6 39.45,87.18 39.45,86.61 39.36,86.52 39.36,85.52 38.55,84.72 UE1.93
BATT_LOW_LED_R#: length 6.8
  TOP w0.089: Q14.6 45.17,98.47 45.38,98.69 v3(46.44,98.69) 48.12,97.01 Q15.2
BATT_TEMP: length 286.9
  TOP w0.089: CE11.2 52.98,81.85 52.54,81.41 UE1.63 50.46,81.41 49.7,80.65 44.26,80.65 42.85,79.24 41.23,79.24 v1(40.9,78.91) ; PRB25.2 209.15,45.38 211.68,42.85 212.75,42.85 212.89,42.71 213.15,42.71 213.65,42.21 214.17,42.21 214.32,42.06 216.55,42.06 216.9,41.7 216.9,41.7 v1(216.96,41.63)
  TOP w0.254: PD6.2 170.52,41.46 170.29,41.69 170.29,42.06 PR41.1 170.66,42.07 170.72,42.01 171.18,42.01 171.22,42.05 171.92,42.05 PR39.2 172.64,42.77 v1(172.64,43.28) ; PC14.1 176.89,28.14 174.91,28.14 v3(174.63,28.42) 173.77,29.29 v1(173.77,29.56)
  IN2 w0.089: v1(40.9,78.91) 40.55,78.56 40.55,77.06 40.05,76.55 40.05,75.65 40.78,74.91 40.78,73.15 39.83,72.19 39.83,71.51 39.66,71.34 39.66,70.68 39.99,70.34 39.99,70.03 39.43,69.47 39.43,68.08 38.93,67.57 38.93,64.76 39,64.68 39,59.21 39.16,59.05 39.16,58.26 42.63,54.79 42.63,53.74 45.53,50.84 45.53,39.61 48.23,36.91 54.22,36.91 60.12,31.01 60.12,29.87 60.85,29.14 61.82,29.14 62.56,29.88 66.28,29.88 67.36,28.79 83.25,28.79 84.28,27.76 96.75,27.76 97.49,28.5 99.68,28.5 99.9,28.28 109.89,28.28 110.46,28.85 113.99,28.85 114.56,28.28 116.41,28.28 117.27,29.14 120.39,29.14 121.26,28.28 125.03,28.28 128.65,31.9 135.7,31.9 137.56,33.77 145.25,33.77 146.83,32.18 146.83,31.8 149.07,29.56 151.14,29.56 151.47,29.24 163.21,29.24 163.63,29.66 168.64,29.66 168.85,29.87 173.46,29.87 v1(173.77,29.56) 174.19,29.99 175.31,29.99 175.35,29.94 178.64,29.94 180.47,31.77 181.64,31.77 181.75,31.67 186.59,31.67 189.53,34.6 190.01,34.6 190.35,34.26 190.35,33.52 191.79,32.08 197.49,32.08 197.66,32.25 202.29,32.25 202.53,32.49 203.33,32.49 203.78,32.04 205.97,32.04 206.4,32.47 206.6,32.47 207.25,31.82 210.47,31.82 211.23,32.59 213.56,32.59 214.07,33.09 214.8,33.09 216.93,35.22 216.93,35.7 217.46,36.24 217.46,40.19 216.96,40.69 216.96,41.63 v1(216.96,41.63)
  BOTTOM w0.254: v1(173.77,29.56) 173.12,30.21 173.12,34.04 173.61,34.53 173.61,38.88 173.52,38.97 173.52,41.89 172.64,42.77 v1(172.64,43.28)
BEEP#: length 77.4
  TOP w0.089: DA3.2 34.4,20.11 34.18,20.33 34.18,21.79 33.4,22.57 31.77,22.57 v3(31.55,22.8) 30.66,23.68 30.66,27.59 30.31,27.94 30.31,28.3 30.53,28.51 v1(30.53,28.59) ; v1(40.23,71.14) 40.65,70.72 41.67,70.72 42.19,70.21 42.49,69.91 45.96,69.91 46.33,69.54 46.33,68.88 46.15,68.71 UE1.23
  IN1 w0.089: v1(40.23,71.14) 39.01,71.14 38.49,71.66 34.61,71.66 v1(34.53,71.59)
  IN2 w0.089: v1(30.53,28.59) 30.62,28.68 31.34,28.68 32.2,29.54 32.2,30.6 38.46,36.86 38.46,39.83 37.71,40.58 37.71,42.55 37.33,42.93 37.33,44.52 39.43,46.63 39.43,52 38.93,52.5 38.93,53.85 35.34,57.44 35.34,60.55 33.71,62.18 33.71,68.72 34.79,69.8 34.79,71.32 v1(34.53,71.59)
BGATE_CHG: length 82.2
  IN1 w0.089: v1(208.4,42) 202.16,42 201.79,41.63 192.87,41.63 191.49,40.25 182.35,40.25 181.2,41.4 179.07,41.4 178.95,41.28 174.29,41.28 173.56,40.56 165.95,40.56 165.7,40.3 156.65,40.3 155.93,41.02 154.52,41.02 153.51,42.03 v1(153.51,42.67)
  BOTTOM w0.203: v1(208.4,42) 208.34,42.06 207.91,42.06 206.84,43.12 206.84,44.35 206.7,44.49 PUB01.32
  BOTTOM w0.254: v1(153.51,42.67) 152.82,42.67 152.56,42.41 148.35,42.41 146.38,40.44 146.38,37.55 145.25,36.42 145.25,31.91 v3(145.6,31.56) 146.27,30.89 PCB33.1 146.86,31.11 147.85,31.11 148,30.96 PQB03.4
BKOFF#: length 253.3
  TOP w0.089: DX1.2 212.62,43.76 213.12,43.26 213.38,43.26 213.72,42.91 v3(216.54,42.91) 216.88,42.91 217.08,43.12 217.94,43.12 v1(218.07,42.98) ; UE1.105 38.56,78.61 39.02,78.15 39.52,78.15 v1(39.63,78.03)
  IN2 w0.089: v1(218.07,42.98) 218.15,42.91 218.15,41.74 217.56,41.15 217.56,40.87 218.01,40.42 218.01,36.01 217.48,35.48 217.48,34.88 215.14,32.54 214.29,32.54 213.79,32.04 211.91,32.04 211.15,31.27 204.43,31.27 204.21,31.49 203.55,31.49 203.14,31.9 202.71,31.9 202.51,31.7 197.88,31.7 196.96,30.77 191.8,30.77 189.91,32.67 188.73,32.67 187,30.93 181.76,30.93 180.03,29.21 175.95,29.21 175.34,28.6 173.36,28.6 172.82,29.14 169.15,29.14 168.94,28.93 166.82,28.93 165.58,27.68 151.73,27.68 150.76,28.65 148.69,28.65 145.92,31.42 145.92,31.8 144.87,32.85 137.94,32.85 136.08,30.99 132.26,30.99 128.63,27.37 112.09,27.37 111.52,27.93 110.84,27.93 110.27,27.37 98.94,27.37 98.74,27.57 97.85,27.57 96.83,26.55 83.63,26.55 83.13,27.05 67.3,27.05 65.38,28.96 62.94,28.96 62.2,28.23 60.47,28.23 59.2,29.49 59.2,30.63 54.29,35.54 48.31,35.54 44.61,39.23 44.61,50.25 41.72,53.15 41.72,54.41 37.63,58.49 37.63,60.55 38.07,60.99 38.07,64.23 38.01,64.29 38.01,64.66 37.26,65.41 37.26,67.96 37.32,68.01 37.32,71.04 39.91,73.63 39.91,74.75 39.31,75.34 39.31,76.86 39.59,77.14 39.59,78 v1(39.63,78.03)
BOT_MUX_N: length 4.5
  BOTTOM w0.102: EU7.4 26.04,129.92 26.19,129.78 26.44,129.78 26.84,130.17 UT10.2
  BOTTOM w0.112: EU7.4 EU7.7 24.45,129.92 24.3,129.78 24.09,129.78 23.99,129.68 23.91,129.68 23.81,129.78 23.53,129.78 LT3.3 23.35,129.95 RT103.1
BOT_MUX_N_R: length 22.5
  TOP w0.102: v1(6.58,121.55) 6.56,121.58 5.75,121.58 JUSBC1.B7
  IN3 w0.135: v1(6.58,121.55) 6.74,121.39 7.15,121.39 7.29,121.53 7.29,123.98 8.68,125.38 8.68,125.99 12.66,129.97 17.7,129.97 18,129.66 19.86,129.66 20.03,129.83 v1(20.03,129.84)
  BOTTOM w0.112: RT103.2 22.44,129.95 LT3.4 21.95,129.79 21.82,129.66 20.22,129.66 v1(20.03,129.84)
BOT_MUX_P: length 4.4
  BOTTOM w0.102: UT10.1 26.63,129.67 26.53,129.57 26.19,129.57 26.04,129.42 EU7.5
  BOTTOM w0.112: EU7.5 EU7.6 24.44,129.42 24.3,129.56 24.18,129.56 24.08,129.46 23.92,129.46 23.75,129.29 LT3.2 23.35,129.12 RT102.1
BOT_MUX_P_R: length 22.6
  TOP w0.102: v1(6.58,120.97) 6.48,121.07 5.75,121.07 JUSBC1.B6
  IN3 w0.135: v1(6.58,120.97) 6.77,121.15 7.25,121.15 7.53,121.43 7.53,123.88 8.92,125.28 8.92,125.89 12.76,129.73 17.6,129.73 17.9,129.42 19.88,129.42 20.03,129.26 v1(20.03,129.26)
  BOTTOM w0.112: RT102.2 22.44,129.12 LT3.1 21.96,129.29 21.81,129.44 20.22,129.44 v1(20.03,129.26)
BP_0: length 3.8
  BOTTOM w0.102: UV1.U1 122.96,122.21 122.96,121.25 v3(122.59,120.88) 122.1,120.4 122.1,119.5 RV82.1
BP_1: length 7.3
  BOTTOM w0.089: v3(120.94,117.46) 120.63,117.76 120.63,119.07 120.93,119.36 RV81.1
  BOTTOM w0.102: RV81.1 121.07,119.8 122.66,121.38 122.66,122.46 123.34,123.14 UV1.U3
BST1_APU: length 1.4
  TOP w0.089: v3(150.38,82.51) 150.77,82.9 PRZ41.1
BST2_APU: length 1.8
  TOP w0.089: v3(158.48,81.62) 158.48,81.95 157.7,82.72 PRZ21.1
BST_1.2V: length 2.3
  TOP w0.203: PRM02.1 39.72,29.84 39.72,29.64 38.89,28.81 PUM01.18
BST_1.2V_R: length 2.9
  TOP w0.508: PRM02.2 41.19,29.92 41.19,28.06 40.81,27.68 PCM12.1
BST_3V: length 1.4
  BOTTOM w0.089: v3(21.55,38.74) 21.55,39.34 21.15,39.73 PR301.1
BST_+1.35VGPU: length 2.4
  TOP w0.508: v1(145.39,109.48) 145.39,108.98 144.81,108.4 PRW06.1
  BOTTOM w0.254: v1(145.39,109.48) 145.02,109.12 PUW01.1
BST_+1.35VGPU_R: length 0.9
  TOP w0.089: 147.48,108.01 v3(147.48,107.12)
BST_+VDDP: length 1
  BOTTOM w0.089: v3(166.29,42.44) PRH06.1
BST_+VDDP_R: length 1.2
  BOTTOM w0.089: PCH12.1 162.86,42.05 162.76,42.05 v3(162.33,41.61)
BST_NB:
  vias: v1(158.01,84.91) v3(158.45,84.59)
BT_ON#: length 3.6
  TOP w0.099: v1(123.72,56.35) 123.9,56.35 v3(124.18,56.07) 124.18,55.91 122.6,54.34 RC902.2
  BOTTOM w0.089: UC1.AW18 123.97,56.35 v1(123.72,56.35)
BT_ON#_R: length 209.7
  TOP w0.099: RC615.2 124.18,49.03 124.18,49.61 v1(123.78,50.01) 122.78,51.01 122.78,53.06 122.55,53.28 RC902.1
  IN2 w0.089: 59.54,42.35 59.54,42.17 61.99,39.71 64.35,39.71 66.36,37.7 79.51,37.7 80.19,37.02 87.43,37.02 87.92,37.52 89.36,37.52 90.09,36.79 93.69,36.79 94.52,37.61 96.83,37.61 97.26,38.04 97.26,38.31 97.48,38.53 105.74,38.53 106.33,39.13 108.27,39.13 110.58,36.82 111.29,36.32 112.33,35.92 113.95,35.92 115.34,36.58 117.36,38.6 117.36,40.5 118.58,41.71 120.68,41.71 123.83,44.85 123.83,48.32 124.18,48.68 124.18,49.61 v1(123.78,50.01)
  IN2 w0.102: v1(70.14,113.83) 69.55,114.43 67.95,114.43 67.34,113.81 65.3,113.81 63.65,115.46 60.19,115.46 59.09,114.36 50.59,114.36 49.38,113.15 49.1,113.15 48.77,112.83 47.17,111.22 47.17,105.49 47.71,104.95 47.71,88.23 47.88,88.06 47.88,86.32 47.71,86.15 47.71,84.51 47.92,84.3 47.92,79.72 47.34,79.14 47.34,76.62 47.63,76.32 47.63,74.43 48.29,73.77 48.29,71.37 48.95,70.72 48.95,69.94 48.56,69.55 48.56,67.55 49.95,66.17 49.95,57.97 53.45,54.47 53.45,49.71 59.03,44.13 59.03,42.97 59.54,42.45 59.54,42.35
  BOTTOM w0.089: JWLAN1.54 72.4,133.9 72.63,133.66 72.63,132.23 73.21,131.65 73.21,127.37 73.06,127.22 73.06,124.97 73.64,124.39 73.64,121.19 72.84,120.39 72.84,119.61 73.4,119.06 73.52,119.06 73.76,118.82 73.76,117.39 v3(72.86,116.49) 70.87,114.51 70.82,114.51 v1(70.14,113.83)
CAP_LED: length 4
  BOTTOM w0.089: v3(79.93,37.53) 79.93,35.78 80.11,35.61 R19.2 80.55,35.55 JKB1.4
CAP_LED_Q: length 9.5
  TOP w0.089: v3(81.12,38.79) 80.49,38.16 v1(80.49,38.13) 80.49,37.78 79.79,37.08 78.2,37.08 77.5,37.78 Q6.1
  BOTTOM w0.089: R19.1 v1(80.49,38.13)
CAP_LED_R#: length 9
  TOP w0.089: Q5.1 78.93,37.84 78.67,38.1 76.11,38.1 75.46,38.74 Q6.2 v3(70.53,38.74)
CAPS_LED: length 92.4
  TOP w0.089: Q5.3 80.6,36.88 v3(81.06,37.33) 81.31,37.59 v1(81.31,38.13) ; UE1.91 39.35,84.5 v1(39.53,84.68)
  BOTTOM w0.089: R20.1 R18.2 v1(81.31,38.13) 81.31,38.21 79.89,39.63 72.13,39.63 71.99,39.77 57.61,39.77 54.79,42.59 54.79,45.39 53.6,46.58 48.51,46.58 47.61,47.48 47.61,62.38 47.51,62.48 47.51,63.58 47.74,63.8 47.74,64.27 48.06,64.6 48.06,67.35 47.13,68.28 47.13,69.68 48.76,71.31 48.76,75.87 48.29,76.34 48.29,78.81 44.24,82.86 41.34,82.86 40.2,84.01 39.72,84.01 39.53,84.19 v1(39.53,84.68)
CCG4_APU_USBC_SCL: length 171.5
  TOP w0.089: v1(145.88,66.34) 145.96,66.42 145.96,66.61 145.85,66.72 QC3.3 ; RT70.2 31.71,125.22 v1(31.89,125.05)
  IN3 w0.089: v1(47.38,113.27) 47.38,113.52 45.23,115.66 45.23,120.16 41.41,123.99 40.22,123.99 39.39,124.81 33.69,124.81 33.45,125.05 v1(31.89,125.05)
  BOTTOM w0.089: v1(47.38,113.27) 47.67,113.27 48.66,114.26 51.61,114.26 52.43,113.43 59.88,113.43 60.68,112.63 63.2,112.63 65.08,110.75 72.63,110.75 74.21,112.32 78.73,112.32 80.34,110.71 82.56,110.71 84.78,112.93 92.64,112.93 95.39,110.18 106.43,110.18 106.74,109.88 110.2,109.88 120.07,100.01 120.07,95.44 ; 139.35,91.14 145.26,91.14 145.63,90.77 145.63,89.73 145.88,89.48 145.88,86.7 145.96,86.62 145.96,84.13 146.89,83.19 146.89,79.75 147.06,79.59 147.06,78.01 146.96,77.91 146.96,76.64 146.49,76.17 146.49,76.02 144.54,74.08 144.54,69.74 145.7,68.58 145.7,66.52 v1(145.88,66.34) ; UT1.29 v1(31.89,125.05) 31.63,125.05 QT6.6
  BOTTOM w0.099: 120.07,95.44 120.07,94.43 123.5,91 123.5,89.48 124.35,88.63 124.7,88.63 124.96,88.37 130.39,88.37 132.09,90.06 132.6,90.06 132.88,90.34 133.74,90.34 134.53,91.14 139.35,91.14
CCG4_APU_USBC_SDA: length 174.4
  TOP w0.089: v1(30.21,124.55) 30.25,124.51 RT71.2 ; v1(145.08,71.11) 145.08,70.81 144.55,70.27 QC3.6
  IN2 w0.089: v1(48.93,107.73) 49.03,107.73 52.48,111.17 59.36,111.17 60.85,112.66 63.03,112.66 63.98,111.72 65.42,111.72 65.97,111.17 72.67,111.17 74.16,112.66 75.73,112.66 76.81,111.59 82.44,111.59 83.16,112.31 89.46,112.31 90.63,111.14 94.55,111.14 95.3,110.38 100.83,110.38 105.58,105.63 118.9,105.63 119.04,105.77 124.54,105.77 125.29,105.01 128.12,105.01 128.32,105.22 129.34,105.22 130.64,106.51 132.25,106.51 134.82,103.95 138.69,103.95 140.55,102.09 140.55,98.78 145.24,94.1 145.24,89.57 146.83,87.98 146.83,84.81 146.4,84.37 v1(146.37,84.37)
  IN3 w0.089: v1(30.21,124.55) 33.85,124.55 33.93,124.63 39.32,124.63 40.16,123.78 41.36,123.78 45.05,120.09 45.05,114.98 48.71,111.32 48.71,107.82 48.8,107.73 v1(48.93,107.73)
  BOTTOM w0.089: UT1.28 v1(30.21,124.55) 30.16,124.55 29.99,124.38 QT6.3 ; v1(146.37,84.37) 146.37,84.33 147.07,83.63 147.07,79.83 147.24,79.66 147.24,77.94 147.14,77.83 147.14,76.57 146.69,76.12 146.69,75.97 145.08,74.35 v1(145.08,71.11)
CCG4_CC1_P1: length 39.2
  TOP w0.279: v1(9.24,120.39) 9.24,121.41 8.76,121.89 8.11,121.89 8.05,121.83 8.04,121.82 JUSBC1.A5
  TOP w0.508: v1(40.19,121.33) 40.19,121.38 39.53,122.04 CT11.1
  IN3 w0.508: v1(13.24,120.42) 14.08,119.58 15.11,119.58 15.55,119.13 17.08,119.13 17.74,119.8 23.26,119.8 24.84,118.22 27.29,118.22 28.91,119.84 28.91,120.35 30.41,121.85 39.67,121.85 v1(40.19,121.33)
  BOTTOM w0.254: v1(13.24,120.42) 13.11,120.28 EU8.9 EU8.1 10.39,120.28 10.04,119.93 9.64,119.93 9.24,120.33 v1(9.24,120.39)
  vias: v3(40.72,121.32)
CCG4_CC2_P1: length 41.8
  TOP w0.102: v1(40.34,123.3) 40.01,123.63 v3(39.59,123.63)
  TOP w0.279: v1(6.53,120.35) 6.31,120.58 5.75,120.58 JUSBC1.B5
  TOP w0.508: v1(40.34,123.3) 40.65,122.99 CT10.1
  IN2 w0.254: v1(6.53,120.35) 6.93,120.35 7.49,120.91 7.49,121.55 8,122.06 9.52,122.06 v1(9.62,122.16)
  IN3 w0.508: v1(40.34,123.3) 39.53,122.49 30.2,122.49 27.99,120.28 27.99,119.78 27.04,118.82 25.09,118.82 23.51,120.4 17.5,120.4 16.83,119.74 15.87,119.74 15.42,120.18 15.1,120.18 13,122.28 v1(12.86,122.28)
  BOTTOM w0.254: v1(12.86,122.28) 12.72,122.42 12.04,122.42 11.89,122.28 EU8.6 EU8.5 10.06,122.28 9.94,122.16 v1(9.62,122.16)
CCG4_ID1: length 6.4
  BOTTOM w0.089: UT1.25 32.84,123.05 32.75,122.96 32.75,120.83 RT115.1 RT4.2 v3(32.38,118.68)
CCG4_ID2: length 5.3
  BOTTOM w0.089: UT1.27 32.45,124.05 32.33,123.92 v1(32.33,123.52) 32.33,121.61 31.87,121.15 RT64.2 RT65.1
CCG4_SWD_CLK: length 5.1
  TOP w0.089: v1(40.69,125.05) 40.69,125.57 TP2.1
  BOTTOM w0.089: UT1.2 v1(40.69,125.05) 40.91,125.05 JCCG4_T.4
CCG4_SWD_IO: length 5
  TOP w0.089: TP1.1 44.07,125.71 v1(43.7,125.71)
  BOTTOM w0.089: UT1.1 42.72,125.55 JCCG4_T.5 43.65,125.66 v1(43.7,125.71)
CCG4_XRES: length 12.5
  TOP w0.089: v1(39.91,120.58) 39.58,120.25 39.58,113.99 TP3.1 39.92,113.65 RT6.2 CT13.1
  BOTTOM w0.089: UT1.10 39.44,120.8 39.66,120.58 v1(39.91,120.58) JCCG4_T.3
CLK_PCIE_N1: length 223.8
  TOP w0.112: v1(30.82,85.11) 30.82,84.73 30.7,84.62 30.2,84.62 29.7,85.11 28.15,85.11 28.04,85 27.03,85 26.36,84.33 UL1.16
  IN3 w0.135: v1(30.82,85.11) 30.82,84.17 31.09,83.89 32.19,83.89 32.88,83.21 32.88,70.87 32.68,70.67 32.68,63.08 30.54,60.94 30.54,57.71 31.63,56.61 31.63,51.56 32.37,50.82 32.37,46.26 31.84,45.73 31.84,42.82 29.81,40.79 29.76,40.79 29.21,40.24 23.91,40.24 23.51,39.84 23.51,36.56 25.57,34.51 30.22,34.51 31.28,35.58 32.65,35.58 33.36,36.28 36.65,36.28 37.29,36.92 37.8,36.92 38.66,37.78 45.37,37.78 45.93,37.22 54.96,37.22 59.72,32.46 62.23,32.46 66.46,28.23 83.65,28.23 83.88,28 98.95,28 99.34,27.61 110.16,27.61 110.7,28.15 112.01,28.15 112.55,27.61 117.35,27.61 117.91,28.16 120.97,28.16 121.52,27.61 125.82,27.61 126.62,28.41 131.01,28.41 140.17,37.57 140.81,38.78 140.81,41.59 138.57,43.83 138.57,47.82 138.76,48.01 138.76,53.55 138.43,53.89 138.43,55.05 137.95,55.53 137.95,58.07 138.63,58.76 138.63,59.69 138.89,59.95 138.89,61.22 138.58,61.53 138.58,61.75 138.41,61.92 138.41,62.11 138.58,62.28 v1(138.58,62.28)
  BOTTOM w0.102: UC1.AM4 136.07,63.1 136.29,63.1 136.42,63.03 136.42,63.03 136.46,63 137.56,63 137.62,63.06 138.33,63.06 138.58,62.81 138.58,62.51 138.53,62.47 138.53,62.32 v1(138.58,62.28)
CLK_PCIE_N2: length 294.7
  IN3 w0.135: v1(137.64,60.95) 137.64,60.93 137.96,60.61 137.96,60.34 137.63,60 137.63,59.17 136.62,58.16 136.62,55.22 136.76,55.08 136.76,53.97 137.84,52.89 137.84,48.39 137.34,47.9 137.34,45.77 135.33,43.76 133.95,40.64 133.95,35.13 134.53,34.55 134.53,33.43 130.59,29.49 127.17,29.49 126.48,30.18 123.9,30.18 123.66,29.94 122.1,29.94 121.25,29.09 117.52,29.09 116.97,28.53 114.49,28.53 113.95,29.07 110.31,29.07 109.77,28.53 99.73,28.53 99.34,28.92 84.26,28.92 83.97,29.21 66.78,29.21 62.61,33.38 60.94,33.38 60.5,33.82 59.67,33.82 55.16,38.32 46.8,38.32 46.3,38.82 35.55,38.82 35.21,38.48 35.21,37.34 35.08,37.21 32.93,37.21 32.22,36.5 30.9,36.5 29.83,35.43 26.02,35.43 24.45,37.01 24.45,38.63 24.74,38.91 29.18,38.91 30.14,39.87 30.19,39.87 32.76,42.43 32.76,45.13 33.39,45.76 33.39,49.45 33.75,49.81 33.75,52.32 32.69,53.38 32.69,56.86 31.46,58.09 31.46,60.56 33.6,62.7 33.6,70.29 33.85,70.54 33.85,82.58 35.69,84.42 35.69,88.29 36.53,89.13 50.53,89.13 55.43,94.04 55.43,109.61 62.13,116.31 63.17,116.31 64.98,118.12 67.98,118.12 68.25,117.85 70.92,117.85 71.07,118 72.83,118 73.63,118.79 74.21,118.79 74.91,119.49 74.91,120.54 75.05,120.67 75.45,120.67 75.56,120.56 75.56,120.37 v1(75.42,120.23)
  BOTTOM w0.089: v1(137.64,60.95) 137.83,61.14 137.91,61.14 138,61.23 138,61.42 137.9,61.51 137.13,61.51 136.71,61.93 136.64,61.98 136.45,61.98 136.19,62.25 136.19,62.43 136.1,62.52 135.82,62.52 135.73,62.43 UC1.AM3
  BOTTOM w0.112: v1(75.42,120.23) 75.66,120.47 75.66,121.21 74.54,122.33 74.54,126.54 75.07,127.07 75.07,131.5 76.11,132.53 78.22,132.53 78.33,132.65 JWLAN1.49
CLK_PCIE_N3: length 155
  IN3 w0.135: v1(26.56,36.59) 26.4,36.43 26.4,36.25 26.53,36.11 29.55,36.11 30.61,37.18 31.09,37.18 31.47,37.56 31.47,38.25 33.39,40.17 37.01,40.17 37.68,39.5 49.75,39.5 50.13,39.88 54.57,39.88 59.95,34.5 60.78,34.5 61.22,34.06 62.89,34.06 66.85,30.1 96.36,30.1 96.77,29.69 99.52,29.69 100.01,29.21 109.49,29.21 110.03,29.75 117.31,29.75 117.32,29.77 120.96,29.77 121.82,30.62 123.37,30.62 123.67,30.92 124.55,30.92 124.75,31.13 131.24,31.13 133.27,33.15 133.27,40.79 134.76,44.16 136.64,46.03 136.64,51.65 136.16,52.12 136.16,52.82 135.89,53.1 135.89,55.04 135.89,55.05 135.89,58.71 136.14,58.96 136.14,62.14 136.95,62.95 137.65,62.95 137.8,63.1 137.8,63.25 v1(137.58,63.48)
  BOTTOM w0.102: v1(137.58,63.48) 137.72,63.62 137.72,63.79 137.62,63.89 136.81,63.89 136.74,63.81 136.61,63.81 136.31,63.51 136.01,63.51 135.59,63.92 135.45,63.92 UC1.AL4
  BOTTOM w0.112: v1(26.56,36.59) 26.38,36.41 26.38,35.58 26.1,35.3 26.1,35.05 26.38,34.77 JSSD1.53
CLK_PCIE_P1: length 223.8
  TOP w0.112: v1(31.4,85.11) 31.59,84.92 31.59,84.74 31.48,84.63 31.03,84.63 30.79,84.39 30.1,84.39 29.61,84.89 28.24,84.89 28.13,84.78 27.12,84.78 26.45,84.11 26.17,84.11 25.99,83.93 UL1.15
  IN3 w0.135: v1(137.99,62.28) 137.92,62.28 137.79,62.14 137.79,61.94 137.95,61.78 138.2,61.78 138.34,61.65 138.34,61.43 138.65,61.12 138.65,60.05 138.39,59.79 138.39,58.86 137.71,58.17 137.71,55.43 138.18,54.95 138.18,53.79 138.52,53.45 138.52,48.11 138.33,47.92 138.33,43.73 140.57,41.49 140.57,38.84 139.98,37.72 130.91,28.65 126.52,28.65 125.72,27.85 121.62,27.85 121.07,28.4 117.81,28.4 117.25,27.85 112.65,27.85 112.11,28.39 110.6,28.39 110.06,27.85 99.44,27.85 99.05,28.24 83.98,28.24 83.75,28.47 66.56,28.47 62.33,32.7 59.82,32.7 55.06,37.46 46.03,37.46 45.47,38.02 38.56,38.02 37.7,37.16 37.19,37.16 36.55,36.53 33.26,36.53 32.55,35.82 31.18,35.82 30.12,34.75 25.67,34.75 23.75,36.66 23.75,39.74 24.01,40 29.31,40 29.86,40.55 29.91,40.55 32.08,42.72 32.08,45.63 32.61,46.16 32.61,50.92 31.87,51.66 31.87,56.71 30.78,57.81 30.78,60.84 32.92,62.98 32.92,70.57 33.12,70.77 33.12,83.31 32.29,84.13 31.19,84.13 31.06,84.27 31.06,84.5 31.18,84.63 31.44,84.63 31.57,84.76 31.57,84.98 31.44,85.11 v1(31.4,85.11)
  BOTTOM w0.102: UC1.AM2 136.16,62.83 136.34,62.83 136.37,62.8 137.64,62.8 137.7,62.86 138.24,62.86 138.37,62.73 138.37,62.59 138.06,62.28 v1(137.99,62.28)
CLK_PCIE_P2: length 294.7
  IN3 w0.135: v1(76,120.23) 75.87,120.36 75.87,120.59 75.55,120.91 74.95,120.91 74.67,120.64 74.67,119.59 74.11,119.03 73.53,119.03 72.73,118.24 70.97,118.24 70.82,118.09 68.35,118.09 68.08,118.36 64.88,118.36 63.07,116.55 62.03,116.55 55.19,109.71 55.19,94.14 50.43,89.37 36.43,89.37 35.45,88.39 35.45,84.52 33.61,82.68 33.61,70.64 33.36,70.39 33.36,62.8 31.22,60.66 31.22,57.99 32.45,56.76 32.45,53.28 33.51,52.22 33.51,49.91 33.15,49.55 33.15,45.86 32.52,45.23 32.52,42.53 30.09,40.11 30.04,40.11 29.08,39.15 24.64,39.15 24.21,38.73 24.21,36.91 25.92,35.19 29.93,35.19 31,36.26 32.32,36.26 33.03,36.97 35.18,36.97 35.45,37.24 35.45,38.38 35.65,38.58 46.2,38.58 46.7,38.08 55.06,38.08 59.57,33.58 60.4,33.58 60.84,33.14 62.51,33.14 66.68,28.96 83.87,28.96 84.16,28.68 99.24,28.68 99.63,28.29 109.87,28.29 110.42,28.83 113.85,28.83 114.39,28.29 117.07,28.29 117.62,28.84 121.35,28.84 122.2,29.7 123.76,29.7 124,29.94 126.38,29.94 127.07,29.25 130.69,29.25 134.77,33.33 134.77,34.65 134.19,35.23 134.19,40.59 135.53,43.62 137.58,45.67 137.58,47.8 138.08,48.29 138.08,52.99 137,54.07 137,55.18 136.86,55.32 136.86,58.06 137.87,59.07 137.87,59.9 138.21,60.24 138.21,60.93 v1(138.22,60.95)
  BOTTOM w0.089: v1(138.22,60.95) 138.19,60.98 138.19,61.5 137.98,61.7 137.21,61.7 136.84,62.07 UC1.AM1
  BOTTOM w0.112: JWLAN1.47 78.36,132.15 78.2,132.31 76.2,132.31 75.29,131.4 75.29,126.98 74.76,126.45 74.76,122.42 75.88,121.31 75.88,120.35 v1(76,120.23)
CLK_PCIE_P3: length 155
  IN3 w0.135: v1(138.16,63.48) 138.05,63.37 138.05,63 137.75,62.71 137.05,62.71 136.39,62.04 136.39,60.34 136.38,60.34 136.38,58.86 136.13,58.61 136.13,53.2 136.4,52.92 136.4,52.22 136.88,51.75 136.88,45.93 134.96,44.02 133.51,40.74 133.51,33.05 131.34,30.89 124.85,30.89 124.65,30.68 123.77,30.68 123.47,30.38 121.92,30.38 121.06,29.52 117.42,29.52 117.41,29.51 110.13,29.51 109.59,28.97 99.91,28.97 99.42,29.45 96.67,29.45 96.26,29.86 66.75,29.86 62.79,33.82 61.12,33.82 60.68,34.26 59.85,34.26 54.47,39.64 50.23,39.64 49.85,39.26 37.58,39.26 36.91,39.93 33.49,39.93 31.71,38.15 31.71,37.46 31.19,36.94 30.71,36.94 29.65,35.87 26.43,35.87 26.16,36.15 26.16,36.41 v1(25.97,36.59)
  BOTTOM w0.102: v1(138.16,63.48) 137.92,63.72 137.92,63.87 137.7,64.09 136.73,64.09 136.65,64.01 136.53,64.01 136.32,63.81 UC1.AL2
  BOTTOM w0.112: v1(25.97,36.59) 26.15,36.41 26.15,35.67 25.87,35.39 JSSD1.55
CLK_PEG_N0: length 135.3
  IN3 w0.135: v1(111.17,145.37) 110.44,145.37 109.71,144.65 109.71,142.67 109.01,141.97 104.92,141.97 103.39,140.43 103.39,136.26 106.72,132.93 106.72,127.77 102.94,123.99 102.94,121.54 101.66,120.26 101.66,115.66 108.16,109.16 115.46,109.16 116.3,110 118.22,110 118.74,110.51 123.17,110.51 123.69,111.03 124.81,111.03 126.03,112.25 130.28,112.25 131.08,111.45 132.76,109.77 133.42,109.77 133.95,109.25 133.95,104.64 133.32,104 133.32,98.68 135.81,96.19 135.81,90.24 135.12,89.56 135.12,87.37 135.85,86.65 136.57,86.65 137.03,86.19 137.3,86.19 138.95,84.54 138.95,77.57 137.85,76.47 137.85,74.24 138.22,73.88 138.8,73.88 139.05,73.63 139.05,72.7 138.53,72.18 138.53,71.98 138.2,71.65 138.2,69.82 138.47,69.55 138.47,68.97 138.96,68.48 v1(138.96,67.89)
  BOTTOM w0.089: UC1.AK3 135.75,64.34 136.48,64.59 136.65,64.59 136.89,64.46 138.77,64.46 138.89,64.35 139.97,64.35 140.06,64.44 140.06,65.61 138.96,66.72 v1(138.96,67.89)
  BOTTOM w0.102: UV1.AK32 113.72,144.2 113.2,144.73 113.2,144.73 113.15,144.78 113.15,144.78
  BOTTOM w0.112: v1(111.17,145.37) 111.35,145.19 112.74,145.19 113.15,144.79 113.15,144.78
CLK_PEG_P0: length 135.3
  IN3 w0.135: v1(111.17,144.79) 111.15,144.79 110.81,145.13 110.54,145.13 109.95,144.55 109.95,142.57 109.11,141.73 105.02,141.73 103.63,140.33 103.63,136.36 106.96,133.03 106.96,127.67 103.18,123.89 103.18,121.44 101.9,120.16 101.9,115.76 108.26,109.4 115.36,109.4 116.2,110.24 118.12,110.24 118.64,110.75 123.07,110.75 123.59,111.27 124.71,111.27 125.93,112.49 130.38,112.49 131.18,111.69 132.86,110.02 133.52,110.02 134.19,109.35 134.19,104.54 133.56,103.9 133.56,98.78 136.05,96.29 136.05,90.14 135.37,89.46 135.37,87.47 135.95,86.89 136.67,86.89 137.13,86.43 137.4,86.43 139.19,84.64 139.19,77.47 138.1,76.37 138.1,74.34 138.32,74.12 138.9,74.12 139.29,73.73 139.29,72.6 138.77,72.08 138.77,71.88 138.44,71.55 138.44,69.92 138.71,69.65 138.71,69.07 139.2,68.58 139.2,68.25 139.55,67.91 v1(139.55,67.89)
  BOTTOM w0.089: UC1.AK1 136.57,64.27 138.69,64.27 138.81,64.16 140.05,64.16 140.26,64.36 140.26,65.69 139.15,66.8 139.15,67.5 v1(139.55,67.89)
  BOTTOM w0.102: 112.84,144.78 112.99,144.63 113.29,144.33 113.29,144.25 113.3,144.25 113.3,143.77 113.67,143.4 UV1.AK30
  BOTTOM w0.112: 112.84,144.78 112.65,144.97 111.35,144.97 v1(111.17,144.79)
CLK_SMB: length 5.6
  TOP w0.112: PR42.1 164.69,40.92 v1(164.41,41.21)
  BOTTOM w0.112: PBATT1.7 161.01,40.95 161.26,41.21 v1(164.41,41.21)
CLKREQ_PCIE#1: length 158.3
  TOP w0.089: v1(28.1,81.36) 27.97,81.48 27.97,82.09 RL15.1 27.34,82.73 UL1.12
  IN1 w0.089: v1(39.2,81.41) 39.15,81.47 35.72,81.47 34.96,82.23 28.97,82.23 v1(28.1,81.36)
  IN3 w0.089: 122.2,52.6 122.2,51.64 122.84,51 122.84,50.25 122.82,50.24 122.82,48.98 121.89,48.05 121.89,46.21 122.34,45.75 122.34,45.41 120.89,43.95 120.89,42.85 120.07,42.03 118.84,42.03 117.59,40.78 117.59,39.61 117.59,39.6 114.45,36.47 112.37,36.47 111.47,36.87 110.97,37.21 110.51,37.67 110.15,38.21 110.07,38.4 108.81,39.66 107.11,39.66 106.97,39.8 105.7,39.8 105.17,40.33 103.38,40.33 102.04,38.98 86.44,38.98 85.75,38.29 85.25,38.29 85,38.54 79.96,38.54 79.91,38.5 67.06,38.5 65.27,40.29 64.86,40.29 64,41.14 61.91,41.14 61.26,41.78 61.26,42.81 59.76,44.32 58.97,44.32 56.32,46.97 47.76,46.97 40.88,53.85 40.88,62.69 39.92,63.66 39.92,65.62 39.61,65.93 39.61,67.4 40.92,68.71 40.92,74.81 40.05,75.69 40.05,79.75 39.56,80.23 39.56,81.05 39.2,81.4 v1(39.2,81.41)
  IN3 w0.099: v1(123.73,60.91) 123.73,60.7 123.35,60.32 123.35,59.74 123.15,59.54 123.15,58.6 122.89,58.34 122.89,55.21 122.2,54.52 122.2,52.6
  BOTTOM w0.1: UC1.AN19 123.33,61.31 v1(123.73,60.91)
CLKREQ_PCIE#2: length 240.9
  TOP w0.099: v1(123.73,60.11) 124.15,59.68 125.89,59.68 126.12,59.45 126.12,56.9 125.51,56.29 v3(125.51,54.35) 125.98,53.88 125.98,51.94 125.08,51.04 125.08,49.81 125.76,49.13 RC1696.2
  IN3 w0.089: v1(72.77,114.04) 72.77,113.84 71.63,112.7 68.72,112.7 68.19,112.17 61.59,112.17 59.27,109.86 ; 53.09,86.18 49.95,83.05 46.67,83.05 46,82.38 43.39,82.38 43.27,82.26 39.47,82.26 38.68,81.46 38.68,78.45 39.56,77.57 39.56,75.91 39.85,75.62 39.85,70.99 40.18,70.67 40.18,68.22 39.43,67.47 39.43,65.85 39.74,65.55 39.74,63.58 40.7,62.62 40.7,53.78 47.74,46.73 56.28,46.73 58.87,44.14 59.69,44.14 61.04,42.78 61.04,41.74 61.83,40.96 63.93,40.96 64.78,40.1 65.19,40.1 67.57,37.72 85.44,37.72 86.52,38.8 102.11,38.8 102.74,39.42 108.79,39.42 109.79,38.42 110.37,37.55 110.86,37.06 111.38,36.71 112.33,36.29 114.53,36.29 117.77,39.53 117.77,39.68 117.77,39.68 117.77,40.7 118.91,41.84 120.18,41.84 121.08,42.75 121.08,43.89 122.53,45.33 122.53,45.83 122.08,46.27 122.08,47.98 123.01,48.91 123.01,50.16 123.02,50.17 123.02,51.07 122.4,51.7 122.4,52.81
  IN3 w0.099: v1(123.73,60.11) 123.73,59.84 123.35,59.46 123.35,58.48 123.09,58.22 123.09,54.61 122.4,53.92 122.4,52.81
  IN3 w0.102: 53.09,86.18 58.16,91.26 58.16,108.75 59.27,109.86
  BOTTOM w0.089: 78.11,133.65 77.92,133.84 76.01,133.84 75.81,133.65
  BOTTOM w0.1: v1(123.73,60.11) 123.33,60.51 UC1.AP19
  BOTTOM w0.112: v1(72.77,114.04) 73.78,115.06 75.24,115.06 75.35,115.17 75.35,115.92 74.79,116.49 74.79,120.33 74.02,121.1 74.02,126.87 73.79,127.1 73.79,131.63 75.81,133.65 ; JWLAN1.53 78.11,133.65
CLKREQ_PCIE#3: length 144.7
  TOP w0.099: RC1697.2 125.69,46.43 125.29,46.83 124.82,46.83 124.58,47.07 124.58,47.3 124.36,47.52 123.95,47.52 v3(123.22,46.79) 123.03,46.6 v1(122.46,46.6)
  IN2 w0.089: v1(26.54,27.62) 26.92,27.24 30.48,27.24 32.56,29.32 32.56,29.52 38.11,35.07 38.11,35.74 39.04,36.66 39.04,40.05 38.25,40.84 38.25,42.93 37.87,43.31 37.87,44.26 41.99,48.37 v1(41.99,48.62)
  IN3 w0.089: v1(41.99,48.62) 45.59,48.62 47.71,46.5 56.23,46.5 58.78,43.96 59.62,43.96 60.85,42.73 60.85,41.68 61.75,40.78 63.85,40.78 64.7,39.92 65.11,39.92 67.5,37.54 85.52,37.54 86.59,38.62 102.19,38.62 102.81,39.24 108.71,39.24 109.65,38.3 110.23,37.43 110.74,36.92 111.29,36.55 112.29,36.1 114.6,36.1 117.95,39.45 117.95,40.32 118.42,40.78 119.5,40.78 121.27,42.55
  IN3 w0.099: v1(123.73,58.61) 123.73,58.54 123.29,58.1 123.29,54.53 122.64,53.88 122.64,51.72 123.21,51.15 123.21,50.1 123.19,50.08 123.19,48.83 122.46,48.1 v1(122.46,46.6) 122.46,46.16 122.71,45.91 122.71,45.25 121.27,43.81 121.27,42.55
  BOTTOM w0.089: v1(26.54,27.62) 26.63,27.53 JSSD1.52
  BOTTOM w0.1: v1(123.73,58.61) 123.62,58.61 123.33,58.91 UC1.AT19
CLKREQ_PEG#0: length 267.6
  TOP w0.089: v1(117.15,108.34) 117.15,108.71 116.75,109.11 113.64,109.11 113.39,109.36 v3(100.94,109.36) v1(99.27,109.36)
  TOP w0.099: RC1695.2 124.62,46.43 124.24,46.81 124.24,47.11 v1(124.2,47.14)
  IN3 w0.089: 56.17,89.72 50.1,83.66 47.02,83.66 46.41,83.05 42.05,83.05 41.48,82.48 39.43,82.48 38.49,81.54 38.49,78.37 39.38,77.49 39.38,76.77 38.97,76.36 38.97,72.74 39.51,72.2 39.51,71.07 39.99,70.59 39.99,69.06 39.82,68.89 39.82,68.13 39.2,67.5 39.2,65.72 39.41,65.51 39.41,63.4 40.39,62.42 40.39,53.4 41.23,52.55 41.23,48.85 41.91,48.17 45.79,48.17 47.64,46.32 56.16,46.32 59.45,43.04 59.57,43.04 59.62,43.08 60.01,43.08 60.66,42.43 60.66,41.5 62.3,39.86 64.35,39.86 64.58,39.63 64.89,39.63 67.17,37.36 85.59,37.36 86.27,38.03 89.58,38.03 90.3,37.31 94.51,37.31 94.58,37.38 96.88,37.38 97.21,37.71 97.82,37.71 98.54,38.43 102.27,38.43 102.89,39.06 108.63,39.06 109.51,38.18 110.08,37.32 110.62,36.78 111.2,36.39 112.25,35.92 114.68,35.92 118.14,39.38 118.14,40.24 118.49,40.6 119.57,40.6 120.3,41.32 121.93,41.32 123.1,42.49 123.1,44.26 123.69,44.85 123.69,45.98 124.2,46.5 v1(124.2,47.14) 124.66,47.61 124.66,52.1 123.95,52.81 123.95,54.16 ; v1(99.27,109.36) 99.14,109.48 89.94,109.48 88.82,110.6 78.67,110.6 75.5,113.77 73.61,113.77 72.97,114.41 72.44,114.41 70.99,112.96 68.43,112.96 67.84,112.37 61.48,112.37 59.28,110.17
  IN3 w0.099: 123.95,54.16 125.11,55.32 125.11,56.6 124.73,56.98 v1(124.73,57.01)
  IN3 w0.102: 59.28,110.17 57.97,108.86 57.97,91.53 56.17,89.72
  BOTTOM w0.1: v1(124.73,57.01) 124.43,57.31 UC1.AV18
  BOTTOM w0.112: v1(117.15,108.34) 117.15,115.49 118.09,116.42 119.13,116.42 119.34,116.63 124.09,116.63 124.37,116.91 124.37,117.95 RV153.1
CLKREQ_PEG#0_R: length 7.5
  BOTTOM w0.102: UV1.N7 126.91,125.63 126.91,122.41 126.71,122.21 126.71,122.19
  BOTTOM w0.112: 126.71,122.19 v3(126.71,120.85) 126.24,120.37 125.9,120.37 RV368.2 124.91,119.38 RV153.2
CLKRUN#: length 110.3
  TOP w0.112: RE52.1 v1(54.82,71.69)
  IN1 w0.099: 108.1,43.54 109.95,45.39 114.89,45.39 116.57,47.07 119.97,47.07 123.86,50.96 124.2,50.96 124.42,51.17
  IN1 w0.119: v1(127.84,52.72) 127.82,52.72 126.86,51.76 125,51.76 124.42,51.17 ; 108.1,43.54 107.52,42.97 104.75,42.97 102.2,40.42 100.84,40.42 v1(100.74,40.51)
  IN3 w0.102: 56.17,48.54 61.6,43.11 62.71,43.11 63.44,42.38 63.44,42.35
  IN3 w0.135: v1(54.82,71.69) 56.04,70.46 56.04,48.66 56.17,48.54 ; v1(100.74,40.51) 100.74,40.25 99.99,39.5 66.67,39.5 65.45,40.72 65.07,40.72 63.44,42.35 63.44,42.35
  BOTTOM w0.1: UC1.BC13 127.74,54.39 127.74,53.5 127.84,53.41 v1(127.84,52.72) 127.84,52.49 127.63,52.28 127.63,51.25 127.46,51.09 T111.1
  BOTTOM w0.112: RX36.1 101.39,39.75 101.04,40.09 101.04,40.28 100.81,40.51 v1(100.74,40.51)
CLKRUN#_R: length 2
  TOP w0.089: UE1.38 53.02,71.41 RE52.2
CLKRUN#_R_TPM: length 3.8
  BOTTOM w0.089: UX1.13 103.03,39.56 102.84,39.75 v3(102.83,39.75) RX36.2 101.67,39.42 101.08,39.42 RX38.2
COMP_CHG: length 3.5
  BOTTOM w0.089: v3(208.24,47.98) PRB30.1
  BOTTOM w0.203: PUB01.28 207.29,46.09 207.36,46.02 208.09,46.02 PCB39.1
  BOTTOM w0.254: PCB39.1 208.23,47.02 PRB30.1
CS_1.2V: length 2.6
  TOP w0.203: PUM01.13 36.85,26.39 37.77,25.46 PRM03.1
CSIN_CHG: length 4.1
  TOP w0.254: v1(201.7,46.58) 201.13,47.15 PCB20.1
  BOTTOM w0.203: PUB01.14 201.79,46.49 v1(201.7,46.58) 201.12,47.15 PCB18.2
  BOTTOM w0.254: PRB03.2 200.17,47.15 PCB18.2
CSIP_CHG: length 5.1
  TOP w0.254: v1(201.74,47.75) 202.06,48.06 v3(202.06,48.55) 201.81,48.79 PCB19.1
  BOTTOM w0.203: PUB01.15 202.06,46.89 201.74,47.21 v1(201.74,47.75) 201.42,48.07 PCB18.1 200.22,48.07 PRB02.2
CSON_CHG: length 4.5
  TOP w0.254: PCB43.1 206.14,42.37 206.08,42.43 v1(206.08,42.87)
  BOTTOM w0.203: PUB01.1 205.97,43.24 205.99,43.21 205.99,42.96 v1(206.08,42.87)
  BOTTOM w0.254: v1(206.08,42.87) 206.08,42.43 206.13,42.38 PCB41.1 206.13,40.38 PRB36.1
CSOP_CHG: length 4.9
  TOP w0.254: PCB38.1 205.53,42.23 205.53,42.98 v1(205.47,43.05)
  BOTTOM w0.203: PRB32.1 205.22,40.37 PCB41.2 205.22,41.64 205.51,41.93 v3(205.51,42.16) 205.51,43.01 v1(205.47,43.05) 205.57,43.14 PUB01.2
DAT_SMB: length 8.5
  TOP w0.112: v1(167.64,38.39) 168.22,38.97 v3(168.22,39.56) PR37.1
  BOTTOM w0.112: PBATT1.6 163.01,38.99 163.42,38.58 167.45,38.58 v1(167.64,38.39)
DBC_EN: length 283.7
  TOP w0.089: v1(57.25,27.36) 57.04,27.36 v3(56.75,27.66) ; UE1.89 40.15,82.71 39.51,82.06 39.51,81.94 v1(39.59,81.85)
  IN1 w0.089: v1(209.2,58.64) 210.07,57.78 211.11,57.78 212.38,56.51 212.38,53.6 215.92,50.05 219.62,50.05 220.97,48.7 220.97,41.44 218.93,39.4 218.93,36.34 217.96,35.37 217.96,29.72 216.93,28.69 214.99,28.69 213.39,30.29 202.91,30.29 202.82,30.38 202.82,30.64 202.19,31.28 199.47,31.28 198.56,30.37 190.9,30.37 190.2,31.07 189.54,31.07 188.84,30.37 181.93,30.37 181.6,30.04 177.91,30.04 174.39,26.52 146.63,26.52 142.87,30.28 139.15,30.28 133.74,24.88 101.66,24.88 100.71,23.93 60.35,23.93 57.82,26.46 57.82,26.79 v1(57.25,27.36)
  IN2 w0.089: v1(39.59,81.85) 39.59,81.85 39.72,81.73 39.72,80.96 39.56,80.8 39.56,79.61 39.47,79.52 39.18,79.52 37.53,77.88 37.53,77.71 38.03,77.21 38.03,73.65 37.35,72.97 36.96,72.97 35.9,71.92 35.9,69.87 34.71,68.68 34.71,62.22 36.07,60.85 36.07,57.86 39.88,54.05 39.88,52.59 41.33,51.14 41.33,50.28 41.76,49.85 42.29,49.85 43.15,48.98 43.15,38.19 47.89,33.46 51.8,33.46 52.29,32.97 54.41,32.97 57.03,30.35 57.03,27.58 v1(57.25,27.36)
  BOTTOM w0.089: R4.2 209.58,56.89 209.2,57.27 v1(209.2,58.64)
DBC_EN_R: length 2.7
  BOTTOM w0.089: JEDP1.11 212.04,55.45 211.36,56.13 R6.1 210.8,56.76 R4.1
DCIN_CHG:
  vias: v1(202.03,50.91) v1(202.66,50.91) v3(202.03,50.29)
DDR_A_ACT#: length 57.4
  IN1 w0.099: v1(120.03,71.81) 119.98,71.81 119.57,72.22 118.37,72.22 118.19,72.4 117.36,72.4 117.15,72.18 115.97,72.18 115.45,72.7 112.87,72.7 111.43,74.14 111.43,75.21 110.67,75.97 103.6,75.97 103.32,76.25 103.32,77.9 102.18,79.04 102.18,79.83 101.83,80.17 101.58,80.17
  IN1 w0.188: 101.58,80.17 94.57,80.17 91.52,83.22 80.32,83.22 79.54,82.43 75.46,82.43 75.35,82.32 73.66,82.32 v1(73.04,81.69)
  BOTTOM w0.1: v1(120.03,71.81) 120.43,71.41 UC1.AA22
  BOTTOM w0.168: JDIMM1.114 72.57,81.74 72.62,81.69 v1(73.04,81.69)
DDR_A_ALERT#: length 54
  IN1 w0.099: v1(117.6,71.82) 117.56,71.78 115.83,71.78 115.78,71.73 115.04,71.73 114.47,72.31 112.71,72.31 110.17,74.85 103.42,74.85 103.32,74.95 103.32,75.69 103.02,75.99 102.92,76.09 102.92,77.69 101.58,79.02
  IN1 w0.102: v1(74.4,81.72) 74.79,81.33 76.72,81.33 77.03,81.64 80.3,81.64 80.55,81.9
  IN1 w0.109: 101.58,79.02 93.92,79.02 91.05,81.9 80.55,81.9
  BOTTOM w0.1: v1(117.6,71.82) 117.6,71.79 118.03,71.36 UC1.AA25
  BOTTOM w0.102: v1(74.4,81.72) 74.4,81.34 74.06,81 72.79,81 72.54,81.24 72.54,81.24 72.53,81.25 70.96,81.25 JDIMM1.116
DDR_A_BA0: length 55.6
  IN1 w0.099: v1(120.83,66.81) 120.45,67.18 119.87,67.18 119.59,66.9 119.59,66.67 119.48,66.55 118.27,66.55 118.05,66.78 117.56,66.78 117.01,66.22 116.53,66.22 116.09,66.66 115.73,66.66 115.63,66.77 115.03,66.77 114.66,66.39 111.78,66.39 111.47,66.7 102.01,66.7
  IN1 w0.188: 102.01,66.7 101.92,66.79 87.68,66.79 83.74,70.73 80.05,70.73 78.75,72.03 74.6,72.03 73.82,72.8 v1(73.82,72.94)
  BOTTOM w0.1: UC1.AF21 121.23,67.21 v1(120.83,66.81)
  BOTTOM w0.168: JDIMM1.150 71.69,70.74 73.82,72.88 v1(73.82,72.94)
DDR_A_BA1: length 48.6
  IN1 w0.099: v1(116.77,66.8) 116.51,67.05 115.9,67.05 115.79,67.16 114.87,67.16 114.5,66.79 112.31,66.79 111.72,67.38 104.58,67.38 104.28,67.67 101.41,67.67
  IN1 w0.188: v1(76.39,72.93) 76.39,73.07 76.69,73.37 77.06,73.37 77.24,73.18 77.24,72.79 77.43,72.61 77.81,72.61 78,72.79 78,73.09 78.18,73.28 79.15,73.28 80.36,72.08 83.84,72.08 88.24,67.67 101.41,67.67
  BOTTOM w0.099: UC1.AF27 116.53,67.04 v1(116.77,66.8)
  BOTTOM w0.168: v1(76.39,72.93) 76.39,72.61 77.01,71.99 JDIMM1.145
DDR_A_BG0: length 60.3
  IN1 w0.099: 101.54,82.65 102.95,81.24 102.95,80.43 105.87,77.51 110.56,77.51 110.88,77.19 110.88,76.88 112.23,75.54 112.23,74.65 112.68,74.2 113.56,74.2 113.67,74.09 113.82,74.09 114.38,73.53 116.58,73.53 116.76,73.35 118.07,73.35 118.08,73.36 118.96,73.36 119.11,73.21 120.29,73.21 120.83,72.67 v1(120.83,71.81)
  IN1 w0.188: v1(74.97,83.79) 74.97,84.33 76.49,85.85 92.25,85.85 95.45,82.65 101.54,82.65
  BOTTOM w0.1: UC1.AA21 121.23,71.41 v1(120.83,71.81)
  BOTTOM w0.168: v1(74.97,83.79) 77.27,81.49 JDIMM1.115
DDR_A_BG1: length 53.4
  IN1 w0.099: v1(116.16,72.93) 115.95,73.14 114.21,73.14 113.65,73.7 113.5,73.7 113.4,73.8 112.51,73.8 111.83,74.49 111.83,75.37 110.7,76.5 104.21,76.5 103.98,76.73 103.98,78.84 102.49,80.33 102.49,81.14 102.17,81.46 101.58,81.46
  IN1 w0.188: v1(76.14,83.79) 76.6,83.33 78.06,83.33 79.4,84.66 91.76,84.66 94.96,81.46 101.58,81.46
  BOTTOM w0.1: UC1.AA27 116.53,71.51 116.19,71.85 116.19,72.15 116.18,72.16 116.18,72.91 v1(116.16,72.93)
  BOTTOM w0.168: JDIMM1.113 77.91,81.99 76.29,83.61 76.29,83.64 v1(76.14,83.79)
DDR_A_CKE0: length 53
  IN1 w0.099: v1(119.23,72.81) 118.88,73.16 118.16,73.16 118.16,73.15 116.6,73.15 116.42,73.34 114.29,73.34 113.73,73.9 113.59,73.9 113.48,74 112.6,74 112.03,74.57 112.03,75.45 110.77,76.72 104.28,76.72 104.18,76.81 104.18,78.92 102.75,80.35 102.75,81.16 101.86,82.06 100.89,82.06
  IN1 w0.188: 100.89,82.06 95.2,82.06 92,85.26 78.5,85.26 77.32,84.07 v1(77.32,83.79)
  BOTTOM w0.1: UC1.Y23 119.63,72.41 v1(119.23,72.81)
  BOTTOM w0.168: v1(77.32,83.79) 77.32,83.63 77.96,82.99 JDIMM1.109
DDR_A_CKE1: length 55.2
  IN1 w0.099: v1(117.64,72.78) 117.38,72.78 117.16,72.55 115.88,72.55 115.5,72.94 113.1,72.94 111.63,74.4 111.63,75.29 110.69,76.23 104.19,76.23 103.78,76.64 103.78,78.76 101.78,80.77 101.58,80.77
  IN1 w0.188: 101.58,80.77 94.81,80.77 91.77,83.81 79.57,83.81 78.8,83.04 74.54,83.04 v1(73.79,83.79)
  BOTTOM w0.099: UC1.Y26 117.23,72.37 v1(117.64,72.78)
  BOTTOM w0.168: v1(73.79,83.79) 73.79,83.25 73.27,82.74 JDIMM1.110
DDR_A_CLK0: length 55.1
  IN1 w0.099: v1(117.57,68.79) 117.57,68.87 117.67,68.96 117.92,68.96 118.02,68.87 118.02,68.43 117.92,68.33 117.45,68.33 116.94,68.84 115.68,68.84 115.58,68.94 115.02,68.94 114.81,68.73 112.86,68.73 111.75,69.84 104.14,69.84 102.74,71.24 101.59,71.24 101.55,71.27 101.47,71.27
  IN1 w0.188: 101.47,71.27 89.68,71.27 89.16,71.79 89.16,72.06 90.04,72.93 90.04,73.47 89.62,73.89 89.08,73.89 88.21,73.01 87.94,73.01 87.64,73.31 87.64,73.58 88.23,74.17 88.23,74.74 87.85,75.12 87.28,75.12 86.69,74.53 86.42,74.53 85.32,75.64 77.16,75.64 76.94,75.86 76.94,76.17 v1(77.17,76.4)
  BOTTOM w0.099: v1(117.57,68.79) 117.68,68.67 117.85,68.67 118.21,69.04 118.21,69.18 118.09,69.31 UC1.AD25
  BOTTOM w0.163: JDIMM1.137 78.18,75.99 78.07,75.88 77.15,75.88 77.02,76.01 77.02,76.24 v1(77.17,76.4)
DDR_A_CLK0#: length 55.3
  IN1 w0.099: v1(118.4,68.69) 118.35,68.64 118.35,68.47 118,68.13 117.37,68.13 116.85,68.65 115.6,68.65 115.5,68.74 115.1,68.74 114.89,68.53 112.77,68.53 111.66,69.64 104.05,69.64 102.66,71.04 101.62,71.04 101.53,70.95 101.49,70.95
  IN1 w0.188: 101.49,70.95 89.54,70.95 88.83,71.66 88.83,72.19 89.71,73.07 89.71,73.33 89.48,73.56 89.22,73.56 88.34,72.68 87.81,72.68 87.31,73.18 87.31,73.71 87.9,74.3 87.9,74.61 87.72,74.8 87.41,74.8 86.82,74.21 86.28,74.21 85.18,75.31 77.03,75.31 76.58,75.76 v1(76.58,76.4)
  BOTTOM w0.099: v1(118.4,68.69) 118.4,68.87 UC1.AD24
  BOTTOM w0.163: v1(76.58,76.4) 76.68,76.3 76.68,75.87 77.01,75.54 78.21,75.54 78.26,75.49 JDIMM1.139
