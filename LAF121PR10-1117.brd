# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.2VP: length 25
  TOP w0.203: v1(40.1,31.06) 39.88,31.06 39.37,30.56 39.37,29.79 39.35,29.77 39.35,29.72 38.84,29.21 PUM01.19
  TOP w0.508: v1(40.1,31.06) 41.26,31.06 41.52,31.33 45.86,31.33 46.06,31.12 47.88,31.12 PCM09.1
  IN1 w0.508: v1(35.9,31.24) 36.55,31.89 39.05,31.89 39.88,31.06 v1(40.1,31.06)
  BOTTOM w0.254: 43.61,31.11 43.16,31.11 42.64,31.63 38.72,31.63 38.57,31.78 36.42,31.78 35.9,31.26 v1(35.9,31.24)
  vias: v1(52.75,30.96) v1(52.75,30.37) v1(53.39,30.96) v1(53.39,30.37) v1(54.02,30.96) v1(54.02,30.37) v1(54.61,30.96) v1(54.61,30.37) v1(55.19,30.96) v1(55.19,30.37) v3(52.68,31.81)
+1.8V_ALW: length 228
  TOP w0.089: v1(171.43,45.77) 171.6,45.77 v4(171.93,46.1)
  TOP w0.254: RC6129.1 124.11,61.74 125.69,61.74 v1(125.75,61.81)
  TOP w0.508: RE40.1 32.72,69.44 v1(32.08,68.79) ; v1(149.13,74.97) 148.97,74.82 148.97,73.66 148.47,73.16 148.47,72.18 147.96,71.67 146.5,71.67 145.06,70.23 RC94.1
  IN2 w0.508: v1(33.82,49.27) 33.82,52.38 32.08,54.12 32.08,57.84 32.66,58.43 32.66,60.22 31.49,61.39 31.49,66.5 32.08,67.09 v1(32.08,68.79)
  IN3 w0.508: v1(148.94,41.4) 148.62,41.71 148.62,50.16 148.95,50.49 148.95,51.43 147.77,52.61 147.77,55.5 147.27,56.01 145.76,56.01 144.74,57.03 144.74,59.79 145.22,60.27 145.22,65.93 145.21,65.93 145.21,67.78 v1(145.05,67.95) ; v1(123.83,112.45) 124.59,112.45 125.98,113.83 125.98,114.09 126.6,114.71 127.75,114.71 129.06,113.4 130.76,113.4 131.56,112.6 133.23,110.93 133.9,110.93 135.64,109.18 135.64,107.29 140.76,102.18 140.76,87.28 142.65,85.39 142.65,82.33 144.97,80.01 145.39,80.01 147.1,78.29 148.84,78.29 149.44,77.7 149.44,75.28 v1(149.13,74.97)
  BOTTOM w0.508: 33.18,48.31 33.18,47.32 37.87,42.63 40.94,42.63 42.71,40.85 42.71,38.64 45.69,35.66 53.01,35.66 56.92,31.75 58.7,31.75 59.28,31.17 66.26,31.17 66.62,30.82 82.8,30.82 84.5,32.52 92.48,32.52 93.2,31.8 93.2,30.22 94.51,28.91 98.6,28.91 99.36,28.15 108,28.15 114.14,34.29 117.09,34.29 117.6,34.8 117.6,38.4 117.6,38.41 117.6,41.42 118.32,42.15 118.32,42.78 ; v1(145.05,67.95) 144.83,67.73 RC6125.1
  vias: v1(33.82,48.64) v1(118.23,44.29) v1(118.31,43.71) v1(118.92,43.71) v1(125.81,60.87) v1(171.62,44.75) v1(171.87,45.33) v1(172.3,44.9) v1(217.79,53.23) v1(218.25,52.82) v1(222.54,66.81) v1(223.47,66.85) v1(223.55,58.44) v1(224.1,66.85)
+1.8V_ALW_APU: length 1.9
  TOP w0.254: v1(123.63,63.11) 123.63,62.81 RC6129.2
  BOTTOM w0.305: UC1.AL19 v1(123.63,63.11) UC1.AM18
+1.8V_AVDD: length 23.2
  TOP w0.203: UA1.40 26.28,9.35 v1(26.26,9.33) 26.26,9.27 v3(25.78,8.78) 24.99,8 CA53.1
  TOP w0.381: v1(37.69,18.49) 37.7,18.5 RA53.1
  BOTTOM w0.381: v1(26.26,9.33) 27.47,10.54 28.99,10.54 30.07,9.46 32.04,9.46 32.67,10.09 32.67,11.06 33.31,11.69 33.31,16.18 35.62,18.49 v1(37.69,18.49)
+1.8VALWP: length 14.8
  IN1 w0.254: v1(173.82,61.4) 173.82,51.55 174.04,51.33 174.04,48.94 v1(174.41,48.57)
  BOTTOM w0.508: PC1807.1 173.77,60.44 PR1807.1 v1(173.82,61.4)
  vias: v1(174.85,48.97) v4(173.77,48.06)
+1.8VGS: length 121.7
  TOP w0.381: 111.88,135.6 112.67,134.81 RV28.1 ; 111.88,135.6 112.44,136.16 112.93,136.16 113.38,136.61 RV11.1 ; 111.88,135.6 110.44,135.6 110.11,135.28 LV2.1
  TOP w0.508: v1(115.81,133.54) 115.81,134.15 RV8.1 ; LV6.1 126.46,122.85 v1(125.99,122.38) ; v1(129.99,118.23) 130.54,118.23 131.22,118.91 LV7.1 ; PRV12.1 67.92,131.69 v1(67.84,131.77)
  IN2 w0.508: v1(125.12,117.51) 126.57,118.96 126.96,118.96 127.68,119.68 127.7,119.68 ; v1(129.99,118.23) 128.8,119.42 127.95,119.42 127.7,119.68 ; 127.7,119.68 127.95,119.93 127.95,121.52 127.09,122.38 v1(125.99,122.38)
  IN3 w0.508: v1(113.03,117.58) 111.69,116.24 111.69,113.42 v1(108.82,110.55)
  BOTTOM w0.254: RV71.1 107.35,126.97 107.78,126.54 107.78,126.28 108.1,125.97 108.47,125.97 108.49,125.98 109.18,125.98 v1(109.56,126.36) ; v1(109.16,132.55) 111.62,132.55 112.48,133.41 115.68,133.41 v1(115.81,133.54) ; v1(113.42,142.96) 113.38,142.96 UV1.AM30
  BOTTOM w0.508: RV81.2 RV82.2 v1(121.97,117.51) ; v1(125.12,117.51) 125.32,117.51 125.83,118.02 RV152.2 ; v1(108.82,110.55) 108.55,110.28 106.9,110.28 106.6,110.58 95.55,110.58 92.8,113.32 84.62,113.32 82.4,111.1 80.51,111.1 78.89,112.72 74.05,112.72 72.47,111.14 65.25,111.14 63.37,113.02 60.84,113.02 59.83,114.04 59.83,115.74 57.76,117.81 57.76,122.18 60.49,124.92 60.9,124.92 63.29,127.3 63.29,127.73 67.33,131.77 v1(67.84,131.77)
  vias: v1(113.67,117.58) v1(120.52,112.37) v1(120.94,111.84) v4(117.64,118.17)
+1.8VS: length 206.8
  TOP w0.381: UC5.5 133.31,95.07 133.56,95.31
  TOP w0.508: 123.76,97.76 132.79,97.76 133.56,96.99 133.56,95.31 134.26,94.61 148,94.61 149.18,93.43 v1(149.51,93.43) 150.22,93.43 150.83,94.03 154.21,94.03 154.72,93.53 PRZ16.1 ; RC10.2 128.69,89.82 v1(128.65,89.85) 128.69,89.88 128.69,90.48 128.91,90.7 QC1.2 ; RC8.1 125.38,91.92 v1(125.31,91.99) ; RC8.1 RC7.1 ; RC8.1 RC6.1 ; v1(149.03,92.25) 148.63,91.85 147.76,91.85 144.7,88.78 144.7,81.1 147.11,78.68 149.1,78.68 150.06,77.72 150.06,75.81 149.91,75.67 149.91,74.51 149.76,74.36 149.76,73.34 149.26,72.83 149.26,71.68 149.06,71.48 149.06,64.21 150.28,62.99 150.68,62.99 151.41,62.26 151.41,59.73 151.77,59.37 151.77,58.62 150.82,57.67 v1(150.39,57.67) ; RC97.1 145.83,61.91 v1(145.91,61.83) 145.99,61.91 146.86,61.91 147.75,61.02 148.36,61.02 RC15.1
  IN1 w0.508: v1(130.86,87.64) 130.86,87.67 130.49,88.04 130.02,88.04 128.69,89.38 128.69,89.82 v1(128.65,89.85) 128.65,90.11 127.83,90.93 126.37,90.93 v1(125.31,91.99) ; v1(32.04,28.19) 33.12,27.1 35.41,27.1 37.82,24.7 37.82,22.88 36.82,21.89 36.82,19.54 36.37,19.08 v1(36.37,15.6)
  IN2 w0.508: v1(32.04,28.19) 33.04,29.19 33.04,29.44 38.51,34.91 38.51,35.58 39.43,36.5 39.43,38.72 40.98,40.27 40.98,42.64 v1(40.15,43.47)
  IN3 w0.508: v1(149.03,92.25) 149.37,92.59 149.37,93.29 v1(149.51,93.43)
  BOTTOM w0.508: v1(146.14,56.65) 145.94,56.45 RC12.1
  BOTTOM w0.762: 107.7,30.92 107.7,29.86 106.72,28.88 99.66,28.88 98.9,29.64 95.33,29.64 94.57,30.4 94.57,31.92 93.1,33.4 87.85,33.4 ; 41.39,43.73 43.44,41.68 43.44,38.94 45.99,36.39 53.32,36.39 57.22,32.48 59.34,32.48 59.4,32.42 65.74,32.42 66.02,32.14 68.86,32.14 69.88,33.17 83.69,33.17 84.24,33.71
  vias: v1(38.25,44.1) v1(38.25,43.47) v1(38.88,44.1) v1(38.88,43.47) v1(39.52,44.1) v1(39.52,43.47) v1(40.15,44.1) v1(84.11,38.1) v1(84.74,38.1) v1(121.51,46.6) v1(121.96,45.56) v1(122.59,96.64) v1(122.85,62.38) v1(123.1,96.26) v1(123.36,62.11) v1(123.57,95.87) v4(38.39,42.73)
+1.8VS_GATE: length 7.8
  TOP w0.203: v1(35.53,50.03) 35.58,50.08 U6.5
  TOP w0.508: C42.2 35.45,47.94 v4(34.57,47.94) v1(33.82,47.94) 33.37,47.49 33.07,47.49 R27.2 R703.2
  BOTTOM w0.508: v1(35.53,50.03) 35.53,49.5 34.01,47.98 33.91,47.98 33.87,47.94 v1(33.82,47.94)
+1.8VS_LS:
  vias: v4(38.9,48.08)
+1.35V_MEM_GFX: length 147.1
  TOP w0.254: UV14.E10 v1(158.73,122.09) UV14.D11 ; UV14.K3 154.22,128.2 154.03,128.2 153.51,128.72 UV14.L2 UV14.L1 153.51,130.23 v1(153.51,130.23) ; UV12.L11 156.71,144.33 v1(156.31,144.73) 155.91,145.13 UV12.K12 ; UV14.T1 v1(149.05,130.17) ; v1(151.51,137.52) 151.11,137.93 UV12.D3 ; UV14.R5 v1(149.91,126.91) ; v1(150.71,127.71) UV14.P3 ; UV12.K3 155.91,137.93 v1(156.31,137.52) ; UV14.M14 v1(153.11,118.91) UV14.L14 ; UV14.T12 v1(149.11,121.31) ; UV14.T14 v1(149.91,118.91) ; UV14.M1 152.71,130.28 v1(152.69,130.29) ; UV12.C5 150.4,139.53 v1(150.73,139.86) ; UV12.C10 150.31,143.52 v1(149.91,143.13) ; UV12.F3 152.71,137.93 v1(153.11,137.52) 153.51,137.13 UV12.G2 ; UV14.N5 v1(152.31,126.91) ; UV14.P14 v1(150.71,118.91) ; v1(151,130.34) 151.11,130.24 UV14.P1 UV14.P2 151.1,128.91 v1(150.71,128.51) ; UV12.F1 152.71,136.32 v1(153.11,135.92) 153.51,136.32 UV12.G1 ; UV14.M12 v1(153.11,120.51) UV14.L13 ; UV12.B1 149.55,136.28 149.55,135.65 v1(149.14,135.24) ; UV12.E5 151.91,139.53 v1(151.51,139.93) ; UV12.G4 v1(153.93,138.31) UV12.H3 ; UV12.D1 151.11,135.99 v1(150.88,135.76) ; UV14.D14 v1(159.11,118.79) ; UV14.H12 UV14.G13 v1(156.31,119.71) ; UV12.E10 151.91,143.53 v1(151.49,143.95) 151.11,144.33 UV12.D11 ; UV14.L4 v1(153.11,126.91) ; UV14.T3 149.51,128.11 v1(149.91,128.51) ; v1(149.91,137.52) 149.51,137.93 UV12.B3 ; UV14.L11 v1(153.91,121.31) UV14.K12 ; UV14.M3 152.71,128.11 v1(152.31,128.51) ; UV14.C10 v1(160.31,122.91) ; UV14.P11 v1(150.71,122.11) ; UV14.P12 v1(150.71,121.31) ; UV12.F12 v1(152.31,144.73) ; UV14.G14 v1(156.71,118.74) ; UV14.G11 v1(157.11,122.11)
  TOP w0.33: UV14.D3 158.71,128.51 v1(158.61,128.51) ; UV14.B12 160.71,120.85 161.04,120.52 v1(161.19,120.52) ; UV14.R10 150.4,122.51 v1(150.71,122.81) ; UV14.N10 151.82,122.51 v1(151.51,122.82)
  TOP w0.508: CV176.1 128.43,130.25 v1(128.92,129.76) 128.92,129.37 CV175.1 ; v1(163.53,129.02) CV227.1 ; v1(154.64,150.66) RV79.1 RV80.1 ; CV47.1 127.41,131.85 v1(127.75,131.51) 127.75,131.25 CV177.1 CV48.1 ; CV174.1 129.32,127.09 v1(129.36,127.05) 129.51,126.9 CV53.1
  BOTTOM w0.254: UV12.B1 149.55,136.28 149.55,135.65 v1(149.14,135.24) ; UV14.G11 v1(157.11,122.11) ; UV12.T3 160.71,137.92 v1(160.31,137.52) ; v1(159.42,120.51) 159.11,120.82 UV14.D12 ; v1(161.11,135.93) 160.71,136.32 UV12.T1 ; UV14.T12 v1(149.11,121.31) ; UV15.D13 151.17,120.16 151.17,120.85 UV14.P12 v1(150.71,121.31) ; v1(151.51,122.82) 151.82,122.51 UV14.N10 ; v1(130.93,129.57) 130.54,129.95 UV1.H13 ; UV14.M14 v1(153.11,118.91) UV14.L14 ; v1(156.31,135.92) 156.71,136.32 UV12.L1 ; UV14.E10 v1(158.73,122.09) UV14.D11 ; v1(161.11,144.73) 160.71,145.13 UV12.T12 ; v1(157.1,121.3) 157.11,121.3 UV14.F12 ; UV12.N5 158.31,139.87 v1(158.45,140.01) ; UV1.H16 131.17,133.42 v1(131.17,133.49) ; UV12.P14 159.11,146.73 v1(159.51,147.13) ; UV1.K9 129.01,127.4 129.33,127.08 ; UV12.G4 v1(153.93,138.31) UV12.H3 ; 129.33,127.08 v1(129.33,127.77) ; 129.33,127.08 v1(129.36,127.05) 129.72,127.4 UV1.J9 ; v1(149.14,147.1) 149.51,146.73 UV12.B14 ; UV12.D11 151.11,144.33 v1(151.49,143.95) 151.91,143.53 UV12.E10 ; UV14.N5 v1(152.31,126.91) ; v1(150.71,128.51) 151.11,128.11 UV14.P3 v1(150.71,127.71) ; UV13.D13 159.04,145.86 159.04,145.19 UV12.P12 159.11,145.13 v1(159.51,144.73) ; v1(129.33,127.77) 129.74,128.18 UV1.J10 ; v1(129.33,127.77) 128.94,128.16 UV1.K10 UV1.L11 UV1.L12 ; UV14.F3 v1(157.11,128.51) UV14.G2 ; v1(156.31,119.71) UV14.G13 UV14.H12 ; v1(159.56,143.13) 159.91,143.48 UV12.R10 ; v1(159.14,130.3) 159.11,130.27 UV14.D1 ; v1(128.84,135.84) 128.79,135.8 UV1.L20 UV1.L21 UV1.L22 128.37,137.8 v1(128.69,138.12) 128.69,138.35 UV1.K23 128.94,138.66 v1(129.31,139.04) ; UV12.N10 158.31,142.99 v1(158.31,142.99) ; UV12.F14 152.7,146.74 152.7,147.14 v1(152.61,147.23) ; UV12.K3 155.91,137.93 v1(156.31,137.52) 156.71,137.13 UV12.L2 ; v1(127.75,131.51) 128.14,131.12 UV1.L13 UV1.L12 ; v1(157.09,127.71) 156.71,127.33 UV14.G4 UV14.H3 155.51,128.51 154.71,128.51 UV14.K3 UV14.L2 ; UV14.T1 v1(149.05,130.17) ; v1(153.82,147.16) 153.51,146.85 UV12.G14 ; UV1.J24 129.67,139.4 v1(129.31,139.04) ; UV14.B12 160.8,120.91 v1(161.19,120.52) ; UV14.G14 v1(156.71,118.74) ; v1(150.73,139.86) 150.4,139.53 UV12.C5 ; UV14.P14 v1(150.71,118.91) ; v1(129.31,139.04) 129.74,138.61 UV1.J23 ; v1(129.31,139.04) 128.96,139.4 UV1.K24 ; UV14.R5 v1(149.91,126.91) ; v1(157.53,135.79) 157.51,135.81 UV12.M1 ; v1(130.77,134.69) 130.54,134.92 UV1.H19 ; UV12.P3 159.11,137.93 v1(159.51,137.52) ; v1(159.51,143.93) 159.11,144.33 UV12.P11 ; UV14.M12 v1(153.11,120.51) UV14.L13 ; UV14.M1 152.71,130.28 v1(152.69,130.29) ; UV12.D14 151.11,147.16 v1(151.02,147.24) ; UV13.P2 151.11,137.12 v1(151.51,137.52) 151.11,137.93 UV12.D3 ; v1(128.92,129.76) 128.68,130 UV1.L12 ; v1(161.08,130.79) 160.71,130.43 UV14.B1 ; UV12.F12 v1(152.31,144.73) ; UV14.B14 160.71,119.31 v1(161.08,118.93) ; UV14.K12 v1(153.91,121.31) UV14.L11 ; UV12.B3 149.51,137.93 v1(149.91,137.52) ; UV12.F1 152.71,136.32 v1(153.11,135.92) 153.51,136.32 UV12.G1 ; UV14.G1 156.71,129.86 v1(157.03,130.18) UV14.F1 ; UV12.L11 156.71,144.33 v1(156.31,144.73) 155.91,145.13 UV12.K12 ; UV14.D3 159.01,128.11 v1(158.61,128.51) 159.01,128.91 UV15.P2 ; v1(149.91,143.13) 150.31,143.52 UV12.C10 ; v1(157.49,118.73) 157.51,118.75 UV14.F14 ; v1(153.51,130.23) 153.51,130.23 UV14.L1 ; v1(151.51,139.93) 151.91,139.53 UV12.E5 ; v1(150.88,135.76) 151.11,135.99 UV12.D1 ; v1(160.31,147.13) 160.71,146.73 UV12.T14 ; v1(159.59,126.12) 159.91,126.44 UV14.C5 ; UV12.G11 153.51,144.32 v1(153.13,143.95) ; v1(152.31,128.51) 152.71,128.11 UV14.M3 ; UV12.L4 156.71,138.73 v1(157.11,139.13) ; UV14.P1 151.11,130.24 v1(151,130.34) ; v1(157.91,137.52) 157.51,137.93 UV12.M3 ; v1(153.91,146.33) 153.51,145.93 UV12.G13 UV12.H12 ; UV12.B12 149.51,145.13 v1(149.88,144.75) ; UV12.G2 153.51,137.13 v1(153.11,137.52) 152.71,137.93 UV12.F3 ; UV14.T14 v1(149.91,118.91) ; UV14.E5 v1(157.9,126.1) ; v1(160.31,139.13) 159.91,139.53 UV12.R5 ; UV14.T3 149.51,128.11 v1(149.91,128.51) ; UV14.P11 v1(150.71,122.11) ; UV14.L4 v1(153.11,126.91) ; v1(160.4,128.5) 160.4,128.42 UV14.B3 ; v1(159.13,135.76) 159.11,135.78 UV12.P1 ; v1(150.71,145.53) 151.11,145.13 UV12.D12 ; UV12.L13 156.71,145.93 v1(157.11,145.53) 157.51,145.13 UV12.M12 ; UV14.C10 v1(160.31,122.91) ; UV14.D14 v1(159.11,118.79) ; UV14.R10 150.4,122.51 v1(150.71,122.81) ; UV12.L14 156.71,146.73 v1(157.11,147.13) 157.51,146.73 UV12.M14
  BOTTOM w0.508: CV230.1 160.31,147.13 v1(160.31,147.13) ; CV155.1 163.05,140.33 v1(163.05,140.32) ; CV164.1 160.7,117.4 v1(160.44,117.66) ; CV233.1 159.3,147.34 v1(159.51,147.13) ; CV235.1 158.28,148.85 157.11,147.68 v1(157.11,147.13) ; RV117.2 RV131.2 156.12,133.4 v1(157.52,134.8) ; RV54.1 153.62,148.56 153.96,148.22 153.96,147.3 v1(153.82,147.16) ; CV173.1 v1(163.63,130.1) ; CV334.1 v1(159.62,117.39) ; CV219.1 157.61,117.21 v1(157.49,117.33) ; CV161.1 v1(163.63,126.86) ; CV170.1 v1(163.63,124.7) ; v1(162.8,136.15) 163.93,136.15 CV158.1 ; CV157.1 v1(163.23,137.22) ; CV335.1 v1(158.54,117.33) ; CV162.1 v1(163.63,127.94) ; CV153.1 v1(163.48,121.85) ; CV160.1 v1(163.63,125.78) ; CV221.1 v1(151.93,117.45) ; CV216.1 v1(163.48,120.77)
  vias: v1(128.52,139.78) v1(128.47,134.31) v1(129.32,139.76) v1(135.25,131.27) v1(135.84,131.27) v1(155.81,114.07) v1(155.81,113.49) v1(156.39,114.07) v1(156.39,113.49) v1(156.97,114.07) v1(156.97,113.49) v1(157.56,114.07) v1(157.56,113.49) v1(158.14,114.07) v1(158.14,113.49) v4(142.78,147.25)
+1.35VGPUP: length 14.1
  BOTTOM w0.254: 154.97,111.77 154.95,111.79 154.95,113.03 154.94,113.04 154.94,113.68 154.77,113.85 152.43,113.85 152.1,113.52 PCW14.1 146.66,113.52 146.03,112.9 144.1,112.9 144.04,112.84 143.91,112.84 143.48,112.4 PRW09.2
  vias: v1(153.68,110.45) v1(153.68,109.86) v1(153.95,110.97) v1(154.35,110.49) v1(154.35,109.9) v4(154.91,110.49)
+2.5V_MEM: length 60.1
  TOP w1.524: 56.88,52.64 56.93,52.69 56.93,61.91 56.61,62.23 56.61,110.42 58.14,111.95
  vias: v1(63.34,43.04) v1(63.75,42.6) v1(77.05,43.19) v1(77.48,42.74) v4(56.55,46.79)
+2.5VP:
  vias: v3(62.07,112.58)
+3.3V_ADP_DCIN: length 103
  TOP w0.089: v1(59.55,132.69) 59.55,132.88 v4(59.25,133.18)
  TOP w0.254: PR22.1 87.82,149.23 88.39,149.8 89.3,149.8 v1(89.42,149.92) 89.98,150.48 PR14.1
  TOP w0.508: v1(46.01,116.82) 46.01,117.15 45.7,117.46 PRS32.1 PRS04.1 ; PDS01.2 55.04,122.23 v1(55.04,122.84) 55.04,123.4 PRS44.2 ; v1(41.36,126.09) 41.36,126.68 PRS65.1 ; PU1.5 84.03,144.37 83,143.34 83,142.21 82.37,141.58 PC9.1 82.37,140.95 PD11.2 83.28,139.76 v1(82.88,139.35) ; v1(60.93,123.68) 61.69,124.44 PRS34.1
  IN1 w0.254: v1(86.03,143.16) 85.31,142.45 83.2,142.45 82.7,141.94 82.7,140.92 82.88,140.74 v1(82.88,139.35)
  IN1 w0.508: v1(59.55,132.69) 59.96,132.69 60.46,133.18 70.86,133.18 71.73,134.04 74.04,134.04 76.23,136.24 78.89,136.24 79.4,136.75 79.4,139.22 79.84,139.66 81.73,139.66 82.04,139.35 v1(82.88,139.35)
  IN2 w0.254: v1(86.03,143.16) 88.62,143.16 89.23,143.77 89.23,149.73 v1(89.42,149.92)
  IN2 w0.508: v1(55.04,122.84) 58.22,126.02 58.22,131.35 v1(59.55,132.69)
  IN3 w0.508: v1(55.04,122.84) 55.36,122.84 56.21,123.68 v1(60.93,123.68) ; v1(46.01,116.82) 45.92,116.92 45.92,120.81 41.36,125.37 v1(41.36,126.09)
  BOTTOM w0.254: v1(89.42,149.92) 89.87,149.46 PR60.1
  BOTTOM w0.508: v1(55.04,122.84) 55.04,122.56 54.06,121.59 49.74,121.59 47.54,119.39 47.54,118.35 v1(46.01,116.82)
+3.3V_VBUS_IN: length 283.4
  TOP w0.381: v1(54.31,122.87) 54.31,122.53 54.06,122.28 PDS01.3
  TOP w0.508: PRS12.1 48.79,124.54 v1(49.03,124.29) ; PUS04.3 80.4,143.94 79.73,143.27 PCS16.1 79.73,141.93 v1(79.71,141.91) 79.94,141.68 79.94,141.49 81.4,140.04 PD11.3 ; v1(164.72,36.34) 164.72,36.06 164.59,35.93 PRB38.1 ; PRS13.1 v1(56.05,132.25)
  IN1 w0.508: v1(55.32,125.57) 55.3,125.59 51.22,125.59 49.92,124.29 v1(49.03,124.29)
  IN2 w0.508: v1(79.71,141.91) 79.71,141.75 79.14,141.18 78.44,141.18 75.5,138.24 73.06,138.24 72.23,139.08 63.41,139.08 60.89,136.56 56.84,136.56 56.05,135.77 v1(56.05,132.25) 54.81,131.02 54.81,127.15 55.32,126.64 v1(55.32,125.57) 54.31,124.56 v1(54.31,122.87) ; v1(52.03,112.63) 52.45,113.05 60.42,113.05 60.61,113.24 63.27,113.24 64.21,112.29 65.65,112.29 66.21,111.74 72.43,111.74 73.93,113.24 75.97,113.24 77.05,112.16 82.2,112.16 82.92,112.89 89.7,112.89 90.87,111.71 94.78,111.71 95.54,110.96 101.07,110.96 105.82,106.21 118.66,106.21 118.92,106.47 125.83,106.47 126.24,106.88 128.36,106.88 128.89,107.41 132.63,107.41 135.25,104.79 139,104.79 141.31,102.48 141.31,99.22 146,94.53 146,90.43 148.2,88.22 148.2,84.58 149.18,83.6 150.31,83.6 152.33,81.58 165.17,81.58 168.22,78.53 168.22,68.82 170.5,66.53 170.5,65.72 171.89,64.34 171.89,53.69 170.84,52.64 161.94,52.64 159.57,50.27 153.39,50.27 151.36,48.25 151.36,42.18 153.4,40.13 154.28,40.13 154.75,39.66 162.37,39.66 164.72,37.3 v1(164.72,36.34)
  IN3 w0.508: v1(49.03,124.29) 49.91,123.41 49.91,120.04 49.39,119.52 49.39,117.85 52.03,115.2 v1(52.03,112.63)
  vias: v3(56.36,125.66)
+3.3V_VDD_PIC: length 31.2
  TOP w0.508: RT2.1 17.71,119.14 v1(17.71,118.92) ; RT6.1 39.01,113.29 35.7,116.61 v1(35.7,116.75)
  IN1 w0.508: v1(29.83,119.63) 30.77,119.63 33.58,116.82 35.62,116.82 v1(35.7,116.75)
  IN3 w0.508: v1(29.83,119.63) 29.55,119.63 27.53,117.62 24.59,117.62 24.48,117.73 18.34,117.73 17.71,118.35 v1(17.71,118.92)
  BOTTOM w0.508: RT4.1 30.22,118.68 29.83,119.07 v1(29.83,119.63) 29.6,119.63 29.21,120.02 29.21,120.79 29.57,121.15 RT64.1
  vias: v1(33.52,127.52) v1(33.52,126.88) v1(33.52,126.25) v1(40.29,111.87) v1(40.93,111.87) v1(41.56,111.87) v1(42.2,111.87) v4(32.51,121.99)
+3V_1.8V_CPVDD: length 29.7
  TOP w0.089: v1(38.44,20.67) 38.44,21.67 v3(38.32,21.79)
  TOP w0.203: v1(23.85,10.6) 23.72,10.73 23.72,10.92 23.87,11.07 UA1.36
  TOP w0.381: v1(38.44,20.67) RA7.2
  TOP w0.508: CA12.1 v1(21.12,8.95) ; CA14.1 RA58.2 RA7.2
  BOTTOM w0.381: v1(21.12,8.95) 22.2,8.95 v1(23.85,10.6) 25.12,11.87 32.45,11.87 32.83,12.25 32.83,16.37 37.13,20.67 v1(38.44,20.67)
+3V_DVDD: length 5.5
  TOP w0.127: v4(34.65,9.18) 34.84,8.99 35.63,8.99
  TOP w0.203: v1(31.02,10.49) 31.1,10.58 31.1,10.86 30.89,11.07 UA1.1
  TOP w0.508: CA7.1 39.35,20.86 RA7.1 RA2.1 39.71,18.82 v1(39.71,18.51) ; RA10.2 v1(31.36,17.65)
  vias: v1(35.59,9.53)
+3V_HUB: length 1.9
  TOP w0.508: v1(217.59,63.24) 217.39,63.05 R59.1 ; R63.1 v1(219.05,63.24) ; R61.1 v1(218.22,63.24)
  vias: v1(213.22,56.21) v1(215.74,56.26) v1(216.44,56.26) v1(218.28,59.62) v4(210.66,55.68)
+3VALW: length 357.9
  TOP w0.254: PRW03.1 v1(147.44,112.11)
  TOP w0.508: CC13.1 132.88,47.24 v1(132.84,47.28) 132.84,47.31 132.88,47.35 RC33.1 ; RW13.1 73.01,138.73 73.38,138.36 74.27,138.36 v1(75.08,139.18) ; v1(148.7,54.63) 148.23,54.63 147.73,55.14 147.73,55.55 147.22,56.05 145.91,56.05 145.58,56.38 RC48.2 ; UC21.5 v1(24.28,24.3) ; RE17.1 34.08,74.63 v1(34.27,74.44) ; RE5.2 v1(52.12,86.2) ; v1(207.37,48.64) 207.63,48.38 207.73,48.38 208.24,47.87 PRB27.1 ; v1(45.31,86.81) 45.31,86.81 RE510.1 RE509.1 ; v1(16.91,127.17) 16.48,126.74 RT19.1 RT25.1 ; RA54.1 v1(27.72,22.66) ; RC905.1 RC6121.1 RC906.1 147.28,64 148.02,63.26 148.02,63.03 148.55,62.5 RC56.1 148.29,62.73 v1(145.91,62.73) RC619.2 ; v1(47.25,63.94) 47.47,64.16 RE23.1 ; v1(131.06,47.32) 131.06,47.34 131.1,47.37 RC6122.1 ; PRM06.1 31.75,26.66 31.24,26.15 v1(31.24,25.2) ; PR5.2 60.95,122.89 v1(61.36,122.48) 61.45,122.56 PRS28.1 ; v1(25.8,122.35) 25.5,122.04 RT17.1 RT23.1 RT27.1 ; R15.1 112.67,27.68 112.93,27.94 v1(112.93,28.29) ; RC41.2 131.99,47.36 v1(131.95,47.32) ; RC17.2 130.21,47.27 v1(130.2,47.27) ; RE19.1 39.85,86.27 v1(39.85,87.02) ; RC53.1 124.88,42.72 124.49,42.33 v1(124.49,42.29) ; v1(131.49,33.66) 131.12,33.66 130.73,33.27 130.73,30.97 v1(133.28,28.42) ; RV165.2 v1(49.49,90.61) ; RT131.1 18.44,117.67 17.92,117.15 17.92,116.89 CT32.1 17.59,116.56 v1(17.59,115.93) ; RC40.1 v1(128.44,47.32) ; R801.2 210.12,50.57 v1(210.12,48.69) ; v1(29.63,122.74) 28.73,121.85 DT1.2
  IN1 w0.508: v1(31.53,86.79) 31.73,86.58 37.21,86.58 37.8,87.18 39.68,87.18 v1(39.85,87.02) 39.85,86.88 41.22,85.5 43.84,85.5 45.15,86.81 v1(45.31,86.81) 45.32,86.81 45.93,86.2 v1(52.12,86.2) ; v1(68.36,137.16) 68.36,137.89 69.06,138.59 74.5,138.59 v1(75.08,139.18) ; v1(145.75,44.43) 145.75,39.38 145.23,38.86 143.89,38.86 143.39,38.35 143.39,37.83 142.63,37.07 v1(142.63,36.91) 142.63,36.36 142.46,36.18 142.46,34.64 141.95,34.13 132.81,34.13 132.53,33.85 131.71,33.85 131.53,33.68 131.51,33.68 v1(131.49,33.66)
  IN2 w0.508: v1(124.49,42.29) 124.49,42.46 125,42.97 126.13,42.97 127.98,44.83 v1(128.08,44.83) ; v1(49.49,90.61) 50.95,90.61 52.12,89.44 v1(52.12,86.2) 52.22,86.1 52.22,84.26 53.3,83.18 v1(53.3,73.39) ; v1(148.7,54.63) 148.7,53.62 148.95,53.37 148.95,50.43 148.62,50.1 148.62,44.61 148.45,44.43 v1(145.75,44.43) ; v1(105.32,114.1) 105.12,114.1 104.61,113.6 91.82,113.6 90.65,114.77 87.44,114.77 84.89,117.32 81.23,117.32 79.63,115.72 78.88,115.72 v1(77.67,114.51) ; v1(61.36,122.48) 61.39,122.48 61.9,122.99 61.9,129.91 61.65,130.16 61.65,135.98 63.8,138.12 67.85,138.12 68.36,137.61 v1(68.36,137.16) ; v1(147.44,112.11) 147.44,112.43 146.68,113.19 143,113.19 141.44,111.63 136.28,111.63 135.84,112.07 131.76,112.07 131.53,111.84 121.76,111.84 121.11,111.18 120.39,111.18 119.45,112.12 112.61,112.12 111.17,113.56 111.17,117.57 v1(109.48,119.26)
  IN3 w0.508: v1(148.7,54.63) 148.7,55.42 147.51,56.61 147.26,56.61 146.47,57.4 146.47,57.99 145.82,58.63 145.82,58.66 145.82,58.67 145.82,60.02 145.82,60.03 145.82,60.87 146.49,61.54 146.49,62.18 145.94,62.73 v1(145.91,62.73) ; v1(105.32,114.1) 105.89,114.67 105.89,116.2 108.95,119.26 v1(109.48,119.26) ; v1(62.03,114.26) 62.03,114.44 62.66,115.07 63.75,115.07 65.18,113.64 67.02,113.64 67.82,114.45 71.92,114.45 72.28,114.81 77.11,114.81 v1(77.24,114.94) ; v1(24.84,128.27) 21.83,128.27 20.91,127.35 17.09,127.35 v1(16.91,127.17) ; v1(53.3,73.39) 53.3,70.44 47.25,64.4 v1(47.25,63.94)
  BOTTOM w0.356: RT37.1 30.64,126.35 30.64,125.38
  BOTTOM w0.381: RT36.1 30.64,122.88 30.64,123.78
  BOTTOM w0.457: v1(145.75,44.43) 145.93,44.26 UC9.5 ; UC4.5 109.48,118.85 v1(109.48,119.26)
  BOTTOM w0.508: RT35.1 RT24.1 16.91,116.44 v1(16.48,116.01) ; PRH03.1 168.19,43.48 168.61,43.06 170.02,43.06 v1(170.56,43.59) 170.47,43.68 170.47,46.76 170.01,47.22 169.29,47.22 168.95,46.88 PRH05.1 ; v1(142.63,36.91) 142.63,36.52 142.5,36.39 RC6130.1 ; RT72.1 RT73.1 36.29,116.84 v1(36.32,116.81) ; RT37.1 v1(31.49,126.42) ; RT36.1 v1(29.63,122.74) ; v1(22.58,116.06) 22.88,116.37 RT29.1 RT30.1 RT20.1 ; v1(34.27,74.44) 33.27,74.44 30.02,77.69 30.02,85.72 30.9,86.6 v1(30.9,86.79) ; v1(124.49,42.29) 124.49,41.66 124.88,41.28 125.61,41.28 126.12,40.77 126.12,38.98 125.58,38.45 125.58,36.56 126.31,35.83 126.31,35.26 127.44,34.13 130.79,34.13 131.26,33.66 v1(131.49,33.66) ; v1(61.36,122.48) 61.36,121.45 60.5,120.58 60.5,116.77 61.69,115.58 61.69,114.61 v1(62.03,114.26)
  vias: v1(23.69,89.61) v1(24.28,89.61) v1(25.47,128.27) v1(26.11,128.27) v1(30.26,56.51) v1(30.26,55.88) v1(30.26,55.24) v1(30.26,54.61) v1(30.26,53.97) v1(30.26,53.34) v1(30.26,52.7) v1(30.26,52.07) v1(30.9,56.51) v1(30.9,55.88) v1(30.9,55.24) v1(30.9,54.61) v1(30.9,53.97) v1(30.9,53.34) v1(30.9,52.7) v1(30.9,52.07) v1(97.76,26.69) v1(98.1,32.37) v1(98.4,26.69) v1(98.74,32.37) v1(134.02,28.63) v1(134.46,29.08) v1(171.19,43.59) v1(171.67,28.57) v1(171.99,28.06) v1(181.91,59.95) v1(182.55,59.95) v1(225.09,63.97) v1(225.09,63.33) v4(26.13,93.15) v4(32.19,52.88) v4(98.28,30.21)
+3VALW_APU: length 61.9
  TOP w0.254: CC66.1 123.8,42.98 123.63,42.82 v3(123.63,42.29) 123.63,41.63 v1(123.58,41.58) 122.65,40.65 122.65,34.51 v1(122.98,34.18)
  IN3 w0.254: v1(125.23,63.11) 125.23,63.06 126.26,62.03 126.26,56.08 126.78,55.56 126.78,53.99 125.82,53.03 125.82,51.67 125.18,51.02 125.18,48.78 125.43,48.52 125.43,47.11 123.97,45.65 123.97,44.56 123.36,43.96 123.36,41.8 123.58,41.58 v1(123.58,41.58)
  BOTTOM w0.254: v1(122.98,34.18) 123.96,34.18 126.65,31.49 128.33,31.49 129.25,30.57 134.65,30.57 135.18,30.04 136.41,30.04 136.72,29.73 136.72,26.64 136.36,26.27 RC6126.2 136.05,25.45 135.56,24.95 134.1,24.95 133.78,25.27 UC20.1
  BOTTOM w0.305: UC1.AM16 v1(125.23,63.11) UC1.AL17
  BOTTOM w0.508: v1(123.58,41.58) 123.63,41.63 123.63,43.34 123.1,43.87 CC67.1 CC68.1
+3VALW_EC: length 86.1
  TOP w0.203: UE1.9 40.55,66.8 40.41,66.66 v1(40.41,66.56) 40.41,66.41 40.52,66.29 40.52,65.77 CE4.1 ; UE1.22 45.75,66.97 46.19,66.54 v1(46.19,66.32) 45.86,66 45.39,66 CE2.1 ; UE1.33 52.21,69.41 52.65,69.85 CE3.2 ; UE1.125 34.68,70.61 34.48,70.4 34.48,70.27 v1(34.24,70.03)
  TOP w0.254: LE1.1 37.41,87.72 37.41,90.84 36.03,92.22 36.03,102.08 37.65,103.7 37.65,105.28 41.27,108.9 42.49,108.9 45.6,112.01 45.6,112.48 45.52,112.56 45.52,115.68 44.94,116.26 44.02,116.26 43.51,116.77 43.51,119.3 PR64.1
  TOP w0.381: v1(45.44,59.6) 44.56,59.6 44.18,59.22 UC3.5
  TOP w0.508: v1(32.11,69.68) 31.86,69.94 CE5.1 31.99,70.48 RE42.1 ; v1(32.12,79.52) 32.49,79.88 RE506.2 ; CE3.2 53.3,69.62 v1(52.55,68.87) ; v1(32.11,81.75) 32.2,81.66 RE31.2 ; RE507.2 32.29,72.13 v1(32.11,71.95)
  IN1 w0.508: v1(45.44,59.6) 44.49,59.6 43.3,60.79 43.3,65.45 42.46,66.29
  BOTTOM w0.508: v1(34.3,84.47) 34.3,83.99 32.11,81.81 v1(32.11,81.75) 32.11,81.59 32.7,81.01 32.7,80.1 32.12,79.53 v1(32.12,79.52) 32.12,79.3 32.77,78.65 32.77,76.57 34.14,75.2 34.5,75.2 35.07,74.63 35.07,73.24 34.44,72.61 32.77,72.61 v1(32.11,71.95) v1(32.11,69.68) 33.89,69.68 v1(34.24,70.03)
  vias: v4(35.78,88.01)
+3VALW_TYPEC: length 37.1
  TOP w0.089: v1(18.3,115.93) 18.72,115.51 v3(19.06,115.51)
  TOP w0.508: v1(18.3,115.93) 18.64,116.28 RT131.2 CT36.1 CT35.1 CT33.1 CT34.1
  IN1 w0.508: v1(20.25,126.69) 20.25,126.28 19.75,125.78 17.94,125.78 17.23,126.49 v1(17.23,126.58) 16.71,126.06 16.71,125.12 17.34,124.48 17.34,120.18 18.3,119.22 v1(18.3,118.8) 18.3,118.14 18.58,117.86 22.61,117.86 v1(23.49,118.74)
  IN2 w0.508: v1(18.3,115.93) 19.38,117.01 21.76,117.01 v1(23.49,118.74)
  BOTTOM w0.203: v1(18.3,118.8) 18.16,118.95 UT9.28 ; UT9.1 18.16,125.95 17.93,126.18 17.62,126.18 v1(17.23,126.58) ; UT9.6 20.16,126.27 20.25,126.36 v1(20.25,126.69) ; 22.49,119.95 21.98,120.46 UT9.20
  BOTTOM w0.508: v1(23.49,118.74) 22.49,119.74 22.49,119.95
+3VALWP: length 60.1
  TOP w0.254: v1(21.12,45.46) 21.12,46.16 22.2,47.24 22.2,49.3 24.14,51.24 24.34,51.24 ; 24.39,51.65 23.81,51.65 21.48,49.32 v1(21.48,48.64) 21.48,47.11 19.43,45.06 PR304.1
  IN3 w0.508: v1(27.32,58.48) 27.32,61.08 29.75,63.51 29.75,66.04 29.5,66.29 29.5,69.84 29.34,70.01 29.34,78.79 27.52,80.61 27.52,84.83 26.01,86.34 26.01,87.89 26.48,88.36 27.47,88.36 29.33,90.23 v1(29.33,92.26)
  BOTTOM w0.254: PU301.14 20.34,45.14 20.66,45.46 v1(21.12,45.46) ; PR307.1 20.61,47.86 PR306.2 20.61,48.38 20.86,48.64 v1(21.48,48.64)
  BOTTOM w0.508: v1(29.33,92.26) 28.88,91.8 PR504.1
  vias: v1(25.55,52.1) v1(25.55,51.52) v1(26.13,53.27) v1(26.13,52.69) v1(26.13,52.1) v1(26.13,51.52) v1(26.72,53.27) v1(26.72,52.69) v1(26.72,52.1) v1(26.72,51.52) v4(24.74,50.48)
+3VGS: length 169.7
  TOP w0.089: v1(49.3,91.44) v4(50.07,91.44)
  TOP w0.356: QV1.5 QV1.2
  TOP w0.381: QV1.5 124.31,122.98 124.04,123.25 RV5.1 ; RV6.1 123.51,119.67 124.31,120.47 QV1.2
  TOP w0.457: PRV14.1 67.64,130.31 67.18,130.77 v1(67.18,130.77)
  TOP w0.508: v1(123.1,118.72) 122.66,119.16 RV6.1 ; v1(127.1,120.18) 127.36,120.43 RV154.1 ; RV164.1 v1(49.3,91.44)
  IN2 w0.508: v1(123.1,118.72) 124.48,118.72 125.94,120.18 v1(127.1,120.18)
  IN3 w0.508: v1(108.3,110.88) 111.09,113.67 111.09,116.95 110.49,117.55 110.49,119.23 108.95,120.77 108.95,123.96 v1(108.78,124.13) ; v1(67.18,130.77) 66.82,130.41 66.82,128.38 66.24,127.8 66.24,126.96 64.46,125.18 64.46,123.69 64.03,123.26 64.03,122.22 62.49,120.68 59.6,120.68 58.2,119.28 58.2,117.77 57.41,116.99 56,116.99 52.64,113.62 52.64,112.38 51.08,110.82 51.08,98.66 51.53,98.2 51.53,93.67 v1(49.3,91.44)
  BOTTOM w0.508: v1(108.3,110.88) 108,111.18 95.8,111.18 93.05,113.92 84.37,113.92 82.15,111.7 80.76,111.7 79.14,113.32 73.8,113.32 72.22,111.74 65.5,111.74 63.61,113.62 61.09,113.62 60.43,114.29 60.43,115.99 58.44,117.98 58.44,122.02 60.74,124.32 61.15,124.32 63.41,126.57 64.37,126.57 65.39,127.59 65.39,128.98 v1(67.18,130.77) ; 108.76,125.38 108.65,125.49 107.88,125.49 107.86,125.48 106.71,126.63 106.71,129.6 108.17,131.06 108.17,132.9 108.77,133.49 LV4.1 108.49,134.18 107.98,134.69 107.98,138.13 108.34,138.49 RV162.1
  vias: v1(108.78,124.77) v1(120.34,116.09) v1(120.99,116.09) v1(128.75,114.57) v1(129.38,114.57) v1(130.02,114.57)
+3VLP: length 159
  TOP w0.508: v1(32.11,76.42) 32.28,76.26 RE12.1 RE44.1
  TOP w0.762: 20.2,42.24 20.38,42.06 30.04,42.06 31.59,40.51 37.69,40.51 38.89,39.3 40.51,39.3 41.09,39.89 47.39,39.89 49.69,37.59 49.69,36.29 52.9,33.08 54.71,33.08 56.26,31.53 58.66,31.53 59.41,30.78 59.41,27.97
  IN2 w0.508: v1(32.11,76.42) 32.11,75.89 29.69,73.47 29.69,57.9 26.4,54.61 24,54.61 23.05,53.65 23.05,51.84 22.1,50.89 22.1,45.57 v1(21.61,45.08)
  BOTTOM w0.762: 60.27,25.94 61.98,24.23 100.56,24.23 101.51,25.18 122.35,25.18 126.21,29.04 129.94,29.04 129.96,29.05
  vias: v1(59.44,27.08) v1(59.83,26.63) v1(129.93,30.07) v1(130.56,30.07) v1(158.58,32.75) v1(159.22,32.75) v4(19.55,42.16)
+3VS: length 275.3
  TOP w0.305: v1(38.29,91.96) R82.1 39.07,92.38 39.81,93.11 R83.1 ; RX7.1 222.78,43.42 221.86,43.42 221.65,43.2 U2.5 221.65,42.38 221.34,42.07 v1(220.29,42.07) ; v1(46.78,92.21) 46.85,92.15 54.02,92.15 55.38,93.51 v1(55.38,111.83)
  TOP w0.432: Q11.5 181.64,67.38 181.38,67.65 R32.1 ; v1(21.34,88.68) 21.91,88.68 22.7,87.89 RL12.1 ; R31.1 181.64,64.46 Q11.2
  TOP w0.457: RC712.2 129.32,47.35 128.62,46.66 127.92,46.66 127.47,47.11 RC621.1
  TOP w0.508: R32.1 181.38,68.42 181.3,68.5 181.3,69.37 RF2.2 181.54,69.47 v1(182.28,68.73) ; v1(31.6,73.67) 31.01,73.08 R36.2 ; PRV17.1 79.87,125.85 80.23,125.48 80.23,123.81 79.73,123.3 ; PRZ15.1 v1(155.48,94.12) ; RC663.1 133.7,46.78 134.18,46.3 134.18,45.49 v1(133.35,44.66) ; v1(183.6,38.96) 183.61,38.95 RS12.1 RS11.1 ; RE2.2 90.05,39.05 89.16,38.16 v1(89.16,36.94) ; RC46.1 125.76,42.75 v1(125.11,42.1) ; RF1.2 45.82,64.09 v1(45.89,64.02) ; RS9.1 RS8.1 RS3.2 180.39,31.17 v1(180.91,30.65) ; CD38.1 75.27,45.19 v1(75.19,45.12) ; v1(123.03,47.3) 123.19,47.46 RC96.1 RC615.1 RC938.1 RC1696.1 RC664.1 RC621.1 ; v1(215.53,49.11) 215.68,48.95 C5.1 RW2.2 ; v1(178.52,61.68) 178.63,61.68 179.18,62.23 C53.1 181,62.47 C54.1 ; v1(35.59,17.2) 36.43,16.37 37.23,16.37 38.35,17.48 QA1.2 38.72,18.41 38.44,18.69 RA2.2 ; R31.1 v1(182.61,64.19) ; v1(132.39,42.25) 132.58,42.44 132.58,42.5 133.51,43.43 133.51,44.5 v1(133.35,44.66) ; RC620.1 v1(145.88,63.56) ; v1(28.71,80.81) 28.69,80.83 RL15.2 ; v1(126.44,44.84) 126.57,44.96 126.57,45.3 126.65,45.39 RC6124.2 RC1697.1 RC1695.1 ; R56.2 211.46,50.27 210.79,49.6 RC5.2 212.7,48.9 212.96,48.64 213.29,48.64 213.52,48.41 v1(213.52,48.41) ; RS5.1 189.8,30.54 189.74,30.6 v1(189.73,30.6) 189.67,30.54 RS7.1 ; RS10.1 RS4.2 186.71,38.22 186.71,38.5 v1(187.04,38.83) ; v1(133.35,44.66) 133.17,44.84 132.5,44.84 131.99,45.36 RC34.1 ; CD67.1 65.57,44.88 65.49,44.79 v1(65.24,44.79) ; RC26.1 123.73,91.53 124.24,92.04 v1(124.54,92.04) ; RC24.1 RC25.1 127.03,91.38 127.03,91.56 126.53,92.07 v1(126.4,92.07) ; RE25.1 44.04,64.35 44.42,63.97 v1(44.42,63.93)
  IN1 w0.254: 72.55,46.16 74.15,46.16 v1(75.19,45.12)
  IN1 w0.305: v1(46.78,92.21) 46.43,92.57 38.9,92.57 v1(38.29,91.96)
  IN1 w0.508: v1(35.59,17.2) 35.59,17.21 35.59,21.51 36.47,22.39 36.47,25.19 35.16,26.5 25.03,26.5 v1(24.6,26.93) ; v1(44.42,63.93) 44.57,64.08 45.83,64.08 v1(45.89,64.02) 46.26,64.02 47.04,64.79 v1(55.25,64.79) ; v1(174.35,64.52) 175.57,64.52 178.41,61.68 v1(178.52,61.68) ; v1(21.34,88.68) 19.91,87.24 19.91,85.91 20.2,85.62 20.2,84.58 20.58,84.2 21.56,84.2 22.2,84.83 26.39,84.83 27.27,83.95 27.27,81.28 27.78,80.77 28.68,80.77 v1(28.71,80.81) ; v1(182.28,68.73) 182.28,64.52 v1(182.61,64.19) ; v1(126.44,44.84) 126.44,44.46 125.11,43.13 v1(125.11,42.1)
  IN2 w0.305: v1(26.95,99.12) 25.23,99.12 23.57,97.46 23.57,95.97 23.36,95.77 23.36,90.23 22.97,89.84 22.06,89.84 21.34,89.12 v1(21.34,88.68)
  IN2 w0.508: 26.72,100.68 25.01,102.38 25.01,104.55 24.51,105.06 23.48,105.06 22.87,105.67 22.87,108.85 23.25,109.23 23.25,113.5 25.43,115.68
  IN3 w0.508: v1(122.08,42.35) 121.95,42.48 121.95,43.92 123.11,45.09 123.11,46.12 123.1,46.13 123.1,47.24 v1(123.03,47.3)
  BOTTOM w0.254: JDIMM1.255 79.15,44.49 75.82,44.49 v1(75.19,45.12) ; JDIMM2.255 66.45,44.49 65.55,44.49 v1(65.24,44.79)
  BOTTOM w0.305: JDIMM2.256 59.99,44.24 60.42,43.81 61.12,43.81 v1(61.38,44.06) ; v1(12.48,108.71) 12.17,109.02 QI3.5
  BOTTOM w0.432: QI3.2 v1(14.54,109.02)
  BOTTOM w0.508: PRW05.1 140.76,112.49 140.25,113 v1(140.06,113) ; v1(215.53,49.11) 214.78,48.36 214.06,48.36 214.01,48.41 v1(213.52,48.41) ; R33.1 v1(174.35,64.52) ; v1(145.88,63.56) 146.3,63.98 146.3,64.82 146.66,65.18 146.66,68.18 146.12,68.72 146.12,74.84 147.41,76.13 147.41,76.28 147.53,76.4 147.53,77.67 148.1,78.24 150.73,78.24 151.21,78.72 151.21,81.23 v1(150.48,81.97) 150.48,82.37 PRZ24.1 ; v1(133.35,44.66) 133.35,45.08 132.08,46.35 RC1707.1 ; RS15.2 187.42,38.45 v1(187.04,38.83) ; RC6123.2 119.13,41.21 119.1,41.18 v1(119.03,41.18) ; v1(31.6,73.67) 31.4,73.86 31.4,75.46 29.36,77.5 29.36,78.94 28.46,79.84 28.46,80.56 v1(28.71,80.81) ; 181.61,64.02 181.45,64.17 180.39,64.17 178.52,62.3 v1(178.52,61.68) 178.52,61.35 R34.1 ; R18.1 v1(81.31,34.88)
  vias: v1(14.22,112.78) v1(14.22,112.2) v1(23.33,28.2) v1(23.33,27.57) v1(23.33,26.93) v1(23.96,28.2) v1(23.96,27.57) v1(23.96,26.93) v1(24.6,28.2) v1(24.6,27.57) v1(25.97,116.85) v1(25.97,116.21) v1(33.92,56.51) v1(33.92,55.88) v1(33.92,55.24) v1(33.92,54.61) v1(33.92,53.97) v1(34.55,56.51) v1(34.55,55.88) v1(34.55,55.24) v1(34.55,54.61) v1(34.55,53.97) v1(55.01,56.47) v1(55.01,55.84) v1(55.01,55.2) v1(55.01,54.57) v1(55.01,53.93) v1(55.38,112.42) v1(55.65,56.47) v1(55.65,55.84) v1(55.65,55.2) v1(55.65,54.57) v1(55.65,53.93) v1(55.96,112.42) v1(55.96,111.83) v1(78.79,38.87) v1(79.42,38.87) v1(89.67,116.89) v1(89.67,116.25) v1(90.31,116.89) v1(90.31,116.25) v1(90.94,116.89) v1(90.94,116.25) v1(109.47,35.24) v1(109.98,34.96) v1(122.54,104.85) v1(122.87,104.34) v1(123.17,104.85) v1(123.16,103.82) v1(123.5,104.34) v1(123.8,103.82) v1(125.38,96.54) v1(125.38,95.91) v1(126.02,96.54) v1(126.02,95.91) v1(126.65,96.54) v1(126.65,95.91) v1(126.84,114.13) v1(127.48,114.13) v1(174.49,39.76) v1(175.1,39.95) v1(179.33,38.03) v1(179.92,38.03) v1(200.81,34.17) v1(201.39,34.17) v1(208.16,32.38) v1(208.19,30.9) v1(214,30.92) v1(214.59,30.92) v1(224.11,33.33) v1(224.11,32.7) v4(33.18,54.8)
+3VS_APU: length 6.2
  TOP w0.508: v1(124.49,63.11) 124.65,62.96 124.65,62.87 124.96,62.55 CC65.1 ; CC1190.1 CC1189.1 122.28,50.91 v1(122.46,50.73) v3(122.46,49.88) 122.46,49.56 RC96.2
  BOTTOM w0.305: UC1.AM17 124.49,63.04 v1(124.49,63.11) 124.42,63.11 UC1.AL18
+3VS_CAM: length 2.8
  TOP w0.127: v3(214.93,49.61) 214.93,47.9 214.28,47.25 RW2.1
  vias: v1(213.55,47.2)
+3VS_SSD: length 4.8
  TOP w0.089: 25.57,29.32 v4(25.57,26.96) ; v4(28.98,28.24) 28.27,28.95 28.06,28.95 ; v4(27.31,27.73) 27.64,28.06 27.64,28.84
  vias: v1(26.02,30.26) v1(26.02,29.62) v1(26.02,28.99) v1(26.65,30.26) v1(26.65,29.62) v1(26.65,28.99) v1(27.29,30.26) v1(27.29,29.62) v1(27.29,28.99)
+3VS_TOUCH: length 145.1
  TOP w0.508: v1(40.61,86.94) R14.2 R13.2
  BOTTOM w0.762: v1(40.61,86.94) 40.61,86.57 39.81,85.77 39.05,85.77 37.09,83.8 37.09,82.36 36.03,81.3 36.03,78.11 38.29,75.85 38.29,72.8 36.85,71.37 36.85,69.96 37.31,69.5 37.31,67.69 36.61,66.99 36.61,65.3 35.53,64.22 35.53,52.6 32.18,49.25 32.18,46.96 37.43,41.7 40.57,41.7 41.78,40.5 41.78,38.21 45.46,34.53 51.17,34.53 52.56,33.14 54.2,33.14 57.27,30.07 57.27,29.43 58.17,28.53 62.61,28.53 65.87,25.27 100.13,25.27 101.27,26.41 109.23,26.41 112.93,30.11 116.86,30.11 116.87,30.12
  vias: v1(118.26,32.51) v1(118.84,32.51) v1(119.43,32.51) v4(114.74,32.86)
+3VS_WLAN_NGFF: length 5.6
  TOP w0.089: v4(74.08,136.08) 73.57,136.08 73.17,136.47 CW15.1 ; v4(74.96,119.12) 74.9,119.06 74.9,118.61 ; v4(71.34,119.82) 71.41,119.76 71.79,119.76
  TOP w0.508: 77.35,118.02 77.9,117.47 79.14,117.47 79.65,117.98 RW8.1
  vias: v1(69.44,137.16) v1(69.44,136.52) v1(70.07,137.16) v1(70.07,136.52) v1(71.7,119.3) v1(72.28,119.3) v1(72.84,118.94)
+5V_AVDD: length 8.6
  TOP w0.203: UA1.26 22.49,15.07 22.26,15.3
  TOP w0.508: 22.26,15.3 22.07,15.49 22.07,16.38 CA6.1 20.94,17.51 CA10.1 v3(20.94,19.43) 19.91,20.46 19.91,20.89
+5V_CONN_P1: length 18.9
  TOP w0.102: v1(37.98,111.32) v3(37.98,111.91)
  TOP w0.508: CT4.1 41.56,121.78 v1(41.56,121.4) ; v1(37.98,111.32) 37.84,111.18 CT3.1 35.67,111.18 35.29,111.56 UT3.3
  IN2 w0.508: v1(37.98,111.32) 37.98,116.29 38.21,116.52 38.21,117.49 41.56,120.83 v1(41.56,121.4)
  BOTTOM w0.254: UT1.8 41.11,122.05 41.56,121.6 v1(41.56,121.4)
+5V_HDD: length 0.7
  TOP w0.102: v4(196.38,37.59) 196,37.59 195.74,37.84
  vias: v1(183.9,36.65) v1(184.52,36.6) v1(192.58,37.96) v1(193.23,37.96) v4(193.46,38.86) v4(194.73,37.78)
+5V_HDMI: length 0.6
  TOP w0.102: v1(12.35,113) v4(12.94,113)
  vias: v1(12.35,113.58) v1(14.7,102.23) v1(14.7,101.6) v1(14.7,100.96)
+5V_PVDD: length 1.8
  TOP w0.203: v1(26.26,8.63) 26.77,9.14 26.77,9.71 26.68,9.8 UA1.41
  vias: v1(25.82,8.12) v1(32.61,8.35) v1(33.19,8.35) v4(34.6,7.02)
+5V_USB_PWR1: length 0.6
  TOP w0.508: CU14.1 v1(16.4,41.91)
  vias: v1(17.5,49.02) v1(17.65,55.14) v1(17.71,54.4) v1(18.09,55.58) v1(18.13,49.02) v1(18.16,54.85) v4(17.69,48.13)
+5V_USB_PWR2:
  vias: v1(196.88,35.75) v1(197.46,35.94) v1(198.08,35.77) v4(196.82,34.92)
+5VALW: length 113.2
  TOP w0.178: PUV01.26 77.4,129.84 77.67,129.57 78.09,129.57 78.48,129.96 78.48,130.13 78.71,130.36 78.71,130.42
  TOP w0.203: v1(35.54,50.73) 35.71,50.73 35.96,50.48 U6.4 ; PUV01.31 75.98,133.04 v1(76.17,133.24)
  TOP w0.508: v1(81.64,112.93) 82.12,112.45 PRF04.1 ; v1(83.54,129.73) 83.54,130.86 82.6,131.8 81.12,131.8 80.74,131.42 PCV12.1 79.66,131 PRV13.1 79.35,131.06 78.71,130.42 ; v1(67.87,115.74) 68.12,116 69.05,116 69.33,115.73 70.5,115.73 71.11,116.34 PR2504.1 ; RE18.2 42.26,86.42 41.73,86.95 v1(41.73,87) ; v1(143.75,41.59) 143.88,41.46 R28.1 ; 200.85,37.03 200.82,37 193.46,37 193.43,37.03 CS40.1 192.15,37.03 191.78,37.39 US5.5
  IN1 w0.508: v1(76.17,133.24) 76.91,132.49 78.86,132.49 79.54,131.82 82.65,131.82 83.54,130.93 v1(83.54,129.73)
  IN2 w0.508: v1(166.78,38.11) 166.78,37.26 167.29,36.75 170.52,36.75 171.17,36.1 171.17,35.04 171.48,34.73 172.25,34.73 175.87,38.35 ; v1(159.53,34.55) 153.1,34.55 150.55,37.11 148.14,37.11 143.75,41.5 v1(143.75,41.59)
  IN3 w0.508: v1(76.17,133.24) 75.44,132.5 72.12,132.5 71.3,131.69 71.3,126.21 70.79,125.7 69.43,125.7 68.86,126.27 66.4,126.27 65.06,124.93 65.06,123.31 65.26,123.11 65.26,121.98 64.75,121.47 64.13,121.47 63.46,120.8 63.46,119.92 ; v1(36.84,88.4) 37.32,88.4 37.7,88.02 39.44,88.02 39.79,88.36 40.99,88.36 41.73,87.62 v1(41.73,87)
  BOTTOM w0.508: v1(169.73,43.71) 168.88,43.71 168.29,44.3 PRH11.2 ; v1(159.53,34.55) 160.78,34.55 161.76,33.57 163.7,33.57 166.78,36.65 v1(166.78,38.11)
  vias: v1(16.93,50.49) v1(17.51,51.71) v1(17.51,51.13) v1(17.51,50.49) v1(26.46,112.21) v1(26.46,111.57) v1(26.46,110.94) v1(26.49,110.32) v1(27.04,112.21) v1(27.04,111.57) v1(27.04,110.94) v1(27.68,112.21) v1(27.68,111.57) v1(27.68,110.94) v1(28.31,112.21) v1(28.31,111.57) v1(28.31,110.94) v1(28.32,110.3) v1(28.95,112.21) v1(28.95,111.57) v1(28.95,110.94) v1(28.96,110.3) v1(31.2,129.64) v1(31.2,129.05) v1(31.78,129.64) v1(31.78,129.05) v1(32.37,129.64) v1(32.37,129.05) v1(34.07,24.6) v1(34.65,24.6) v1(35.24,24.6) v1(35.82,24.6) v1(36.54,99.37) v1(36.54,98.73) v1(36.54,98.1) v1(37.17,99.37) v1(37.17,98.73) v1(37.17,98.1) v1(37.81,99.37) v1(37.81,98.73) v1(37.81,98.1) v1(38.44,99.37) v1(38.44,98.73) v1(39.05,97.32) v1(39.05,96.73) v1(39.09,99.37) v1(42.21,30.74) v1(42.21,30.16) v1(42.79,30.16) v1(43.39,30.16) v1(45.6,94.42) v1(45.8,95.03) v1(52.51,97.44) v1(52.51,96.81) v1(52.51,96.17) v1(52.51,95.54) v1(61.13,119.53) v1(61.45,120.1) v1(61.72,119.53) v1(62.04,120.1) v1(65.25,115.96) v1(65.5,115.39) v1(65.83,115.96) v1(66.09,115.39) v1(91.49,110.7) v1(92.12,110.7) v1(92.76,110.7) v1(93.39,110.7) v1(124.58,113.87) v1(132.28,113.48) v1(132.28,112.9) v1(132.86,113.48) v1(132.86,112.9) v1(173.72,44.74) v1(173.72,44.1) v1(174.35,44.74) v1(174.35,44.1) v1(200.77,38.37) v1(200.77,37.79) v1(201.35,38.37) v1(201.35,37.79) v4(27.66,110.29) v4(53.31,98.93) v4(96.74,110.68)
+5VALWP: length 34.3
  IN2 w0.254: v1(24.16,94.74) 24.23,94.74 24.84,94.13 26.07,94.13 26.55,94.61 26.55,95.96 28.33,97.74 28.33,105.29 28.54,105.51 28.54,107.34 v1(28.74,107.53) ; v1(25.03,94.7) 25.89,94.7 26.15,94.95 26.15,96.1 27.95,97.9 27.95,105.45 28.14,105.64 28.14,106.36 28.1,106.4 v1(28.1,107.53)
  BOTTOM w0.254: PU501.14 25.11,94.78 v1(25.03,94.7) ; PR509.2 24.86,93.84 ; 24.86,93.84 PR510.1 ; 24.86,93.84 24.86,94.1 24.23,94.74 v1(24.16,94.74)
  vias: v1(23.71,108.14) v1(23.71,107.55) v1(24.32,108.16) v1(24.32,107.53) v1(24.93,108.14) v1(24.95,107.53) v1(25.55,108.14) v1(25.59,107.53) v1(26.19,108.11) v1(26.22,107.51) v1(26.82,108.11) v1(26.83,107.53) v1(27.46,108.11) v1(27.47,107.53) v1(28.09,108.11) v1(28.73,108.11) v4(22.77,108.14)
+5VS: length 82.6
  TOP w0.127: RS60.2 188.25,37.8 188.64,38.2 188.64,40.34 188.88,40.58
  TOP w0.203: PRZ17.2 154.78,82.53 154.78,84.21 154.77,84.22 PUZ01.26
  TOP w0.508: v1(157.32,80.62) 155.81,80.62 PCZ23.1 155.23,81.08 PRZ17.2 ; RA52.1 v1(19.91,23.17)
  IN1 w0.508: v1(19.91,23.17) 20.09,23.35 25.26,23.35 26.53,22.08 31.77,22.08 32.42,21.43 32.42,16.75 32.98,16.19 32.98,9.44 34.5,7.92 v1(38.69,7.92)
  IN3 w0.508: v1(166.38,85.2) 166.38,82.36 171.28,77.46 171.28,74.68 175.95,70.02 177.05,70.02 178.72,68.35 v1(178.72,68.18)
  BOTTOM w0.508: v1(59.97,33.15) 59.82,33.3 57.43,33.3 56.57,34.16 RE4.1 ; v1(157.32,80.62) 157.32,81.83 158.17,82.69 161.13,82.69 163.65,85.2 v1(166.38,85.2)
  vias: v1(16.35,105.89) v1(16.58,105.32) v1(16.58,104.74) v1(38.69,7.29) v1(38.96,105.85) v1(38.96,105.21) v1(38.96,104.58) v1(38.96,103.94) v1(38.96,103.31) v1(38.96,102.67) v1(39.59,105.85) v1(39.59,105.21) v1(39.59,104.58) v1(39.59,103.94) v1(39.59,103.31) v1(39.59,102.67) v1(47.39,30.45) v1(48.1,30.41) v1(51.46,38.99) v1(52.05,38.99) v1(52.63,38.99) v1(53.21,38.99) v1(53.8,38.99) v1(90.97,29.38) v1(91.55,29.38) v1(179.36,68.11) v1(190.48,42.36) v1(191.12,42.36) v1(191.68,66.11) v1(191.68,65.47) v1(191.75,42.36) v1(192.31,66.11) v1(192.31,65.47) v1(192.53,60.92) v1(192.53,60.33) v1(192.95,66.11) v1(192.95,65.47) v1(193.11,60.92) v1(193.11,60.33) v1(193.7,60.92) v1(193.7,60.33) v1(213.69,40.81) v1(213.69,40.23) v1(213.69,39.64) v1(214.27,40.81) v1(214.27,40.23) v1(214.27,39.64) v1(216.75,29.97) v1(216.75,29.33) v1(224.05,34.67) v1(224.05,34.03) v4(41.56,105.53)
+5VS_KBL:
  vias: v1(95.64,34.98) v1(96.22,34.98) v4(96.11,33.97)
+5VS_ODD: length 2
  TOP w0.102: CS26.1 194.12,61.57 v4(194.92,60.76)
  vias: v1(194.85,66.02) v1(194.85,65.38) v1(195.49,66.02) v1(195.49,65.38)
+17.4V_BATT+: length 72.5
  IN1 w0.381: v1(153.13,42.16) 153.13,41.95 154.39,40.69 155.8,40.69 156.52,39.98 165.83,39.98 166.09,40.23 173.7,40.23 174.42,40.95 179.09,40.95 179.2,41.07 181.06,41.07 182.21,39.92 191.63,39.92 193.01,41.3 202.55,41.3 202.73,41.48 208.74,41.48 208.99,41.74 v1(208.99,41.99)
  BOTTOM w0.381: v1(153.13,42.16) 153.07,42.16 152.91,42 148.52,42 v3(147.13,40.61) 146.81,40.29 146.81,35.24
  BOTTOM w0.508: v1(208.99,41.99) 208.99,42.38 208.96,42.41 PRB39.1
+17.4V_BATT++: length 4.5
  TOP w0.089: v1(157.86,38.46) 157.9,38.46 158.43,37.93 v4(158.43,37.66) v4(158.43,35.94) v4(158.43,34.26)
+19V_ADPIN:
  vias: v1(83.42,141.69) v1(83.42,141.11) v1(84.03,141.74) v1(84.03,141.16) v1(84.64,141.74) v1(84.64,141.16) v1(85.25,141.74) v1(85.25,141.16) v1(85.86,141.74) v1(85.86,141.16) v4(85,140.56) v4(87.47,141.88) v4(89.53,141.87)
+19VB: length 377.8
  TOP w0.102: v1(31.31,102.79) v4(31.31,103.48)
  TOP w0.508: v1(169.88,51.16) 169.88,51.54 PRH16.1
  TOP w2.032: 53.3,24.53 100.53,24.53 101.43,25.43 134.2,25.43 136.28,27.51 136.28,29.3 139.37,32.38 143.74,32.38 147,29.13 147,27.52 149.03,25.48 176.6,25.48
  IN1 w1.016: 137.03,112.69 137.99,112.69 138.86,111.82 141.89,111.82 143.76,113.69 152.01,113.69 152.15,113.82 153.58,113.82 155.24,112.16 159.68,112.16 160.72,113.2 165.17,113.2
  IN1 w1.27: 183.24,45.07 180.41,47.9 176.37,47.9 175.52,47.05 172.5,47.05 169.77,49.78
  IN1 w2.032: 133.82,152.69 165.03,152.69 167.19,150.53 167.19,140.83 167.64,133.71 167.64,117.07
  IN2 w2.032: 176.53,25.43 146.96,25.43 145.33,27.06 145.33,28.67 143.12,30.88 140.89,30.88 139.43,30.36 134.5,25.43 101.43,25.43 100.48,24.48 53.18,24.48
  BOTTOM w0.508: PRB21.2 204.31,39.73 v1(204.28,39.7) ; PR302.2 v1(17.29,47.01)
  vias: v1(16.07,37.68) v1(16.07,37.09) v1(16.07,36.51) v1(16.07,35.92) v1(16.66,37.68) v1(16.66,37.09) v1(16.66,36.51) v1(16.66,35.92) v1(30.04,102.79) v1(30.04,102.15) v1(30.04,101.52) v1(30.68,102.79) v1(30.68,102.15) v1(30.68,101.52) v1(31.31,102.15) v1(31.31,101.52) v1(31.31,100.88) v1(47.98,24.76) v1(50.4,24.81) v1(51.03,25.39) v1(51.03,24.81) v1(51.67,24.81) v1(90.29,141.55) v1(90.29,140.94) v1(90.29,140.33) v1(90.29,139.72) v1(90.9,141.55) v1(90.9,140.94) v1(90.9,140.33) v1(90.9,139.72) v1(134.44,112.81) v1(134.82,113.38) v1(135.08,112.81) v1(167.05,96.31) v1(167.05,95.68) v1(167.05,95.04) v1(169.01,116.18) v1(169.01,115.55) v1(169.01,114.91) v1(169.25,51.16) v1(169.33,116.71) v1(169.65,116.18) v1(169.65,115.55) v1(169.65,114.91) v1(170.52,51.16) v1(173.33,78.04) v1(173.33,77.4) v1(173.33,76.77) v1(174.02,78.04) v1(174.02,77.4) v1(174.02,76.77) v1(177.97,26.61) v1(177.97,25.98) v1(177.97,25.34) v1(178.61,26.61) v1(178.61,25.98) v1(178.61,25.34) v1(179.24,26.61) v1(179.24,25.98) v1(179.24,25.34) v1(179.88,26.61) v1(179.88,25.98) v1(179.88,25.34) v1(184.44,44.84) v1(184.44,44.2) v1(184.44,43.57) v1(184.44,42.93) v1(184.44,42.3) v1(185.07,44.84) v1(185.07,44.2) v1(185.07,43.57) v1(185.07,42.93) v1(185.07,42.3) v1(190.48,41.65) v1(191.13,41.65) v1(191.75,41.65) v1(200.07,66.24) v1(200.07,65.65) v1(200.07,65.07) v1(200.66,66.82) v1(200.66,66.24) v1(200.66,65.65) v1(200.66,65.07) v1(205.43,53.77) v1(205.55,54.35) v1(206.24,53.88) v1(206.88,53.88) v1(207.51,53.88) v1(207.63,55.11) v1(207.63,54.48) v1(208.24,55.11) v1(208.24,54.48)
+19VB_1.2V: length 12.1
  TOP w0.508: PRM07.1 31.88,27.46 v1(31.59,27.74)
  IN2 w0.254: v1(31.59,27.74) 31.97,27.36 v1(42.26,27.36)
  vias: v1(42.26,26.73) v1(42.9,27.36) v1(42.9,26.73) v3(46.33,27.55)
+19VB_+1.35VGPU: length 1.5
  TOP w0.089: PCW03.1 v3(141.25,109.41)
  vias: v1(139.16,108.61) v1(139.75,108.61)
+19VB_+VDDP:
  vias: v1(163.79,49.64) v1(163.79,49) v1(163.79,48.37) v4(164.5,49.02)
+19VB_APU:
  vias: v1(154.97,74.35) v1(154.97,73.46) v1(156.24,77.47) v1(156.26,76.61) v1(157.32,76.64) v1(158.2,76.61) v1(164.22,72.07) v1(164.83,72.07) v1(165.44,72.07) v1(165.44,71.46) v1(165.44,70.85) v1(165.67,77.34) v1(166.28,77.34) v1(166.89,77.34) v1(167.19,73.24) v1(167.19,72.58) v1(167.19,71.97) v1(167.5,77.34) v4(163.29,75.69)
+19VB_NB:
  vias: v1(163.83,97.28) v1(164.46,97.28) v4(166.09,97.91)
+19VB_VGA:
  vias: v1(81.48,125.59) v1(82.1,135.61) v1(82.07,125.59) v1(82.71,135.61) v1(82.65,125.59) v1(83.05,124.04) v1(83.24,125.59) v1(83.32,135.61) v1(83.66,124.04) v1(83.82,125.59) v1(83.93,135.61) v1(84.21,123.73) v1(84.54,135.61) v1(84.57,124.65) v1(84.72,124.04) v1(85.34,138.29) v1(85.95,138.29) v1(86.56,138.29) v1(87.17,138.29) v1(87.78,138.29) v4(82.71,121.41)
+V18R: length 4.4
  TOP w0.089: UE1.124 34.16,71.01 RE42.2 RE40.2 33.64,69.48 34.2,68.92 34.39,68.92 v3(34.49,68.82)
+VBUS_DC_SS: length 207
  IN2 w0.508: v1(59.71,133.57) 60.17,133.12 60.17,132.45 58.82,131.1 58.82,120.87 61.1,118.59 67.98,118.59 69.16,117.4 70.59,117.4 70.77,117.23 72.15,117.23 72.46,117.54 73.84,117.54 74.11,117.81 76.84,117.81 77.87,118.84 86.99,118.84 88.16,117.67 91.4,117.67 91.86,117.21 100.03,117.21 101.51,115.73 107.2,115.73 108.67,114.25 108.67,112.52 112.21,108.99 114.83,108.99 115.62,109.78 118.4,109.78 119.47,108.7 123.45,108.7 124.28,109.52 132.48,109.52 132.7,109.74 134.21,109.74 137.41,106.55 139.65,106.55 139.92,106.28 143.41,106.28 143.56,106.28 144.19,106.28 144.19,106.28 145.44,105.03 156.59,105.03 157.23,105.67 164.19,105.67 168.5,101.36 168.5,97.72 169.53,96.69 169.53,87.59 169.74,87.38 169.97,87.15 170.02,87.1 170.02,72.38 171.05,71.35 171.05,70.72 171.05,70.13 178.89,62.3 185.86,62.3 189.84,58.33 202.59,58.33 203.01,57.91 203.64,57.91 204.66,56.89
  vias: v1(205.28,56.89) v1(205.28,56.3) v4(59.41,135.63)
+VCC_TPM: length 7.2
  BOTTOM w0.254: UX1.22 105.7,35.3 105.83,35.17 106.48,35.17 106.92,34.73 v1(106.92,34.7) ; UX1.14 103.53,39.69 v1(103.42,39.8) ; UX1.8 v1(99.39,37.8)
  BOTTOM w0.356: RX28.1 v1(99.31,36.48)
  BOTTOM w0.508: v1(99.48,40.76) 99.48,40.7 99.72,40.46 RX38.1 ; v1(101.63,32.37) 101.63,32.29 101.7,32.22 RX39.1 CX13.1
  vias: v1(107.56,34.35) v1(108.15,34.35) v4(99.73,34.35)
+VDD_CT: length 8.3
  TOP w0.508: LV3.2 110.25,136.82 CV61.1 111.26,137.05 v3(112.09,137.05) 112.44,136.7 v1(112.68,136.7) ; CV63.1 119.04,137.02 v1(118.56,137.02) ; CV62.1 120.26,136.68 v1(119.86,136.28)
  BOTTOM w0.381: v1(119.86,136.28) UV1.AB21 119.12,137.02 v1(118.56,137.02) ; v1(119.86,136.28) 119.38,135.8 UV1.AB20 ; v1(119.86,136.28) UV1.AA20 ; v1(119.86,136.28) 120.14,136.57 120.34,136.76 UV1.AA21
+VDD_TOUCH: length 3.6
  TOP w0.457: U5.1 211.81,35.4 210.68,36.53 210.63,36.53
  TOP w0.508: R300.2 208.76,35.11 208.76,36.36
  vias: v1(210.83,38.98) v1(210.83,38.4) v4(207.62,40.44)
