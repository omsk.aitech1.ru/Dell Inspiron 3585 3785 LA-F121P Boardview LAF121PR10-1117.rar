# Allegro board LAF121PR10-1117.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 27.32,85 27.32,83.26 27.21,83.15 26.36,83.15 26.29,83.22 26.29,84.25 26.11,84.43 24.96,84.43 24.79,84.26 24.79,82.34 24.96,82.17 25.76,82.17 25.86,82.08 25.86,80.6 25.77,80.51 25.72,80.55 25.72,80.56 25.46,80.79 25.12,80.68 24.88,80.44 24.35,80.44 24.29,80.39 24.29,79.69 24.16,79.56 23.98,79.56 23.85,79.63 23.7,79.64 23.62,79.66 23.58,79.74 23.58,81.19 23.44,81.34 22.51,81.34 22.07,81.78 21.24,81.78 21.12,81.91 21.12,82.76 21.12,83.66 21.32,83.87 21.8,83.87 22.02,84.08 22.04,84.08 22.04,84.11 22.25,84.31 23.34,84.31 23.54,84.5 23.54,84.98 23.63,85.07 27.25,85.07
GND on BOTTOM (solid shape): 97.5,152.5 100.5,152.5 100.5,154.4 103,154.4 103,154 99,150 95,154 95,154.4 97.5,154.4
GND on BOTTOM (solid shape): 212.95,54.52 212.99,54.48 213.03,54.43 213.12,54.34 213.18,54.34 213.28,54.33 213.38,54.34 213.39,54.34 213.49,54.34 213.81,54.66 214.07,54.66 214.23,54.49 214.23,50.42 214.17,50.38 214.13,50.36 214.07,50.33 214,50.36 213.72,50.44 213.47,50.27 213.37,50.27 212.87,50.77 211.88,50.77 211.78,50.87 211.78,51.04 211.88,51.14 213.01,51.14 213.15,51.28 213.15,52.17 213.04,52.28 211.86,52.28 211.78,52.36 211.78,52.56 211.86,52.64 213.18,52.64 213.24,52.7 213.24,53.81 213.04,54.01 213.04,54.03 212.97,54.15 212.84,54.22 212.83,54.22 212.79,54.26 211.95,54.26 211.81,54.4 211.81,54.53 211.94,54.66 212.92,54.66
GND on BOTTOM (solid shape): 17.18,45.4 17.18,43.62 17.64,43.16 18.88,43.16 19.29,43.57 20.56,43.57 20.94,43.19 21.8,43.19 21.93,43.31 22.06,43.44 22.06,43.75 22.18,43.87 22.44,43.87 22.51,43.8 22.51,43.52 21.88,42.88 20.84,42.88 20.46,42.5 19.69,42.5 19.67,42.53 18.78,42.53 18.7,42.45 17.69,42.45 16.82,41.59 16.71,41.59 16.67,41.62 16.67,41.67 16.44,42.26 16.09,41.74 16.09,41.64 16,41.59 15.58,41.59 15.4,41.41 14.94,41.41 14.61,41.74 14.61,42.63 14.39,42.86 13.67,42.86 13.42,42.6 13.42,38.77 13.32,38.67 12.25,38.67 12.15,38.77 12.15,43.14 13.01,44 14.77,44 15.4,44.64 15.4,45.46 15.78,45.84 16.73,45.84
GND on BOTTOM (solid shape): 200.53,52.3 200.53,50.94 200.28,50.69 199.65,50.69 199.46,50.5 199.45,50.5 199.14,50.2 199.33,49.82 199.33,48.7 199.07,48.43 198.88,48.43 198.88,48.25 198.24,47.6 198.23,47.6 198.08,47.3 198.24,47 198.24,46.29 198.13,46.04 198.3,45.81 198.69,45.42 198.69,45.42 198.85,45.25 198.85,43.92 198.05,43.12 198.05,42.45 197.85,42.25 197.52,42.25 193.76,46.01 184.95,46.01 184.03,46.92 181.31,46.92 180.73,47.51 180.02,47.51 179.76,47.25 179.76,42.98 179.55,42.77 179.16,42.77 179.04,42.89 179.04,45.88 178.66,46.26 177.15,46.26 176.51,46.9 176.51,47.28 176.77,47.53 177.68,47.53 178.19,48.04 179.76,48.04 180.12,48.4 180.12,48.95 180.58,49.41 182.56,49.41 183.88,50.73 189.29,50.73 191.83,48.19 192.26,48.19 193.07,47.38 194.76,47.38 194.92,47.53 194.92,48.05 195.17,48.3 198.03,48.3 198.21,48.48 198.29,48.48 198.29,51.41 198.26,51.41 198.26,51.49 199.13,52.37 200.47,52.37
GND on BOTTOM (solid shape): outline of 115 points within 38.75,31.86 42.5,36.64
GND on BOTTOM (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,44.94 14.36,44.15 12.66,44.15 11.85,43.34 11.85,37.98 12.12,37.7 14.54,37.7 14.87,37.37 14.87,36.02 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.83 13.74,34.84 14.19,35.62 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.19,46.78 13.74,47.56 13.7,47.57 13.7,48.12 14.16,48.12
GND on BOTTOM (solid shape): outline of 132 points within 39.51,22.74 47.28,29.79
GND on BOTTOM (solid shape): 145.58,65.49 145.58,63.74 145.52,63.56 145.58,63.38 145.58,62.87 145.57,62.86 145.55,62.73 145.57,62.61 145.58,62.6 145.58,61.96 145.57,61.95 145.72,61.52 146.17,61.59 147.6,61.59 147.61,61.56 147.72,61.42 147.88,61.35 147.91,61.34 147.92,61.3 147.94,61.21 147.99,61.14 148.22,60.91 148.22,57.53 148.13,57.44 147.91,57.44 147.71,57.63 147.71,60.1 147.02,60.78 147.02,60.8 146.51,61.04 146.4,60.49 146.42,60.43 146.31,60.13 146.42,59.84 146.4,59.78 146.32,59.58 146.36,59.38 146.36,59.3 146.1,59.03 146.12,58.74 146.12,58.73 146.12,58.71 146.17,58.66 146.17,57.46 145.73,57.02 145,57.02 144.87,57.16 144.87,59.2 144.84,59.22 144.84,60.96 144.43,61.37 144.43,65.44 144.62,65.63 145.44,65.63
GND on BOTTOM (solid shape): 10.71,90.66 11.01,90.36 13.32,90.36 13.78,89.9 13.78,89.24 12.05,87.51 12.05,81.94 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.2,79.2 12.2,80.85 12,81.35 11.5,81.55 7.6,81.55 7.6,82.05 7.4,82.55 6.9,82.75 6.1,82.75 5.6,82.55 5.4,82.05 5.4,81.55 0.6,81.55 0.39,81.64 0.3,81.85 0.3,83.35 0.39,83.56 0.6,83.65 2,83.65 2.5,83.85 2.7,84.35 2.7,88.6 2.79,88.81 3,88.9 10.05,88.9 10.74,89.48 10.29,90.26 10.25,90.27 10.25,91.41 10.71,91.41
GND on BOTTOM (solid shape): outline of 156 points within 80.17,122.15 93.53,139.39
GND on BOTTOM (solid shape): outline of 266 points within 0.2,102.63 13.78,126.93
GND on BOTTOM (solid shape): outline of 276 points within 156.14,62.41 163.81,76.96
GND on BOTTOM (solid shape): outline of 292 points within 0.2,0.2 228.2,155.3
GND on BOTTOM (solid shape): outline of 1546 points within 203.45,41.05 228.2,69.2
GND on BOTTOM (solid shape): outline of 14719 points within 47.86,38.66 93.56,112.75
GND on IN1 (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 15.1,22.51 15.1,21.17 14.56,20.63 5.52,20.63 5.16,20.28 5.16,19.85 4.7,19.85 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.19,22.88 13.74,23.66 13.7,23.67 13.7,24.54 14.16,24.54
GND on IN1 (solid shape): 84.87,133.74 84.87,132.6 84.79,132.52 84.51,132.52 84.4,132.4 84.39,132.4 84.22,132.18 84.26,131.9 84.26,131.69 84.21,131.51 84.25,131.33 84.26,131.32 84.26,131.3 84.45,131.11 84.74,131.11 84.92,131.29 84.92,132.01 85.06,132.15 88.11,132.15 88.32,131.94 88.32,131.36 88.69,131 92.82,131 92.96,131.14 92.96,131.78 93.43,132.25 95.44,132.25 95.73,131.96 95.73,128.42 94.92,127.61 93.34,127.61 93.25,127.69 93.25,128.65 93.09,128.81 90.13,128.81 90.12,128.8 89.4,128.8 89.28,128.67 89.28,127.76 89.19,127.67 86.15,127.67 86,127.82 86,128.53 85.57,128.96 84.22,128.96 84.11,128.85 84.11,127.69 84.32,127.48 84.69,127.48 84.79,127.38 84.79,126.16 84.64,126 81.03,126 80.77,126.27 80.77,127.15 82.86,129.24 83.75,129.24 83.9,129.4 83.9,131.05 83.89,131.06 83.89,131.08 82.8,132.18 82.77,132.18 82.43,132.52 80.51,132.52 80.44,132.6 80.44,133.26 80.44,133.27 80.48,133.42 80.44,133.57 80.44,133.58 80.44,133.73 80.56,133.85 84.76,133.85
GND on IN1 (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,44.94 14.36,44.15 12.66,44.15 11.85,43.34 11.85,37.98 12.12,37.7 14.54,37.7 14.87,37.37 14.87,36.02 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.83 13.74,34.84 14.19,35.62 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.19,46.78 13.74,47.56 13.7,47.57 13.7,48.12 14.16,48.12
GND on IN1 (solid shape): 12.53,64.09 15.1,61.53 15.1,60.34 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 11.5,66.75 11.6,66.75 11.7,66.77 12.53,66.77
GND on IN1 (solid shape): outline of 229 points within 11.57,87.89 31.21,101.47
GND on IN1 (solid shape): outline of 315 points within 213.17,23.65 225.2,41.23
GND on IN1 (solid shape): outline of 344 points within 0.2,102.63 14.05,133.9
GND on IN1 (solid shape): outline of 461 points within 198.1,48.99 228.2,69.2
GND on IN1 (solid shape): outline of 562 points within 172.98,67.09 198.97,86.47
GND on IN1 (solid shape): outline of 1083 points within 154.1,61.02 162.45,77.91
GND on IN1 (solid shape): outline of 1238 points within 181.51,40.8 208.57,56.65
GND on IN1 (solid shape): outline of 284 points within 0.2,0.2 228.2,155.3
GND on IN2 (solid shape): 125.95,57.45 126,57.37 126,56.72 125.52,56.24 125.52,55.46 125.44,55.38 125.38,55.37 125.35,55.42 125.35,57.22 125.56,57.43 125.59,57.43 125.72,57.42 125.85,57.46
GND on IN2 (solid shape): 124.48,55.94 124.54,55.93 124.58,55.91 124.58,55.16 123.44,54.01 123.44,53.06 123.4,52.97 123.31,52.96 123.17,52.97 123.04,52.93 122.94,52.94 122.89,53.02 122.89,53.68 123.57,54.37 123.57,55.08 124.38,55.88 124.41,55.91
GND on IN2 (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 15.1,22.51 15.1,21.17 14.56,20.63 5.52,20.63 5.16,20.28 5.16,19.85 4.7,19.85 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.19,22.88 13.74,23.66 13.7,23.67 13.7,24.54 14.16,24.54
GND on IN2 (solid shape): 126.55,56.61 126.58,56.66 126.63,56.65 126.75,56.6 126.89,56.6 126.91,56.61 127.01,56.51 127.01,55.99 127.14,55.86 127.14,55.02 127.69,54.46 127.69,53.86 127.07,53.23 127.05,53.23 126.82,53.13 126.72,52.9 126.72,52.88 126.68,52.84 125.24,52.84 125.18,52.87 125.14,52.93 124.92,53.24 124.55,53.17 124.44,53.15 124.38,53.24 124.38,53.63 126,55.26 126,56.04 126.55,56.58
GND on IN2 (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,44.94 14.36,44.15 12.66,44.15 11.85,43.34 11.85,37.98 12.12,37.7 14.54,37.7 14.87,37.37 14.87,36.02 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.83 13.74,34.84 14.19,35.62 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.19,46.78 13.74,47.56 13.7,47.57 13.7,48.12 14.16,48.12
GND on IN2 (solid shape): 12.53,64.09 15.1,61.53 15.1,60.34 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 11.5,66.75 11.6,66.75 11.7,66.77 12.53,66.77
GND on IN2 (solid shape): 127.37,60.89 127.38,60.88 127.46,60.67 127.65,60.56 127.69,60.55 127.69,60.46 127.65,60.45 127.38,60.11 127.65,59.76 127.69,59.75 127.69,58.86 127.65,58.85 127.38,58.51 127.65,58.16 127.69,58.15 127.69,57.36 127.62,57.35 127.53,57.36 127.49,57.44 127.49,57.91 127.05,58.35 127.06,58.38 126.95,58.75 126.56,58.8 126.55,58.79 126.49,58.79 126.49,58.93 126.6,59.04 126.64,59.01 127.21,59.34 126.57,59.51 126.56,59.49 126.48,59.49 126.48,59.62 126.08,60.03 126.08,60.05 126.09,60.25 125.99,60.41 125.96,60.5 126,60.57 126.15,60.79 126.11,61.05 126.11,61.16 126.2,61.21 127.06,61.21
GND on IN2 (solid shape): 94.74,132.01 94.74,128.09 94.22,127.57 90.1,127.57 90.02,127.61 90,127.69 90.01,127.86 89.93,128.01 89.91,128.07 89.93,128.14 89.66,128.72 89.38,128.14 89.41,128.07 89.38,128.01 89.31,127.86 89.31,127.69 89.29,127.61 89.21,127.57 84.78,127.57 84.73,127.58 84.7,127.62 84.71,127.67 84.83,127.91 84.75,128.16 84.73,128.23 84.75,128.29 84.8,128.68 84.46,128.88 84.39,128.9 84.36,128.98 84.36,131.06 84.39,131.14 84.48,131.16 84.87,131.32 84.84,131.73 84.82,131.8 84.84,131.86 84.9,131.97 84.92,132.1 84.95,132.18 85.02,132.21 89.27,132.21 89.35,132.17 89.37,132.09 89.38,131.94 89.45,131.8 89.47,131.73 89.45,131.67 89.72,131.08 90,131.67 89.97,131.73 90,131.8 90.07,131.94 90.07,132.09 90.09,132.17 90.17,132.21 91.28,132.21 91.28,132.22 94.53,132.22
GND on IN2 (solid shape): outline of 344 points within 0.2,102.63 13.75,133.9
GND on IN2 (solid shape): outline of 971 points within 154.1,61.02 162.45,77.03
GND on IN2 (solid shape): outline of 286 points within 0.2,0.2 228.2,155.3
GND on IN2 (solid shape): outline of 2821 points within 170.79,23.65 228.2,89.51
GND on IN2 (solid shape): outline of 6622 points within 58.36,79.75 123.73,110.4
GND on IN2 (solid shape): outline of 7939 points within 57.57,39.65 126.19,64.96
GND on IN2 (solid shape): outline of 14059 points within 107.16,116.84 170.62,155.3
GND on IN3 (solid shape): 94.73,132.01 94.73,128.09 94.22,127.58 91.63,127.58 90.32,128.89 89.75,128.89 89.75,128.89 84.36,128.89 84.36,131.06 89.95,131.06 90.12,131.06 91.27,132.22 94.52,132.22
GND on IN3 (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 15.1,22.51 15.1,21.17 14.56,20.63 5.52,20.63 5.16,20.28 5.16,19.85 4.7,19.85 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.19,22.88 13.74,23.66 13.7,23.67 13.7,24.54 14.16,24.54
GND on IN3 (solid shape): 225.16,34.85 225.2,34.76 225.2,23.95 225.11,23.74 224.9,23.65 213.6,23.65 213.39,23.74 213.3,23.95 213.3,28.35 213.27,28.56 213.17,28.76 213.17,28.86 213.26,28.92 214.05,28.92 214.99,27.97 220.06,27.97 220.15,27.91 220.14,27.8 220.4,27.21 220.67,27.8 220.66,27.91 220.75,27.97 222.92,27.97 224.69,29.74 224.69,34.7 224.85,34.86 224.88,34.86 224.97,34.85 225.07,34.86
GND on IN3 (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,44.94 14.36,44.15 12.66,44.15 11.85,43.34 11.85,37.98 12.12,37.7 14.54,37.7 14.87,37.37 14.87,36.02 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.83 13.74,34.84 14.19,35.62 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.19,46.78 13.74,47.56 13.7,47.57 13.7,48.12 14.16,48.12
GND on IN3 (solid shape): 12.53,64.09 15.1,61.53 15.1,60.34 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 11.5,66.75 11.6,66.75 11.7,66.77 12.53,66.77
GND on IN3 (solid shape): outline of 260 points within 0.2,102.63 13.67,126.93
GND on IN3 (solid shape): outline of 90 points within 161.55,119.9 170.63,154.8
GND on IN3 (solid shape): outline of 611 points within 202.65,50.1 228.2,69.2
GND on IN3 (solid shape): outline of 284 points within 0.2,0.2 228.2,155.3
GND on GND1: outline of 242 points within 0.2,0.2 228.2,151.13 ; 1 cut-out
GND on IN1, IN2, IN3: 12.2,79.2 12.2,80.85 12,81.35 11.5,81.55 7.6,81.55 7.6,82.05 7.4,82.55 6.9,82.75 6.1,82.75 5.6,82.55 5.4,82.05 5.4,81.55 0.6,81.55 0.39,81.64 0.3,81.85 0.3,83.35 0.39,83.56 0.6,83.65 2,83.65 2.5,83.85 2.7,84.35 2.7,88.6 2.79,88.81 3,88.9 10.05,88.9 10.74,89.48 10.29,90.26 10.25,90.27 10.25,91.41 10.71,91.41 10.71,90.66 11.01,90.36 13.32,90.36 13.78,89.9 13.78,89.24 12.05,87.51 12.05,81.94 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2
GND on VCC: 75.15,41.79 70.14,46.8 70.14,67.31 73.51,67.31 75.04,65.78 78.72,65.78 80.27,64.23 82.4,64.23 86.49,60.14 89.78,60.14 90.41,60.78 101.66,60.78 102.91,62.02 104.61,62.02 105.81,63.22 115.92,63.22 116.29,63.6 118.4,63.6 118.88,64.08 120.68,64.08 120.68,63.45 122.97,61.17 122.97,60.53 122.97,60.53 123.22,60.27 123.22,59.16 123.61,58.78 123.61,49.47 122.48,48.34 116.13,48.34 114.38,46.59 110.42,46.59 107.6,43.77 104.4,43.77 102.42,41.79
GND on VCC: 114.67,74.01 114.03,74.65 112.94,74.65 112.72,74.86 112.72,76.13 110.83,78.02 106.31,78.02 103.86,80.48 103.86,81.8 101.99,83.66 95.85,83.66 92.62,86.89 74.4,86.89 71.57,84.06 71.57,82.13 71.08,81.63 70.14,81.63 70.14,109.68 70.5,110.04 81.87,110.04 83.77,108.14 101.05,108.14 105.9,103.28 118.4,103.28 118.4,92.28 122.21,88.47 122.21,88.08 122.18,88.05 122.18,87.24 122.82,86.59 122.82,79.92 122.13,79.23 122.13,75.02 121.29,74.18 121.29,74.09 121.21,74.01
GND on VCC: 154.32,143.95 154.02,144.25 154.02,145.24 154.66,145.88 154.66,146.66 154.4,146.91 154.4,148.42 154.89,148.9 156.01,148.9 156.37,148.54 156.37,147.61 156.05,147.29 156.05,145.71 155.67,145.33 155.67,144.06 155.57,143.95
GND on VCC: 11,0.2 10.79,0.29 10.7,0.5 10.7,4.6 10.5,5.1 10,5.3 2.85,5.3 2.64,5.39 2.55,5.6 2.55,5.9 12.59,5.9 12.84,6.15 13.98,6.15 16.52,8.69 17.58,8.69 19.23,7.04 21.65,7.04 23.17,5.52 25.41,5.52 25.82,5.92 25.82,7.32 27.09,8.59 27.09,10.83 26.68,11.23 25.46,11.23 25.05,10.83 25.05,10.2 23.04,8.19 22.75,8.19 21.62,9.31 21.62,9.48 22.26,10.11 22.26,10.37 23.51,11.62 24.52,11.62 25.05,12.15 25.05,15.32 25.16,15.43 29.73,15.43 30.9,16.59 30.9,20.76 41,20.76 41,4.1 40.91,3.89 40.7,3.8 36.6,3.8 36.1,3.6 35.9,3.1 35.9,0.5 35.81,0.29 35.6,0.2
GND on VCC: outline of 124 points within 0.2,20.51 24.04,133.9
GND on VCC: 102.71,145.58 102.71,147.99 104.38,147.99 106.46,150.07 117.15,150.07 121.64,145.58
GND on VCC: 33.13,118.75 32.22,119.67 32.22,126.47 32.73,126.98 39.35,126.98 40.17,126.17 40.17,120.26 38.66,118.75
GND on VCC: 154.09,66.2 154.09,77.91 159.31,77.91 162.47,74.76 162.47,69.3 170.09,61.68 170.09,61.02 159.27,61.02
GND on GND2: outline of 277 points within 0.2,0.2 228.2,155.3 ; 1 cut-out
GNDA on GND1, GND2: 23.38,6.03 21.86,7.55 19.44,7.55 17.79,9.2 16.31,9.2 13.77,6.66 12.63,6.66 12.37,6.41 2.55,6.41 2.55,8.25 2.64,8.46 2.85,8.55 13.55,8.55 14.25,9.15 13.75,9.92 13.75,15.38 14.25,16.15 13.55,16.75 2.85,16.75 2.64,16.84 2.55,17.05 2.55,18.45 2.64,18.66 2.85,18.75 4,18.75 4.5,18.95 4.7,19.45 4.7,20 14.87,20 15.76,20.89 18.68,20.89 20.33,22.54 23.68,22.54 24.95,21.27 30.03,21.27 30.39,20.91 30.39,16.8 29.52,15.93 24.95,15.93 24.55,15.53 24.55,12.36 24.31,12.12 23.3,12.12 21.75,10.58 21.75,10.32 21.12,9.69 21.12,9.1 22.53,7.68 23.25,7.68 25.56,9.99 25.56,10.62 25.67,10.73 26.47,10.73 26.58,10.62 26.58,8.8 25.31,7.53 25.31,6.13 25.2,6.03
GNDA on VCC: 23.38,6.03 21.86,7.55 19.44,7.55 17.79,9.2 16.31,9.2 13.77,6.66 12.63,6.66 12.37,6.41 2.55,6.41 2.55,8.25 2.64,8.46 2.85,8.55 13.55,8.55 14.25,9.15 13.75,9.92 13.75,15.38 14.25,16.15 13.55,16.75 2.85,16.75 2.64,16.84 2.55,17.05 2.55,18.45 2.64,18.66 2.85,18.75 4,18.75 4.5,18.95 4.7,19.45 4.7,20 14.87,20 15.76,20.89 18.68,20.89 20.33,22.54 23.68,22.54 24.95,21.27 30.03,21.27 30.39,20.91 30.39,16.8 29.52,15.93 24.95,15.93 24.55,15.53 24.55,12.36 24.31,12.12 23.3,12.12 21.75,10.58 21.75,10.32 21.12,9.69 21.12,9.1 22.53,7.68 23.25,7.68 25.56,9.99 25.56,10.62 25.67,10.73 26.47,10.73 26.58,10.62 26.58,8.8 25.31,7.53 25.31,6.13 25.2,6.03
VDD_1.2V on TOP (solid shape): 36.17,27.66 36.17,26.84 35.09,25.76 34.98,25.76 34.84,25.63 34.84,25 34.79,24.95 34.76,24.96 34.63,24.97 34.5,24.94 34.49,24.93 34.18,24.93 34.07,24.95 33.96,24.93 33.54,24.93 33.53,24.94 33.38,24.97 33.23,24.94 33.22,24.93 33.07,24.93 33.06,24.94 32.77,24.94 32.76,24.93 32.68,24.93 32.68,24.94 31.75,24.94 31.66,25.03 31.66,26.03 31.74,26.11 34.18,26.11 34.87,26.8 34.87,27.63 35.02,27.78 35.64,27.78 35.68,27.78 36.06,27.78
VDDIO_AUDIO on BOTTOM (solid shape): 144.17,66.03 144.12,65.97 144.12,63.81 144.07,63.77 143.42,63.77 143.38,63.79 143.34,63.81 142.85,64.31 142.85,67.05 142.87,67.08 144.17,67.08
+APU_VDDCORE on TOP (solid shape): 164.14,58.64 164.43,58.49 164.72,58.64 168.33,58.64 170.28,56.7 170.62,56.7 170.79,56.53 170.79,54.1 170.56,53.87 153.78,53.87 153.37,54.28 153.37,58.39 153.63,58.64
+APU_VDDCORE on TOP (solid shape): 130.9,70.11 130.99,70.05 130.99,69.95 131.12,69.48 131.57,69.66 131.58,69.7 131.67,69.7 131.67,69.55 132.52,68.7 133.38,68.7 133.45,68.78 134.4,68.78 134.4,68.16 134.37,68.09 134.29,68.06 134.12,68.03 133.98,67.92 133.9,67.88 133.55,68.06 133.28,67.93 133.2,67.88 133.11,67.93 132.76,68.1 132.5,67.8 132.47,67.74 132.4,67.71 132.34,67.71 132.34,67.77 132.01,68.14 131.69,67.77 131.69,67.71 131.55,67.71 131.55,67.77 131.47,68.05 131.2,68.17 130.97,68.17 130.76,67.96 130.65,68.06 130.36,68.17 130.1,68.01 130.01,67.96 129.92,68.02 129.81,68.16 129.65,68.22 129.56,68.28 129.57,68.38 129.57,69.4 129.67,69.5 129.96,69.5 130.08,69.62 130.08,69.91 130.21,70.04 130.72,70.04 130.79,70.11
+APU_VDDCORE on TOP (solid shape): outline of 767 points within 122.14,63.88 134.4,68.19
+APU_VDDCORE on TOP (solid shape): outline of 1952 points within 122.27,69.69 134.4,84.01
+APU_VDDCORE on BOTTOM (solid shape): outline of 531 points within 146.68,50.22 172.45,68.13
+APU_VDDCORE on IN1 (solid shape): outline of 3743 points within 123.03,64.3 133.63,84.08
+APU_VDDCORE on IN2 (solid shape): outline of 8002 points within 124.72,50.87 171.22,83.93
+APU_VDDCORE on IN3 (solid shape): outline of 1856 points within 122.53,64.46 134.98,76.26
+APU_VDDCORE on VCC: 153.7,46.65 153.05,47.3 149.87,47.3 146.95,50.22 136.66,50.22 135.16,51.73 135.16,60.49 131.13,64.52 122.72,64.52 122.72,71.67 122.69,71.69 125.11,71.69 126.27,72.85 126.27,77.42 126.76,77.91 127.65,77.91 130.95,81.21 150.55,81.21 153.58,78.19 153.58,65.97 159.04,60.51 170.09,60.51 170.09,46.71 167.87,46.71 163.12,41.97 153.7,41.97
+APU_VDDSOC on TOP (solid shape): 147.89,106.73 147.99,106.66 147.96,106.55 147.92,106.05 148.42,106.01 148.49,106.03 148.55,106.01 149.05,106.05 149.01,106.55 148.99,106.66 149.08,106.73 150.67,106.73 150.82,106.57 150.82,100.25 150.22,99.65 145.5,99.65 145.28,99.87 145.28,106.36 145.65,106.73
+APU_VDDSOC on TOP (solid shape): outline of 730 points within 119.96,72.45 127.03,82.65
+APU_VDDSOC on BOTTOM (solid shape): 148.95,105.02 148.95,100.89 149.32,100.52 150.47,100.52 151.1,99.88 151.1,98.29 150.97,98.17 150.21,98.17 150.15,98.1 150.15,97.34 150.21,97.28 150.91,97.28 151.1,97.09 151.1,95.94 150.97,95.82 144.31,95.82 143.16,96.96 143.16,101.66 143.29,101.66 143.3,101.62 143.34,101.54 143.39,101.48 143.42,101.4 143.29,101.09 143.42,100.77 143.29,100.45 143.42,100.13 143.29,99.82 143.42,99.5 143.29,99.18 143.42,98.86 143.39,98.79 143.65,98.19 143.9,98.79 143.87,98.86 144,99.18 143.87,99.5 144,99.82 143.87,100.13 144,100.45 143.87,100.77 144,101.09 143.87,101.4 143.9,101.48 143.96,101.9 143.57,102.07 143.48,102.09 143.44,102.17 143.28,102.33 143.28,102.72 143.16,102.84 143.16,105.23 143.59,105.66 148.31,105.66
+APU_VDDSOC on IN3 (solid shape): outline of 435 points within 121.89,72.51 127.16,80.13
+APU_VDDSOC on VCC: 122.19,72.19 121.8,72.58 121.8,73.97 122.64,74.81 122.64,79.02 123.33,79.71 123.33,86.8 122.68,87.45 122.68,87.93 122.72,87.96 122.72,88.68 118.91,92.49 118.91,103.28 124.45,103.28 127.14,105.98 148.14,105.98 149.01,105.11 149.01,93.76 144.18,88.94 144.18,81.72 130.74,81.72 127.44,78.42 126.55,78.42 125.76,77.63 125.76,73.06 124.9,72.19
+BIF_VDDC on TOP (solid shape): 125.47,137.59 125.47,136.88 125.47,136.83 125.38,136.74 124.88,136.74 124.74,136.88 124.03,136.88 123.94,136.97 122.87,136.97 122.69,137.15 122.69,137.68 122.87,137.86 125.2,137.86
+BIF_VDDC on TOP (solid shape): 123.3,143.62 123.3,142.94 123.9,142.33 123.9,142.12 123.85,142.12 123.85,142.02 123.54,141.71 121.89,141.71 121.65,141.96 121.67,141.99 121.68,142.35 121.37,142.54 121.37,143.75 123.17,143.75
+BIF_VDDC on IN3 (solid shape): outline of 433 points within 121.61,136.88 126.19,142.89
+CCG_VBUS on TOP (solid shape): 77.89,144.64 77.89,141.18 77.69,140.99 76.62,140.99 76.45,141.15 76.45,144.72 76.63,144.9 77.64,144.9
+CCG_VBUS on TOP (solid shape): 35.94,129.65 37.16,129.65 37.25,129.56 37.25,127.86 37.11,127.72 35.3,127.72 35.01,128.01 35.01,129.83 35.2,130.02 35.57,130.02
+CCG_VBUS on TOP (solid shape): 8.13,119.84 9.04,119.84 9.13,119.75 9.13,119.53 9.01,119.41 8.16,119.41 7.88,119.69 7.26,119.69 7.23,119.72 7.23,119.86 7.34,119.97 8,119.97
+CCG_VBUS on TOP (solid shape): 9.1,122.62 9.1,122.41 8.87,122.18 7.3,122.18 7.27,122.22 7.27,122.41 7.32,122.46 7.99,122.46 8.06,122.53 8.06,122.63 8.2,122.77 8.96,122.77
+CCG_VBUS on TOP (solid shape): 19.28,130.73 19.28,127.3 19.06,127.07 19.01,127.06 17.27,127.06 17.27,127.32 17.06,127.53 16.77,127.53 16.3,127.06 12.49,127.06 12.48,127.09 12.39,127.22 12.26,127.3 12.25,127.3 12.19,127.36 12.19,130.14 12.46,130.41 15.15,130.41 15.41,130.66 15.47,130.69 15.83,130.58 16.08,130.74 16.09,130.75 16.27,130.93 19.08,130.93
+CCG_VBUS on BOTTOM (solid shape): 37.54,132.55 37.54,130.24 37.53,130.23 37.51,130.11 37.53,129.98 37.54,129.97 37.54,127.43 37.5,127.39 36.69,127.39 36.41,127.67 35.2,127.67 35.1,127.77 35.1,132.16 35.56,132.62 37.46,132.62
+CCG_VBUS on BOTTOM (solid shape): 31.76,117.91 31.76,116.55 31.66,116.3 31.76,116.05 31.76,115.79 31.64,115.68 29.37,115.68 29.23,115.82 29.23,117.02 29.3,117.23 29.23,117.44 29.23,117.88 29.37,118.02 31.66,118.02
+CCG_VBUS on BOTTOM (solid shape): outline of 126 points within 8.09,116.69 13.81,119.87
+CCG_VBUS on IN1 (solid shape): 77.79,142.02 77.79,141.09 77.73,141.03 75.84,141.03 75.77,141.1 75.77,142.01 75.88,142.12 77.69,142.12
+CCG_VBUS on IN1 (solid shape): outline of 1472 points within 7.36,118.22 37.35,132.93
+CCG_VBUS on IN2 (solid shape): outline of 974 points within 8.04,116.3 37.4,133.08
+CCG_VBUS_1 on TOP (solid shape): 49.56,139.81 49.56,137.42 49.53,137.38 46.14,137.38 45.73,137.79 45.73,139.73 45.94,139.95 49.42,139.95
+CCG_VBUS_1 on TOP (solid shape): 28.33,115.81 28.33,115.07 28.46,114.94 28.52,114.87 28.59,114.8 28.61,114.8 28.86,114.72 29.12,114.8 29.13,114.8 29.18,114.8 29.43,114.55 29.43,114.1 29.09,113.76 29.09,112.73 29.02,112.66 28.46,112.66 28.08,113.04 28.08,113.67 27.92,113.83 26.8,113.83 26.73,113.89 26.73,115.12 27.54,115.93 28.2,115.93
+CCG_VBUS_1 on BOTTOM (solid shape): 47.51,139.72 47.51,137.07 46.8,136.36 45.08,136.36 45.03,136.41 45.03,139.68 45.41,140.06 47.16,140.06
+CCG_VBUS_1 on BOTTOM (solid shape): 41.47,132.7 41.47,128.37 39.26,128.37 38.29,129.34 38.29,129.65 40.57,129.65 40.57,129.6 40.58,129.54 40.6,129.49 40.62,129.45 40.65,129.4 40.69,129.36 40.73,129.33 40.77,129.3 40.82,129.28 40.87,129.27 40.93,129.27 40.98,129.27 41.03,129.28 41.08,129.3 41.13,129.33 41.17,129.36 41.21,129.4 41.24,129.45 41.26,129.49 41.28,129.54 41.28,129.6 41.28,129.65 41.28,129.7 41.26,129.75 41.24,129.8 41.21,129.85 41.17,129.89 41.13,129.92 41.08,129.95 41.03,129.97 40.98,129.98 40.93,129.98 40.87,129.98 40.82,129.97 40.77,129.95 40.73,129.92 40.69,129.89 40.65,129.85 40.62,129.8 40.6,129.75 40.58,129.7 40.57,129.65 38.29,129.65 38.29,132.62 38.44,132.77 41.4,132.77
+CCG_VBUS_1 on IN2 (solid shape): 47.23,139.7 47.23,135.17 44.73,132.67 43.47,131.93 42.73,130.67 42.48,130.41 39.45,130.41 39.21,130.65 39.21,132.61 39.42,132.81 41.46,132.81 44.36,135.71 44.36,139.75 44.55,139.94 47,139.94
+CCG_VBUS_1 on IN3 (solid shape): 47.23,139.7 47.23,135.17 44.73,132.67 43.47,131.93 42.73,130.67 42.48,130.41 39.45,130.41 39.21,130.65 39.21,132.61 39.42,132.81 41.46,132.81 44.36,135.71 44.36,139.75 44.55,139.94 47,139.94
+CHARGER_SRC on TOP (solid shape): 201.02,56.54 201.02,53.45 200.95,53.38 199.74,53.38 199.55,53.57 199.55,56.3 199.82,56.58 200.99,56.58
+CHARGER_SRC on BOTTOM (solid shape): outline of 172 points within 188.25,51.86 201.33,61.84
+CHGRTC on TOP (solid shape): 158.94,31.4 159.42,31.4 159.47,31.35 159.47,31.25 159.31,31.09 159.31,30.79 159.47,30.62 159.47,30.6 159.39,30.52 158.22,30.52 158.17,30.58 158.17,31.36 158.21,31.4 158.76,31.4 158.76,31.95 158.94,31.95
+DC_IN on TOP (solid shape): 173.33,38.04 173.33,36.36 173.3,36.33 173.27,36.33 173.12,36.29 173,36.19 172.97,36.16 172.35,35.55 172.32,35.55 172.29,35.53 172.26,35.52 170.43,35.52 170.26,35.69 170.26,37.28 170.36,37.38 172.15,37.38 172.31,37.54 172.31,38.01 172.38,38.08 173.29,38.08
+DC_IN on TOP (solid shape): outline of 270 points within 81.61,144.01 94.08,148.39
+DC_IN_SS on TOP (solid shape): 100.17,146.22 100.17,143.56 100.09,143.43 100.07,143.28 99.73,142.93 97.44,142.93 97,143.38 94.9,143.38 94.4,143.89 94.4,146.3 94.78,146.68 99.72,146.68
+DC_IN_SS on TOP (solid shape): 93.63,142.36 93.63,140.13 93.35,139.78 93.63,139.44 93.63,138.3 93.25,137.92 91.66,137.92 91.54,138.04 91.54,142.55 91.79,142.81 93.19,142.81
+DC_IN_SS on BOTTOM (solid shape): 202.15,60.76 203.19,60.76 203.62,60.34 203.62,60.07 203.3,59.75 203.09,59.75 202.91,59.57 202.21,59.57 201.46,60.32 200.98,60.79 200.98,60.97 201.34,61.33 201.59,61.33
+DC_IN_SS on IN2 (solid shape): 203.68,59.99 203.68,59.82 202.92,59.06 202.03,59.06 201.9,59.19 201.9,59.75 202.72,60.56 203.11,60.56
+DC_IN_SS on IN2 (solid shape): outline of 134 points within 91.53,137.8 100.49,146.17
+EC_VCCA on BOTTOM (solid shape): outline of 176 points within 38.18,81.95 49.91,89.71
+FP_VCC on BOTTOM (solid shape): 222.59,34.78 222.59,29.13 222.33,28.87 221.08,28.87 220.51,28.3 217.67,28.3 217.34,28.62 217.34,31.17 217.43,31.26 218.08,31.26 218.14,31.2 218.14,30.6 218.14,30.54 218.14,29.95 218.56,29.53 219.14,29.53 219.15,29.49 219.41,29.23 219.77,29.34 219.78,29.36 219.8,29.36 220.28,29.84 220.41,29.84 220.5,29.82 220.58,29.84 220.79,29.84 220.8,29.83 220.93,29.83 220.94,29.83 221.14,29.86 221.27,30.03 221.27,30.04 221.57,30.34 221.57,34.77 221.71,34.91 222.45,34.91
+INV_PWR_SRC on TOP (solid shape): outline of 165 points within 201.77,56.72 211.23,59.94
+INV_PWR_SRC on BOTTOM (solid shape): 213.08,60.76 213.08,58.92 212.89,58.73 211.93,58.73 211.91,58.72 211.78,58.65 211.71,58.52 211.71,58.51 211.46,58.26 210.28,58.26 210.21,58.34 210.21,58.78 210.6,59.18 211.3,59.18 211.34,59.22 211.35,59.22 211.56,59.42 211.56,59.71 211.55,59.72 211.55,60.03 211.56,60.04 211.59,60.19 211.56,60.34 211.55,60.35 211.55,60.51 211.87,60.83 213.01,60.83
+LAN_VDD10 on TOP (solid shape): 20.8,82.48 21.75,82.48 21.81,82.42 21.81,82.23 21.75,82.16 20.16,82.16 19.74,81.74 19.72,81.72 19.7,81.7 19.15,81.15 18.7,81.15 18.64,81.21 18.64,81.85 19.4,82.61 20.67,82.61
+LAN_VDD10 on BOTTOM (solid shape): 20.99,83.37 20.99,82.67 20.93,82.67 20.93,82.29 20.24,81.61 20.24,80.79 19.65,80.2 19.31,80.2 18.47,80.2 18.39,80.28 18.39,81.75 18.41,81.76 18.52,81.85 18.59,81.98 18.59,81.99 19.19,82.58 19.2,82.59 19.4,82.69 19.5,82.88 19.5,82.9 20.04,83.43 20.93,83.43
+LAN_VDD10 on BOTTOM (solid shape): 23.01,86.04 23.09,86.01 23.11,85.93 23.44,85.54 23.82,85.88 23.85,85.95 23.92,85.98 25.11,85.98 25.11,85.32 24.99,85.2 23.53,85.2 23.49,85.16 23.48,85.16 23.48,85.15 23.34,85.01 23.34,84.56 23.22,84.44 22.62,84.44 22.56,84.49 22.56,85.55 22.59,85.58 22.59,85.95 22.68,86.04
+LAN_VDD10 on IN1 (solid shape): 20.74,82.48 20.74,81.97 20.5,81.74 20.49,81.74 20.36,81.65 20.27,81.52 20.27,81.51 20.16,81.4 20.16,80.96 20.54,80.58 24.93,80.58 24.99,80.64 25.56,80.64 25.69,80.51 25.69,79.88 25.5,79.69 24.14,79.69 23.81,79.84 23.47,79.76 23.1,79.86 22.75,79.69 19.27,79.69 18.77,80.2 18.77,82.04 19.4,82.67 20.54,82.67
+LAN_VDD10 on IN3 (solid shape): outline of 346 points within 19.15,79.37 24.23,86.1
+LAN_VDD33 on TOP (solid shape): outline of 106 points within 24.28,88.98 28.11,91.66
+LAN_VDD33 on BOTTOM (solid shape): 21.19,81.66 21.99,81.66 22.47,81.18 22.47,80.58 22.3,80.41 20.94,80.41 20.78,80.25 20.78,79.23 20.63,79.09 20.1,79.09 19.99,79.19 19.99,80.36 20.17,80.53 20.22,80.58 20.27,80.64 20.37,80.74 20.37,80.78 20.42,80.82 20.42,81.55 20.58,81.71 21.13,81.71
+LAN_VDD33 on BOTTOM (solid shape): 26.12,83.97 26.12,83.17 26.64,82.65 26.64,82.23 26.39,81.97 26.26,81.97 25.88,82.35 25.12,82.35 24.93,82.55 24.93,82.83 24.94,82.93 24.93,83.02 24.93,83.95 24.94,84.04 24.93,84.2 25.02,84.3 25.79,84.3
+LAN_VDD33 on BOTTOM (solid shape): outline of 220 points within 20.74,87.1 25.49,91.45
+LAN_VDD33 on IN1 (solid shape): 26.89,82.61 26.89,81.53 26.32,80.96 25.12,80.96 24.93,80.77 20.67,80.77 20.35,81.08 20.35,81.41 20.66,81.72 21.37,81.72 21.62,81.47 22.25,81.47 22.35,81.45 22.44,81.47 23.37,81.47 23.47,81.45 23.56,81.47 24.49,81.47 24.58,81.45 24.74,81.47 24.83,81.56 24.88,81.61 25.62,82.35 25.62,82.67 25.75,82.8 26.7,82.8
+LAN_VDD33 on IN1 (solid shape): outline of 364 points within 24.04,86.78 33.34,91.11
+LAN_VDD33 on IN3 (solid shape): outline of 457 points within 19.02,81.12 25.54,91.65
+LAN_VDDREG on TOP (solid shape): 22.56,85.98 22.51,85.73 22.64,85.52 22.64,85.32 22.64,84.68 22.64,84.64 22.58,84.58 22.39,84.58 22.32,84.64 22.32,85.34 22.29,85.37 22.28,85.39 22.15,85.53 21.95,85.52 21.94,85.51 21.4,85.51 21.32,85.59 21.32,86.07 21.62,86.37 22.17,86.37
+LAN_VDDREG on BOTTOM (solid shape): 23.34,86.8 23.34,86.24 23.28,86.2 23.25,86.18 22.58,86.18 22.47,86.07 22.47,85.63 22.36,85.53 21.56,85.53 21.31,85.78 21.31,85.96 21.31,86.74 21.54,86.97 23.17,86.97
+LCDVDD on TOP (solid shape): 221.47,47.33 221.47,46.8 221.47,46.6 222.2,45.87 222.2,44.99 222.09,44.88 221.48,44.88 221.32,45.04 221.32,45.57 220.87,46.02 220.71,46.02 220.46,46.26 220.46,47.37 221.44,47.37
+LCDVDD_CONN on TOP (solid shape): 223.67,48.44 223.67,46.47 223.49,46.29 222.01,46.29 221.62,46.68 221.62,47.55 221.49,47.68 221.18,47.68 221.03,47.84 221.03,48.44 221.08,48.5 223.62,48.5
+LCDVDD_CONN on BOTTOM (solid shape): 214.29,57.6 214.29,55.21 214.05,54.97 213.94,54.97 213.44,54.47 213.18,54.47 213.08,54.57 213.08,55.88 213.57,56.21 213.08,56.53 213.08,56.7 213.01,56.76 211.92,56.76 211.83,56.86 211.83,57.55 211.93,57.65 214.24,57.65
+LCDVDD_CONN on IN1 (solid shape): outline of 240 points within 212.94,46.41 223.74,55.88
+LCDVDD_CONN on IN3 (solid shape): 213.61,55.47 213.61,55.18 218.19,50.61 220.26,50.61 220.99,49.87 220.99,49.65 221,49.63 222.1,48.53 222.1,46.62 221.45,46.62 221.31,46.76 221.31,48.15 220.2,49.26 220.2,49.5 219.9,49.8 217.88,49.8 213.01,54.66 213.01,55.12 213.03,55.14 213.03,55.54 213.05,55.57 213.51,55.57
+PCIE_VDDC on TOP (solid shape): 127.3,143.05 127.3,142.02 127.69,141.62 127.69,140.27 127.54,140.11 127.54,138.83 127.19,138.48 126.39,138.48 125.96,138.06 122.31,138.06 121.85,138.52 121.85,139.31 121.94,139.39 125.1,139.39 125.26,139.56 125.26,140.37 125.12,140.51 124.88,140.51 124.82,140.57 124.82,140.74 125.8,140.74 125.8,140.69 125.81,140.64 125.82,140.59 125.84,140.54 125.87,140.5 125.91,140.46 125.95,140.42 126,140.4 126.05,140.38 126.1,140.37 126.15,140.36 126.21,140.37 126.26,140.38 126.31,140.4 126.35,140.42 126.4,140.46 126.43,140.5 126.46,140.54 126.48,140.59 126.5,140.64 126.51,140.69 126.51,140.74 126.5,140.8 126.48,140.85 126.46,140.9 126.43,140.94 126.4,140.98 126.35,141.01 126.31,141.04 126.26,141.06 126.21,141.07 126.15,141.07 126.1,141.07 126.05,141.06 126,141.04 125.95,141.01 125.91,140.98 125.87,140.94 125.84,140.9 125.82,140.85 125.81,140.8 125.8,140.74 124.82,140.74 124.82,142.03 125.07,142.29 125.07,142.6 124.88,142.8 124.5,142.8 124.5,142.79 124.29,142.69 124.2,142.78 123.99,143.08 123.99,143.11 124.54,143.66 126.68,143.66
+PCIE_VDDC on BOTTOM (solid shape): 116.56,121.27 116.56,120.25 116.99,119.82 116.99,118.21 116.53,117.75 116.53,116.71 116.99,116.25 116.99,115.22 116.75,114.98 114.49,114.98 114.43,115.05 114.43,116.4 114.59,116.56 114.59,120.37 114.85,120.63 114.87,120.64 115.07,120.74 115.17,120.94 115.17,120.96 115.55,121.33 116.5,121.33
+PCIE_VDDC on IN1 (solid shape): outline of 1777 points within 112.75,120.1 127.93,142.96
+PWR_SRC_AC on BOTTOM (solid shape): 187.49,60.18 187.49,56.89 187.33,56.73 183.3,56.73 183.2,56.83 183.2,58.14 183.26,58.21 183.68,58.21 183.74,58.14 183.74,57.45 183.93,57.26 184.44,57.26 184.63,57.45 184.63,58.14 184.69,58.21 185.07,58.21 185.52,58.65 185.52,60.11 185.71,60.3 187.36,60.3
+RTC_APU_R on BOTTOM (solid shape): 132.78,34.58 134.45,34.58 134.77,34.27 134.77,33.16 134.54,32.93 132.8,32.93 132.64,33.09 132.64,33.73 132.37,34.01 131.54,34.01 131.43,34.13 131.43,34.79 131.56,34.92 132.43,34.92
+RTCVCC on TOP (solid shape): 156.91,30.28 157.63,30.28 158.44,29.47 158.44,29.26 158.91,28.79 158.91,28.12 158.72,27.93 154.81,27.93 154.55,28.19 154.55,30.56 154.39,30.71 154.39,31.61 154.53,31.75 155.44,31.75
+SDC_IN on TOP (solid shape): 64.95,138.94 66.39,138.94 66.48,138.85 66.48,137 66.48,137 66.48,136.72 66.95,136.25 67.94,136.25 68.46,135.73 68.46,135.18 68.85,134.79 68.85,134.37 68.63,134.15 68.12,134.15 67.78,133.8 67.78,132.72 66.23,131.17 66.23,130.2 65.08,130.2 64.87,129.98 63.24,129.98 62.58,130.64 62.58,131.62 62.59,131.72 62.58,131.82 62.58,136.93 63.28,137.63 63.28,139.04 63.4,139.16 64.73,139.16
+SDC_IN on TOP (solid shape): outline of 99 points within 94.08,137.98 109.38,153.13
+SDC_IN on TOP (solid shape): outline of 622 points within 159.61,60.38 187.2,119.06
+SDC_IN on BOTTOM (solid shape): 130.44,152.38 130.56,152.36 130.68,152.38 135.94,152.38 136.18,152.14 136.18,149.79 135.86,149.47 130.56,149.47 130.04,149.99 130.04,152.07 130.35,152.38
+SDC_IN on BOTTOM (solid shape): 168.22,121 168.46,121 168.75,120.71 168.75,116.71 168.28,116.23 168.28,114.6 168.2,114.51 167.65,114.51 167.26,114.51 166.87,114.47 163.44,114.47 163.23,114.68 163.23,116.64 163.74,117.15 165.77,117.15 166.24,117.62 166.24,120.62 166.63,121.01 168.21,121.01
+SDC_IN on BOTTOM (solid shape): 117.12,154.25 117.12,154.1 117.28,153.93 117.28,152.01 117.08,151.81 114.51,151.81 113.45,150.74 107.54,150.74 104.59,147.79 102.43,147.79 101.95,148.27 101.95,149.94 102.74,150.65 103.35,151.51 103.36,151.52 103.67,151.82 105.13,151.82 106.62,153.32 113.6,153.32 114.78,154.49 116.87,154.49
+SDC_IN on BOTTOM (solid shape): 185.52,61.59 185.52,60.77 185.26,60.51 185.26,59.41 185.09,59.24 184.53,59.24 184.53,59.77 184.17,60.13 183.81,59.77 183.81,59.24 183.36,59.24 183.23,59.37 183.23,61.4 183.23,61.78 183.42,61.97 185.14,61.97
+SDC_IN on BOTTOM (solid shape): 171.48,91.44 174.06,82.39 180.16,75.22 180.18,75.2 180.18,75.05 179.28,74.15 178.39,74.15 176.18,76.32 174.85,78.08 174.85,78.78 173.25,80.38 173.2,80.51 172.31,81.91 171.01,84.24 170.28,86.8 170.28,86.86 169.52,87.63 169.52,88.7 169.26,88.96 169.26,92.07 168.88,92.45 168.88,100.08 168.44,100.52 168.44,103.06 168.63,103.25 170.73,103.25
+SDC_IN on IN3 (solid shape): outline of 1582 points within 63.93,130.99 106.65,152.5
+SDC_IN on VCC: outline of 93 points within 102.71,60.83 186.47,154.58
+SPI_VCC on TOP (solid shape): outline of 118 points within 119.93,39.8 121.95,45.11
+SPLL_VDDC on TOP (solid shape): 132.03,124.21 132.03,123.79 132.88,122.94 132.88,122.68 133.06,122.5 133,122.11 133.35,121.91 133.42,121.83 133.42,119.21 133.36,119.15 132.6,119.15 132.56,119.18 132.56,120.82 131.94,121.44 131.94,121.54 131.97,121.62 132.06,121.64 132.5,122.07 131.91,122.25 131.88,122.24 131.86,122.24 131.84,122.25 131.31,122.79 131.31,123.97 131.31,123.97 131.31,124.21 131.49,124.39 131.85,124.39
+TPAN_VDD_F on TOP (solid shape): outline of 117 points within 211.43,29.27 214.98,41.71
+VCHGR on TOP (solid shape): outline of 222 points within 170.13,37.54 178.78,46.16
+VCHGR on BOTTOM (solid shape): 178.83,45.9 178.83,43.01 178.62,42.79 178.04,42.79 178.04,43.32 177.68,43.67 177.33,43.32 177.33,43.14 177.32,43.1 177.31,43.05 177.31,42.83 175.59,42.83 175.37,43.05 175.37,44.1 175.47,44.2 176.4,44.2 177.09,44.89 177.09,45.95 177.22,46.08 178.66,46.08
+VCHGR on BOTTOM (solid shape): outline of 883 points within 148.37,28.89 171.91,38.67
+VGA_CORE on TOP (solid shape): 116.58,126.12 116.58,125.76 116.88,125.47 116.88,125.09 117.3,124.66 117.3,124.4 115.46,122.56 114.68,121.78 114.54,121.78 113.19,123.12 113.19,124.24 115.73,126.78 115.92,126.78
+VGA_CORE on TOP (solid shape): 119.41,132.22 119.41,131.01 119.73,130.69 120.96,130.69 121.61,130.04 122.14,130.04 122.78,130.68 123.12,130.68 123.24,130.56 123.24,130.31 122.51,129.59 122.51,128.14 122.4,128.02 121.81,128.02 121.69,128.15 121.69,128.95 121.23,129.41 120.19,129.41 120.18,129.4 119.12,129.4 118.07,130.45 118.07,131.25 118.36,131.54 118.36,132.29 118.55,132.48 119.15,132.48
+VGA_CORE on TOP (solid shape): 122.41,124.61 122.41,123.06 122.26,122.9 122.2,122.69 122.2,121.29 122.11,121.2 122.11,120.32 122.05,120.26 118.99,120.26 118.98,120.25 116.79,120.25 116.68,120.35 116.68,120.91 116.77,121 118.16,121 118.41,121.25 118.41,121.84 119.46,122.89 119.46,123.15 120.65,124.34 120.76,124.41 120.84,124.52 121.17,124.85 122.17,124.85
+VGA_CORE on BOTTOM (solid shape): 119.04,132.25 119.04,132.23 119.1,131.7 119.63,131.75 119.8,131.75 119.99,131.56 119.99,131.16 119.99,131.15 120.02,130.79 120.34,130.62 120.36,130.62 120.44,130.54 120.63,130.54 120.95,130.22 120.95,130.1 120.2,129.35 120.2,129.35 120.07,129.27 119.99,129.14 119.98,129.13 119.36,128.51 118.41,128.51 118.28,128.38 117.95,128.38 117.89,128.43 117.82,128.47 117.81,128.47 117.77,128.51 117.77,128.83 117.82,128.88 117.83,128.88 117.97,128.96 118.06,129.1 118.06,129.12 118.38,129.43 118.53,129.68 118.45,129.96 118.34,130.06 118.21,130.1 118.04,130.27 118.05,130.3 118.06,130.48 117.96,130.64 117.96,131.09 118.02,131.15 118.02,131.42 118.07,131.64 117.96,131.84 117.96,132.13 118.28,132.44 118.85,132.44
+VGA_CORE on BOTTOM (solid shape): 127.76,136.81 127.76,136.79 127.79,136.65 127.87,136.53 127.87,136.06 127.76,135.8 127.87,135.53 127.87,135.06 127.76,134.8 127.87,134.53 127.87,134.06 127.76,133.8 127.87,133.53 127.87,133.26 127.76,133 127.87,132.73 127.87,132.26 127.79,132.16 127.76,132.04 127.76,132.02 127.49,131.75 127.47,131.73 127.39,131.5 127.49,131.27 127.49,130.86 127.3,130.67 126.98,130.67 126.49,131.16 126.48,131.17 126.41,131.27 126.31,131.34 126.3,131.34 125.9,131.75 125.9,132.13 126.09,132.32 126.37,132.32 126.53,132.16 126.58,132.16 126.59,132.15 127.07,132.33 126.88,132.81 126.87,132.81 126.28,133.4 125.9,133.4 125.77,133.52 125.77,133.97 126.03,134.22 126.09,134.22 126.34,134.47 126.34,134.47 126.51,134.89 126.17,135.18 126.15,135.18 125.71,135.62 125.71,135.92 125.79,136 125.8,136 125.89,136.05 125.97,136.13 126.33,136.13 126.87,136.12 126.79,136.66 126.79,136.9 126.82,136.92 126.94,136.98 127.02,137.08 127.49,137.08
+VGA_CORE on BOTTOM (solid shape): outline of 212 points within 94.78,120.33 107.43,141.85
+VGA_CORE on IN1 (solid shape): outline of 2012 points within 115.5,120.45 127.93,137.68
+VGA_CORE on IN2 (solid shape): outline of 6023 points within 102.08,120.25 128.25,147.93
+VGA_CORE on IN3 (solid shape): outline of 2464 points within 115.22,117.31 127.87,136.61
+VGA_CORE on VCC: 96.65,117.53 96.65,144.59 97.13,145.08 105.35,145.08 106.08,145.07 106.09,145.08 125.99,145.08 125.99,136.33 127.89,134.43 127.89,132.74 126.62,131.47 126.62,129.98 127.89,128.71 127.89,127.02 125.99,125.12 125.99,117.53
+VREF_CA on TOP (solid shape): 72.3,67.55 72.39,67.56 73.25,67.56 73.38,67.43 73.38,65.27 73.19,65.08 71.54,65.08 71.41,65.21 71.41,67.43 71.54,67.56 72.2,67.56
+VREFB_CA on TOP (solid shape): 59.28,68.45 59.28,67.62 59.41,67.5 59.79,67.5 59.98,67.69 60.49,67.69 60.61,67.56 60.61,65.59 60.17,65.15 58.39,65.15 58.33,65.21 58.33,65.95 58.4,66.02 58.42,66.02 58.42,66.27 59.66,66.27 59.66,66.21 59.67,66.16 59.69,66.11 59.71,66.07 59.74,66.02 59.78,65.99 59.82,65.96 59.86,65.93 59.91,65.92 59.97,65.91 60.02,65.91 60.07,65.92 60.12,65.93 60.16,65.96 60.21,65.99 60.24,66.02 60.27,66.07 60.3,66.11 60.31,66.16 60.32,66.21 60.32,66.27 60.31,66.32 60.3,66.37 60.27,66.41 60.24,66.45 60.21,66.49 60.16,66.52 60.12,66.55 60.07,66.56 60.02,66.57 59.97,66.57 59.91,66.56 59.86,66.55 59.82,66.52 59.78,66.49 59.74,66.45 59.71,66.41 59.69,66.37 59.67,66.32 59.66,66.27 58.42,66.27 58.42,68.51 59.22,68.51
ACIN_CHG on BOTTOM (solid shape): 201.46,52.18 201.46,51.36 201.47,51.35 201.47,51.17 201.46,51.16 201.46,49.91 201.37,49.82 200.87,49.82 200.72,49.97 200.72,52.17 200.85,52.29 201.34,52.29
AUD_PORTA_L_R_B on TOP (solid shape): 17.37,20.51 17.37,16.76 17.18,16.57 15.91,16.57 15.66,16.82 15.66,20.63 15.91,20.89 16.99,20.89
AUD_PORTA_R_R_B on TOP (solid shape): 18.83,20.76 18.83,19.49 18.73,19.24 18.83,18.99 18.83,18.51 18.83,18.5 18.79,18.35 18.83,18.2 18.83,18.19 18.83,17.52 18.73,17.27 18.83,17.02 18.83,16.63 18.64,16.44 17.88,16.44 17.62,16.7 17.62,20.82 17.81,21.01 18.58,21.01
BOOT1_CHG on BOTTOM (solid shape): 201.17,46.61 201.21,46.47 201.32,46.36 201.51,46.16 201.69,46.16 202.03,45.83 202.79,45.83 202.85,45.76 202.85,45.63 202.79,45.57 201.96,45.57 201.9,45.63 201.16,45.63 201.07,45.65 200.99,45.63 200.57,45.63 200.5,45.7 200.5,46.59 200.57,46.65 201.16,46.65
BOOT2_CHG on BOTTOM (solid shape): 204.87,44.14 204.87,43.41 204.83,43.37 204.83,43.33 204.76,43.25 204.76,42.75 204.75,42.74 204.72,42.59 204.75,42.43 204.76,42.42 204.76,42.27 204.13,41.65 203.91,41.65 203.91,41.52 202.66,41.52 202.55,41.64 202.55,42.17 202.6,42.22 203.69,42.22 203.74,42.17 204.36,42.17 204.54,42.35 204.54,42.51 204.57,42.65 204.55,42.77 204.54,42.78 204.54,43.31 204.57,43.34 204.57,43.36 204.66,43.44 204.66,44.15 204.69,44.19 204.82,44.19
BST1_APU on TOP (solid shape): 152.88,85.28 152.88,84.42 152.78,84.32 152.54,84.32 152.53,84.31 152.45,84.31 151.87,83.73 151.87,83.27 151.97,83.17 152.09,83.17 152.09,82.45 152.03,82.4 151.18,82.4 151.13,82.45 151.13,83.72 151.26,83.85 151.27,83.85 151.44,83.95 151.54,84.12 151.54,84.13 152.55,85.14 152.55,85.27 152.63,85.35 152.81,85.35
BST1_VGA on TOP (solid shape): 77.12,127.88 77.12,127.62 77.12,127.62 77.12,127.46 77.11,126.95 77.62,126.95 77.9,126.95 78.08,127.13 78.08,127.4 78.14,127.54 78.14,127.69 78.71,127.69 78.77,127.63 78.77,126.56 78.59,126.37 76.98,126.37 76.49,126.87 76.49,127.48 76.22,127.74 76.22,127.92 76.25,127.95 77.06,127.95
BST2_APU on TOP (solid shape): 156.55,85.3 156.56,85.3 157.83,84.03 157.83,82.4 157.78,82.34 156.84,82.34 156.76,82.42 156.76,83.03 156.84,83.12 157.19,83.12 157.28,83.2 157.28,83.3 157.31,83.33 157.31,83.61 157.31,83.62 157.28,83.88 157.08,84.05 157.07,84.06 156.82,84.31 156.57,84.31 156.57,84.31 156.47,84.33 156.38,84.33 156.35,84.33 156.25,84.43 156.25,85.32 156.29,85.37 156.48,85.37
BST2_VGA on TOP (solid shape): 77.5,134.17 77.5,133.26 77.45,133.08 77.5,132.9 77.12,132.52 77.12,131.5 77,131.38 76.36,131.38 76.3,131.44 76.3,132.65 76.34,132.69 76.35,132.69 76.49,132.78 76.57,132.91 76.57,132.92 76.74,133.09 76.74,134.17 76.81,134.23 77.44,134.23
BST_3V on BOTTOM (solid shape): 21.47,41.26 21.47,39.63 21.4,39.56 20.77,39.56 20.61,39.73 20.61,40.39 20.68,40.47 20.68,41.03 20.66,41.05 20.66,41.79 20.74,41.87 20.86,41.87
BST_5V on BOTTOM (solid shape): 24.23,100.45 24.23,99.78 24.1,99.2 24.68,99.31 24.82,99.18 24.82,98.39 24.75,98.32 24.48,98.32 24.42,98.38 24.12,98.38 23.87,98.63 23.79,99.02 23.41,99.09 23.28,99.23 23.28,100.45 23.34,100.52 24.16,100.52
BST_+1.35VGPU_R on TOP (solid shape): 147.52,108.5 147.52,107.95 147.4,107.83 146.82,107.83 146.64,107.65 145.92,107.65 145.83,107.74 145.83,108.57 145.91,108.64 147.38,108.64
BST_+VDDP on BOTTOM (solid shape): 165.67,43.82 165.67,42.07 165.55,41.96 164.89,41.96 164.71,42.13 164.71,44.42 164.75,44.46 165.03,44.46
BST_+VDDP_R on BOTTOM (solid shape): 164.22,42.87 164.22,42.05 164.17,41.99 162.73,41.99 162.59,42.13 162.59,42.9 162.62,42.92 164.17,42.92
BST_NB on TOP (solid shape): 157.87,85.26 158.11,85.26 158.23,85.13 158.23,84.63 158.09,84.48 157.65,84.48 156.71,85.43 156.6,85.43 156.54,85.49 156.54,85.59 156.6,85.65 157.48,85.65
BST_NB on BOTTOM (solid shape): 159.9,85.63 159.9,84.62 159.72,84.44 157.95,84.44 157.74,84.66 157.74,85.15 157.83,85.24 158.6,85.24 159.05,85.7 159.83,85.7
CCG4_CC1_P1 on BOTTOM (solid shape): 40.1,121.57 40.96,121.57 41.02,121.51 41.02,121.19 40.95,121.12 40.03,121.12 39.96,121.19 39.93,121.23 39.9,121.25 39.78,121.37 39.02,121.37 38.96,121.43 38.96,121.62 39.03,121.69 39.98,121.69
CCG4_CC2_P1 on BOTTOM (solid shape): 40.7,123.54 40.7,122.65 40.44,122.4 38.97,122.4 38.93,122.45 38.93,122.64 39.01,122.72 39.86,122.72 39.96,122.82 39.96,122.9 39.97,122.91 40.01,123.05 39.97,123.18 39.96,123.19 39.96,123.4 39.99,123.44 40,123.49 40.11,123.6 40.64,123.6
DCIN_CHG on TOP (solid shape): 203.97,51.15 203.97,50.18 203.56,49.77 201.81,49.77 201.67,49.91 201.67,51.19 201.79,51.3 203.81,51.3
DCIN_CHG on BOTTOM (solid shape): 203.62,51.04 203.62,50.14 203.6,50.13 203.6,49.81 203.28,49.48 203.28,49.03 203.25,48.88 203.28,48.74 203.28,48.48 203.3,48.46 203.3,47.6 203.23,47.54 202.92,47.54 202.78,47.68 202.78,47.68 201.99,48.48 201.99,49.59 201.59,49.98 201.59,51.11 201.63,51.15 203.5,51.15
DP_VSSR on BOTTOM (solid shape): outline of 329 points within 111.82,130.69 115.88,133.15
DP_VSSR on BOTTOM (solid shape): outline of 810 points within 111.29,134.93 116.37,139.71
DP_VSSR on IN1 (solid shape): outline of 167 points within 111.25,132.18 114.31,139.23
DP_VSSR on IN3 (solid shape): outline of 122 points within 114.21,130.61 117.28,139.23
EN_1.8VALW on BOTTOM (solid shape): 175.33,57.04 175.87,57.04 176,56.91 176,55.76 175.87,55.64 173.39,55.64 173.26,55.77 173.26,56.97 173.43,57.14 175.23,57.14
FB_1.8VALW on BOTTOM (solid shape): 176.02,60.24 176.02,59.18 175.95,59.11 175.64,59.11 175.06,58.53 175.06,58.52 175.02,58.48 174.42,58.48 174.35,58.55 174.35,60.69 174.44,60.79 175.47,60.79
INT-SPK-L+ on TOP (solid shape): 27.21,10.66 27.21,7.81 27.1,7.69 26.56,7.69 26.51,7.74 26.51,8.25 26.96,8.69 26.96,8.77 26.96,9.04 26.97,9.06 26.97,9.79 26.96,9.81 26.96,10.66 27.02,10.73 27.15,10.73
INT-SPK-L- on TOP (solid shape): 27.59,10.66 27.59,8.77 28.16,8.2 28.16,7.81 28.1,7.74 27.53,7.74 27.47,7.81 27.47,7.96 27.34,8.09 27.34,10.66 27.4,10.73 27.53,10.73
INT-SPK-R+ on TOP (solid shape): 25.4,5.44 25.4,4.65 25.27,4.52 23.77,4.52 23.66,4.64 23.66,5.39 23.78,5.52 25.32,5.52
INT-SPK-R+ on TOP (solid shape): 28.42,10.66 28.42,9.84 28.42,9.52 29.12,8.82 29.12,8.63 28.93,8.44 28.74,8.44 28.16,9.01 28.16,10.66 28.23,10.73 28.36,10.73
INT-SPK-R+ on IN1 (solid shape): 29.12,8.82 29.12,8.63 28.93,8.44 28.23,8.44 27.94,8.16 27.94,5.81 26.77,4.63 24.42,4.63 24.29,4.76 24.29,5.23 24.39,5.33 26.51,5.33 27.21,6.03 27.21,8.44 28.1,9.33 28.61,9.33
INT-SPK-R- on TOP (solid shape): 25.43,4.14 25.43,3.55 24.98,3.09 23.91,3.09 23.66,3.35 23.66,4.13 23.72,4.2 25.38,4.2
INT-SPK-R- on TOP (solid shape): 27.97,10.66 27.97,9.36 27.98,9.36 27.98,9.07 28.04,9.01 28.04,8.96 28.68,8.31 28.74,8.31 28.93,8.12 28.93,7.18 28.85,7.11 28.47,7.11 28.37,7.21 28.37,7.66 28.29,7.75 28.29,7.75 28.29,8.25 28.26,8.28 28.26,8.4 28.22,8.4 28.22,8.44 27.72,8.94 27.72,10.66 27.78,10.73 27.91,10.73
INT-SPK-R- on IN1 (solid shape): 29.12,8 29.12,5.01 27.66,3.55 24.35,3.55 24.29,3.61 24.29,4.19 24.39,4.29 27.4,4.29 28.1,4.99 28.1,5.01 28.23,5.14 28.23,8.12 28.36,8.25 28.86,8.25
JACK_PLUG_DET on TOP (solid shape): 10.05,19.5 10.05,18.42 10.83,17.65 10.83,17.14 10.58,16.89 9.18,16.89 8.92,17.14 8.92,17.97 9.4,18.44 9.4,19.46 9.5,19.55 10,19.55
JACK_SENSE# on TOP (solid shape): 12.8,19.62 12.8,18.54 13.5,17.84 13.5,17.08 13.31,16.89 12.1,16.89 11.78,17.2 11.78,19.36 12.1,19.68 12.73,19.68
LG1_APU on TOP (solid shape): 157.69,72.82 157.69,71.9 157.47,71.69 156.59,71.69 156.32,71.96 156.32,72.2 156.31,72.2 156.31,72.4 156.31,72.87 156.43,72.98 157.53,72.98
LG1_APU on TOP (solid shape): 154.11,85.34 154.1,85.33 154.1,84.37 154.17,84.3 154.17,84.02 154.28,83.91 154.28,82.84 154.16,82.72 153.88,82.72 153.87,82.72 153.8,82.8 153.8,82.82 153.8,82.92 153.78,83.02 153.78,83.02 153.78,83.26 153.82,83.3 153.82,83.76 153.93,83.87 153.93,84.29 153.85,84.36 153.85,85.33 153.92,85.4 154.05,85.4
LG1_APU on BOTTOM (solid shape): 157.82,69.19 157.82,68.2 157.71,68.08 157.27,68.08 157.21,68.02 156.67,68.02 156.56,68.13 156.56,69.03 156.63,69.09 157.13,69.09 157.32,69.28 157.73,69.28
