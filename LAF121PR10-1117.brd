# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AGPIO8: length 23
  TOP w0.089: v1(150.42,61.57) 149.55,61.57 RC57.2 RC56.2
  IN2 w0.089: v1(150.42,61.57) 148.88,63.11 145.47,63.11 144.83,62.47 143.56,62.47 143.36,62.26 141.16,62.26 140.58,62.84 140.07,62.84 139.63,62.39 139.63,61.82 139.82,61.62 139.82,60.92 138.72,59.81 133.59,59.81 v1(133.55,59.77)
  BOTTOM w0.089: UC1.AP6 133.93,60.15 v1(133.55,59.77)
AGPIO25: length 19.7
  BOTTOM w0.089: RC661.1 131.75,43.02 130.98,42.26 130.98,41.55 130.55,41.12 128.57,41.12 128.28,41.41 128.28,42.81 129.46,43.99 129.46,46.11 129.83,46.48 v3(129.83,49.12) 129.83,49.71 130.27,50.16 130.27,51.58 130.06,51.79 130.06,53.72 129.95,53.84 129.95,54.22 130.02,54.29 130.02,54.54 129.73,54.83 UC1.BA11
ALERT#: length 4.8
  BOTTOM w0.089: U8.6 178.09,64.43 178.09,64.3 177.17,63.38 176.55,63.38 R33.2 176.05,63.87 v3(175.34,63.17)
APU_ALERT#: length 14.5
  TOP w0.089: RPC3.2 126.34,93.74 126.66,93.43 v1(126.66,93.07)
  IN2 w0.089: v1(126.66,93.07) 126.66,93.02 127.41,92.27 127.41,91.36 128.28,90.49 128.28,88.78 126.72,87.21 126.72,85.09 126.27,84.64 126.27,82.42 126.58,82.11 v1(126.73,82.11)
  BOTTOM w0.1: UC1.J15 126.33,81.71 v1(126.73,82.11)
APU_DBREQ#: length 139.9
  TOP w0.089: CH3.1 223.8,67.5 RH25.2 224.03,67.56 224.46,67.13 224.7,67.13 v1(224.91,66.92) 224.95,66.89 224.95,65.82 224.37,65.24 RPH1.4
  IN2 w0.089: v1(139.66,54.76) 141.92,52.5 141.92,45.92 142.64,45.2 142.64,44.94 149.35,38.23 151.17,38.23 153.56,35.83 161.74,35.83 163.78,33.8 167.51,33.8 167.61,33.89 169.55,33.89 170.34,33.11 175.15,33.11 177.99,35.94 179.72,35.94 180.44,35.22 187.22,35.22 188.67,36.67 190.32,36.67 190.66,37 191.58,37 191.96,36.62 193.22,36.62 195.49,34.35 198.9,34.35 199.52,34.97 201.29,34.97 201.44,34.82 203.61,34.82 204.07,34.36 207.07,34.36 207.28,34.57 211.19,34.57 211.84,35.22 214.78,35.22 216.04,36.48 216.04,42.05 216.29,42.3 216.29,42.83 218.49,45.02 220.28,45.02 220.87,45.62 220.87,49.88 219.88,50.87 219.88,54.49 222.5,57.1 222.5,59.23 223.04,59.78 223.04,60.09 222.16,60.98 222.16,63.48 224.91,66.24 v1(224.91,66.92)
  BOTTOM w0.089: UC1.AW3 135.75,56.33 138.09,56.33 v1(139.66,54.76)
APU_DBREQ#_R: length 1.1
  TOP w0.089: T125.1 RH25.1
APU_DP1_CTRL_CLK: length 159.8
  IN1 w0.119: v1(14.07,110.31) 14.07,108.79 14.75,108.11 18.02,108.11 18.2,107.93 20.5,107.93 22.83,110.27 22.83,110.84 24.93,112.94 29.76,112.94 33.27,109.43 54.88,109.43 60.99,115.54 64.07,115.54 64.69,114.92 66.36,114.92 66.77,115.32 70.65,115.32 71.05,114.93 76.66,114.93 77.57,114.02 80.45,114.02 80.64,114.21 83.96,114.21 84.7,113.47 85.27,112.89 95.52,112.89 96.24,112.17 96.91,112.17 97.06,112.31 97.06,112.4 v1(96.84,112.62)
  IN3 w0.099: v1(130.73,83.61) 130.72,83.61 130.1,84.23 130.1,84.59 130.61,85.1 130.61,85.6 130.33,85.88 130.3,85.88 130.26,85.92 130.23,85.92 130.05,86.1
  IN3 w0.135: 130.05,86.1 129.47,86.67 129.47,89.02 130.2,89.74 130.2,90.25 130.45,90.51 130.45,93.71 129.81,94.35 129.81,107.76 128.83,108.75 127.48,108.75 125.74,107.01 120.64,107.01 119.21,105.57 106.78,105.57 100.69,111.67 97.3,111.67 96.95,112.02 96.95,112.51 v1(96.84,112.62)
  BOTTOM w0.1: 130.53,83.61 v1(130.73,83.61)
  BOTTOM w0.102: UC1.G11 130.53,83.61
  BOTTOM w0.112: RPI3.1 13.67,110.88 14.08,110.47 14.08,110.31 v1(14.07,110.31) 14.07,109.79 13.96,109.67 QI3.1
APU_DP1_CTRL_DATA: length 162.6
  IN1 w0.119: v1(97.42,112.62) 97.28,112.47 97.28,112.22 97.01,111.95 96.15,111.95 95.43,112.67 85.18,112.67 84.61,113.25 83.87,113.99 80.73,113.99 80.54,113.8 77.48,113.8 76.57,114.71 70.95,114.71 70.56,115.1 66.86,115.1 66.45,114.7 64.6,114.7 63.98,115.32 61.08,115.32 54.97,109.21 33.18,109.21 29.67,112.72 25.02,112.72 23.05,110.75 23.05,110.18 20.59,107.71 18.11,107.71 17.93,107.89 14.66,107.89 14.32,108.24 13.08,108.24 12.8,107.96 v1(12.42,107.96) 12.42,108.06 13.59,109.23 13.59,110.38 v1(13.51,110.46)
  IN3 w0.099: v1(130.73,84.31) 130.59,84.16 130.45,84.16 130.3,84.31 130.3,84.51 130.81,85.02 130.81,85.68 130.39,86.1
  IN3 w0.135: v1(97.42,112.62) 97.2,112.39 97.2,112.12 97.4,111.91 100.79,111.91 106.88,105.81 119.11,105.81 120.54,107.25 125.64,107.25 127.38,108.99 128.93,108.99 130.05,107.86 130.05,94.45 130.69,93.81 130.69,90.41 130.44,90.15 130.44,89.64 129.71,88.92 129.71,86.77 130.39,86.1
  BOTTOM w0.102: UC1.F11 130.51,84.01 130.73,84.23 v1(130.73,84.31)
  BOTTOM w0.112: v1(12.42,107.96) 12,108.37 QI3.4 ; RPI3.2 13.17,110.79 v1(13.51,110.46)
APU_DP1_HPD: length 143.5
  TOP w0.089: RI17.1 v1(24.95,113.76) 25.89,114.7 QI2.3
  IN2 w0.089: v1(128.73,83.61) 129.13,84 129.13,84.7 129.4,84.98 129.4,88.54 130.33,89.46 130.33,91.54 130.51,91.73 130.51,104.31 129.97,104.85 128.48,104.85 128.27,104.65 125.14,104.65 124.39,105.4 119.19,105.4 119.05,105.27 105.58,105.27 105.43,105.27 100.68,110.02 91.24,110.02 89.31,111.95 83.32,111.95 82.59,111.22 76.66,111.22 75.58,112.3 74.32,112.3 72.82,110.8 65.81,110.8 65.26,111.35 63.82,111.35 62.88,112.3 61,112.3 59.51,110.81 53.29,110.81 48.83,106.35 v1(48.52,106.35)
  IN3 w0.089: v1(48.52,106.35) 48.1,106.77 48.1,111.15 46.17,113.08 25.62,113.08 v1(24.95,113.76)
  BOTTOM w0.1: UC1.G13 128.43,83.31 v1(128.73,83.61)
APU_DP1_N0: length 146.8
  TOP w0.112: v1(20.22,90.2) 20.12,90.1 19.8,90.1 CI8.2
  IN1 w0.119: v1(135.22,85.28) 134.97,85.28 134.77,85.48 133.75,85.48 131.8,87.43 131.8,90.21 131.23,90.78 130.56,90.78 129.61,91.72 129.61,91.8 127.43,93.99 120.58,93.99 117.21,97.36 117.21,101.54 116.68,102.86 116.63,102.98 116.55,103.08 116.28,103.36 116.28,103.36 114.87,104.76 106.52,104.76 102.05,109.23 101.29,109.99 98.44,109.99 98.05,109.6 84.43,109.6 83.64,110.39 83.4,110.39 83.21,110.59 82.61,111.18 76.77,111.18 75.6,112.35 74.5,112.35 73.08,110.93 68.59,110.93 67.18,112.35 61.8,112.35 59.94,110.49 59.57,110.49 50.97,101.89 43.8,101.89 42.02,100.11 35.42,100.11 33.6,98.29 33.6,92.79 31.99,91.18 27,91.18 26.49,91.69 23.94,91.69 23.44,91.19 23.44,90.8 22.71,90.07 20.35,90.07 v1(20.22,90.2)
  BOTTOM w0.102: v1(135.22,85.28) 135.09,85.41 UC1.D5
APU_DP1_N1: length 145.1
  TOP w0.112: CI6.2 22.16,92.12 22.38,92.12 v1(22.62,92.36)
  IN1 w0.119: v1(22.62,92.36) 22.85,92.12 23.17,92.12 23.93,92.89 26.2,92.89 27.26,91.82 31.36,91.82 32.95,93.42 32.95,98.62 35.09,100.75 41.47,100.75 43.99,103.27 51.45,103.27 59.38,111.2 59.64,111.2 61.42,112.99 67.44,112.99 68.86,111.57 72.82,111.57 74.23,112.99 75.87,112.99 77.04,111.82 82.88,111.82 83.67,111.03 83.9,111.03 84.7,110.24 97.78,110.24 98.17,110.63 101.56,110.63 106.78,105.41 115.18,105.41 116.92,103.66 117.2,103.3 117.85,101.67 117.85,99.36 122.4,94.82 127.93,94.82 130.1,92.64 130.27,92.64 132.8,90.12 132.8,87.34 133.97,86.17 135.75,86.17 136.13,85.79 136.49,85.79 136.76,85.53 136.92,85.53 v1(137.09,85.69)
  BOTTOM w0.089: v1(137.09,85.69) 137.08,85.71 UC1.C1
APU_DP1_N2: length 152.6
  TOP w0.112: CI4.2 21.99,96.03 v1(22.7,96.03)
  IN1 w0.102: 56.17,109.81 56.53,110.17
  IN1 w0.119: v1(22.7,96.03) 23.34,96.03 23.61,95.77 23.61,94.71 24.03,94.28 26.62,94.28 27.8,93.11 28.14,93.11 28.56,93.53 31.25,93.53 31.67,93.95 31.67,99.18 34.53,102.04 40.43,102.04 44.32,105.93 52.29,105.93 56.17,109.81 ; 56.53,110.17 61.25,114.9 63.76,114.9 64.39,114.27 66.79,114.27 67.2,114.68 70.38,114.68 71.44,113.62 73.04,113.62 73.7,114.29 76.39,114.29 77.34,113.33 80.88,113.33 81.12,113.57 83.69,113.57 84.6,112.66 85.01,112.25 95.07,112.25 95.79,111.52 97.25,111.52 97.64,111.92 102.09,111.92 107.32,106.69 115.78,106.69 118.3,104.18 119.84,100.32 122.91,97.26 128.14,97.26 134.18,91.21 134.18,88.51 135.23,87.46 137.46,87.46 138.42,86.49 138.42,84.55 138.02,84.14 138.02,83.97 v1(138.12,83.86)
  BOTTOM w0.102: UC1.E4 135.53,84.81 135.56,84.84 135.95,84.84 136.28,84.51 137.02,84.51 137.08,84.58 137.74,84.58 137.98,84.33 137.98,84 v1(138.12,83.86)
APU_DP1_N3: length 152.6
  TOP w0.112: CI1.2 19.48,94.24 19.79,93.93 19.94,93.93 20.19,94.18 v1(20.19,94.19)
  IN1 w0.102: 56.17,108.9 57.44,110.17
  IN1 w0.119: v1(137.61,83.2) 137.24,83.2 136.98,83.46 136.98,84.01 137.74,84.77 137.74,86.2 137.13,86.81 134.44,86.81 134.16,87.09 134.16,87.48 133.44,88.2 133.44,90.39 130.65,93.18 130.65,93.58 128.77,95.46 123.07,95.46 122.27,96.26 119.67,98.86 117.69,103.8 115.44,106.05 107.05,106.05 101.82,111.28 97.91,111.28 97.51,110.88 95.53,110.88 94.8,111.61 84.74,111.61 84.54,111.81 83.89,112.46 77.3,112.46 76.14,113.63 73.96,113.63 72.55,112.22 69.9,112.22 69.27,112.85 69.18,112.94 68.4,112.94 67.71,113.63 61.16,113.63 59.45,111.92 59.19,111.92 57.44,110.17 ; 56.17,108.9 52.56,105.29 45.1,105.29 41.21,101.4 34.82,101.4 32.31,98.89 32.31,93.69 31.52,92.89 28.98,92.89 28.56,92.47 27.53,92.47 26.36,93.64 21.82,93.64 21.64,93.83 20.55,93.83 20.19,94.19 v1(20.19,94.19)
  BOTTOM w0.102: v1(137.61,83.2) 137.57,83.16 137.33,83.16 137.13,83.35 137.13,83.41 136.74,83.8 136.14,83.8 UC1.F2
APU_DP1_P0: length 146.9
  TOP w0.112: v1(20.22,89.62) 19.96,89.88 19.83,89.88 CI9.2
  IN1 w0.119: v1(134.74,84.81) 134.85,84.92 134.85,85.09 134.68,85.26 133.66,85.26 131.58,87.34 131.58,90.12 131.14,90.56 130.46,90.56 129.4,91.63 129.4,91.71 127.34,93.77 120.49,93.77 116.99,97.27 116.99,101.5 116.48,102.78 116.44,102.87 116.39,102.94 116.1,103.23 114.78,104.54 106.43,104.54 101.83,109.14 101.59,109.38 101.59,109.38 101.2,109.77 98.53,109.77 98.14,109.38 84.34,109.38 83.55,110.17 83.31,110.17 83.11,110.37 82.52,110.96 76.68,110.96 75.51,112.13 74.59,112.13 73.17,110.71 68.5,110.71 67.09,112.13 61.89,112.13 60.03,110.27 59.66,110.27 51.06,101.67 43.89,101.67 42.11,99.89 35.51,99.89 33.81,98.2 33.81,92.7 32.08,90.96 26.91,90.96 26.4,91.47 24.03,91.47 23.66,91.1 23.66,90.71 22.8,89.85 20.45,89.85 v1(20.22,89.62)
  BOTTOM w0.089: UC1.E6 v1(134.74,84.81)
APU_DP1_P1: length 145.2
  TOP w0.112: CI7.2 22.16,91.9 22.49,91.9 v1(22.62,91.77)
  IN1 w0.119: v1(22.62,91.77) 22.75,91.91 23.26,91.91 24.02,92.67 26.11,92.67 27.17,91.61 31.45,91.61 33.17,93.33 33.17,98.53 35.18,100.54 41.57,100.54 44.09,103.06 51.54,103.06 59.47,110.99 59.73,110.99 61.51,112.77 67.35,112.77 68.77,111.36 72.91,111.36 74.32,112.77 75.78,112.77 76.95,111.6 82.79,111.6 83.58,110.81 83.81,110.81 84.61,110.02 97.87,110.02 98.26,110.41 101.47,110.41 106.69,105.19 115.09,105.19 116.75,103.52 117.01,103.19 117.63,101.62 117.63,99.27 122.31,94.6 127.84,94.6 130.01,92.42 130.18,92.42 132.58,90.03 132.58,87.25 133.88,85.95 135.65,85.95 136.04,85.57 136.4,85.57 136.67,85.31 136.87,85.31 v1(137.08,85.09)
  BOTTOM w0.089: UC1.E1 136.86,85.14 137.04,85.14 v1(137.08,85.09)
APU_DP1_P2: length 152.7
  TOP w0.112: v1(22.7,95.45) 22.7,95.45 22.34,95.81 22.25,95.81 21.83,95.39 CI5.2
  IN1 w0.102: 56.17,109.5 56.33,109.67 56.33,109.68 56.38,109.72 56.38,109.74 56.6,109.96 56.61,109.96 56.66,110 56.67,110 56.84,110.17
  IN1 w0.119: v1(137.54,83.86) 137.8,84.12 137.8,84.23 138.2,84.64 138.2,86.4 137.37,87.24 135.14,87.24 133.96,88.42 133.96,91.12 128.05,97.04 122.82,97.04 119.66,100.2 118.11,104.05 115.69,106.47 107.23,106.47 102,111.7 97.73,111.7 97.34,111.31 95.7,111.31 94.98,112.03 84.92,112.03 84.51,112.44 83.6,113.35 81.21,113.35 80.97,113.11 77.25,113.11 76.3,114.07 73.8,114.07 73.14,113.41 71.35,113.41 70.29,114.46 67.29,114.46 66.88,114.06 64.3,114.06 63.67,114.68 61.35,114.68 56.84,110.17 ; v1(22.7,95.45) 22.7,95.45 23.07,95.81 23.25,95.81 23.39,95.68 23.39,94.62 23.94,94.07 26.53,94.07 27.71,92.89 28.23,92.89 28.66,93.32 31.34,93.32 31.89,93.86 31.89,99.08 34.62,101.82 40.52,101.82 44.41,105.72 52.38,105.72 56.17,109.5
  BOTTOM w0.102: UC1.F3 135.69,84.31 135.58,84.41 135.58,84.55 135.67,84.64 135.87,84.64 136.2,84.31 137.1,84.31 137.16,84.37 137.66,84.37 137.78,84.25 137.78,84.11 v1(137.54,83.86)
APU_DP1_P3: length 152.7
  TOP w0.112: v1(20.19,93.61) 20.08,93.71 19.72,93.71 CI2.2
  IN1 w0.102: 56.17,108.59 56.33,108.76 56.33,108.77 56.38,108.81 56.38,108.83 57.51,109.96 57.52,109.96 57.57,110 57.58,110 57.74,110.17
  IN1 w0.119: 56.17,108.59 52.65,105.07 45.19,105.07 41.3,101.18 34.91,101.18 32.53,98.8 32.53,93.59 31.61,92.67 29.08,92.67 28.65,92.25 27.44,92.25 26.27,93.42 21.73,93.42 21.55,93.61 v1(20.19,93.61) ; v1(137.2,82.78) 137.2,82.93 136.76,83.37 136.76,84.1 137.52,84.86 137.52,86.11 137.04,86.59 134.35,86.59 133.95,87 133.95,87.39 133.22,88.11 133.22,90.29 130.43,93.09 130.43,93.49 128.68,95.24 122.98,95.24 119.48,98.74 117.5,103.68 115.35,105.83 106.96,105.83 101.73,111.06 98,111.06 97.6,110.66 95.44,110.66 94.71,111.39 84.65,111.39 84.45,111.59 84.45,111.59 83.79,112.24 77.21,112.24 76.04,113.41 74.06,113.41 72.64,112 69.81,112 69.09,112.72 68.31,112.72 67.62,113.41 61.25,113.41 59.54,111.7 59.28,111.7 57.74,110.17
  BOTTOM w0.102: UC1.F4 136.02,83.51 136.19,83.51 136.38,83.6 136.65,83.6 136.93,83.32 136.93,83.27 137.2,83 v1(137.2,82.78)
APU_DP2_AUXN: length 133.1
  TOP w0.112: v1(213.78,33.67) 213.98,33.88 214.17,33.88 214.36,34.07 215.06,34.07 C305.1
  IN3 w0.099: 136.14,74.85 135.96,75.03 135.96,75.06 135.93,75.1 135.93,75.12 134.82,76.23 131.06,76.23 130.74,76.55 130.74,77.41 130.85,77.51 130.85,78.05 130.75,78.15 130.16,78.15 129.93,78.38 129.93,79.04 129.83,79.14 129.28,79.14 128.96,79.47 128.96,80.08 129.21,80.33 129.21,80.96 129.1,81.08 129.1,81.78 129.34,82.02 129.52,82.02 v1(129.7,82.2)
  IN3 w0.135: 136.14,74.85 137.47,73.52 137.47,72.03 137.38,71.94 137.38,69.6 137.46,69.52 137.46,67.96 138.74,66.67 140.29,66.67 141.29,65.68 141.29,61.28 141.78,60.79 141.78,60.27 141.28,59.77 141.28,57.16 140.87,56.75 140.87,45.23 149.8,36.3 151.81,36.3 152.64,35.47 161.93,35.47 164.97,32.43 164.97,31.7 166.13,30.55 175.12,30.55 176.23,29.44 179.1,29.44 180.94,31.28 187.8,31.28 189.29,32.77 189.83,32.77 190.74,31.86 197.9,31.86 198.65,32.61 202.94,32.61 203.26,32.93 204.47,32.93 204.76,32.63 206.47,32.63 207.51,31.59 211.02,31.59 213.22,33.79 213.67,33.79 v1(213.78,33.67)
  BOTTOM w0.102: v1(129.7,82.2) 129.69,82.2 129.38,82.51 UC1.H12
APU_DP2_AUXN_C: length 2.1
  TOP w0.112: C305.2 216.2,33.98 216.42,34.2 216.61,34.2 216.87,34.45 216.87,34.68 217,34.81 217.13,34.81 217.18,34.75 JCRT.9
APU_DP2_AUXP: length 133
  TOP w0.112: C304.1 214.85,34.29 214.27,34.29 214.08,34.1 213.94,34.1 v1(213.78,34.26)
  IN3 w0.099: 136.14,75.19 134.9,76.43 131.15,76.43 130.94,76.63 130.94,77.33 131.05,77.43 131.05,78.13 130.83,78.35 130.25,78.35 130.13,78.46 130.13,79.12 129.92,79.34 129.37,79.34 129.15,79.55 129.15,79.99 129.41,80.25 129.41,81.05 129.29,81.16 129.29,81.7 129.42,81.82 129.78,81.82 129.88,81.72 129.88,81.58 v1(129.7,81.4)
  IN3 w0.135: v1(213.78,34.26) 213.55,34.03 213.12,34.03 210.92,31.83 207.61,31.83 206.57,32.88 204.86,32.88 204.57,33.17 203.16,33.17 202.84,32.85 198.55,32.85 197.8,32.1 190.84,32.1 189.93,33.01 189.19,33.01 187.7,31.53 180.84,31.53 179,29.68 176.33,29.68 175.22,30.79 166.23,30.79 165.21,31.8 165.21,32.53 162.03,35.71 152.74,35.71 151.91,36.54 149.9,36.54 141.11,45.33 141.11,56.65 141.52,57.06 141.52,59.67 142.02,60.17 142.02,60.89 141.53,61.38 141.53,65.78 140.39,66.91 138.85,66.91 137.7,68.06 137.7,69.62 137.62,69.7 137.62,71.84 137.71,71.93 137.71,73.62 136.14,75.19
  BOTTOM w0.102: UC1.J12 129.38,81.71 129.69,81.4 v1(129.7,81.4)
APU_DP2_AUXP_C: length 2.1
  TOP w0.112: C304.2 216.2,34.6 216.39,34.42 216.52,34.42 216.65,34.54 216.65,34.77 216.92,35.04 217.04,35.04 217.25,35.25 JCRT.8
APU_DP2_HPD: length 164.4
  TOP w0.089: v1(162.26,38.46) 162.26,37.79 161.4,36.92 161.4,32.8 162.8,31.4 165.65,31.4 165.74,31.31 165.74,29.5 166.63,28.61 v1(166.63,27.39) ; v1(148.53,93.19) 147.87,92.53 147.59,92.53 141.71,86.65 135.96,86.65 135.58,86.27 v3(133.96,86.27) 130.18,86.27 129.63,85.71 ; RP5.1 216.18,32.81 v1(216.71,32.28) 217.18,32.75 JCRT.13
  TOP w0.099: 129.63,85.71 129.14,85.23 129.14,82.53 128.71,82.1 v1(128.71,81.28)
  IN1 w0.089: v1(148.53,93.19) 148.53,93.07 147.54,92.08 147.54,87.78 148.91,86.41 148.91,83.4 149.09,83.22 149.09,81.57 149.45,81.21 150.14,81.21 151.13,80.22 151.13,78.18 152.94,76.37 152.94,69.08 152.75,68.89 152.75,52.88 151.14,51.27 151.14,49.56 150.81,49.22 150.81,44.15 152.69,42.28 152.69,41.64 153.85,40.48 154.3,40.03 154.51,40.03 154.88,39.67 156.14,39.67 156.45,39.37 161.36,39.37 v1(162.26,38.46)
  IN2 w0.089: v1(166.63,27.39) 166.95,27.07 174.5,27.07 175.1,27.68 175.93,27.68 176.37,28.13 180.25,28.13 182.09,29.97 187.63,29.97 187.74,29.86 210.98,29.86 212.43,31.31 214.09,31.31 214.6,31.81 215.45,31.81 215.91,32.28 v1(216.71,32.28)
  BOTTOM w0.102: v1(128.71,81.28) 128.6,81.28 UC1.K13
APU_DP2_N0: length 120.7
  TOP w0.112: v1(214.67,37.26) 214.67,37.53 214.79,37.65 215.04,37.65 C301.1
  IN3 w0.135: v1(214.67,37.26) 214.67,37.82 214.39,38.1 211.61,38.1 211.33,37.82 210.57,37.82 208.57,35.81 208.57,35.81 207.82,35.06 202.82,35.06 202.57,35.3 199.83,35.3 198.95,34.42 193.01,34.42 192.49,34.95 191.83,34.95 191.61,34.73 190.97,34.73 190.33,35.37 189.21,35.37 187.31,33.46 185.1,33.46 184.82,33.18 184.45,33.18 184.17,33.46 183.2,33.46 182.75,33.02 180.37,33.02 178.42,31.06 176.88,31.06 174.99,32.95 172.44,32.95 172.14,32.66 170.34,32.66 169.58,33.42 167.61,33.42 166.86,34.17 165.63,34.17 162.73,37.08 155.07,37.08 154.24,37.9 150.46,37.9 142.47,45.9 142.47,56.02 142.92,56.47 142.92,59.11 143.39,59.58 143.39,60.42 143.87,60.9 143.87,65.37 143.7,65.54 143.7,69.91 141.42,72.18 141.42,72.6 140.66,73.36 139.86,73.36 v1(139.84,73.39)
  BOTTOM w0.102: UC1.AB4 135.34,70.83 135.95,71.05 136.08,71.1 136.18,71.1 136.42,71.01 137.06,71.01 138.2,72.15 138.43,72.15 138.99,72.72 138.99,73.16 139.22,73.39 v1(139.84,73.39)
APU_DP2_N0_C: length 1.7
  TOP w0.112: JCRT.3 217.1,37.75 216.98,37.87 216.86,37.87 216.65,37.67 216.44,37.67 216.2,37.44 C301.2
APU_DP2_N1: length 119.6
  TOP w0.112: C303.1 215.03,35.88 214.77,35.88 v1(214.66,35.77)
  IN3 w0.135: v1(214.66,35.77) 214.55,35.89 214.21,35.89 214.1,35.99 212.43,35.99 211.26,34.82 208.96,34.82 208.28,34.14 202.46,34.14 201.66,33.33 197.81,33.33 197.02,32.54 191.76,32.54 191.07,33.23 191.07,33.32 189.94,34.44 189.59,34.44 187.12,31.97 180.66,31.97 178.82,30.12 176.51,30.12 174.81,31.83 172.86,31.83 172.68,31.64 167.96,31.64 166.36,33.25 165.12,33.25 162.21,36.15 154.69,36.15 153.86,36.98 150.08,36.98 141.55,45.51 141.55,56.4 141.96,56.82 141.96,59.49 142.46,59.99 142.46,62.64 142.49,62.67 142.49,64.6 142.36,64.73 142.36,66.11 139.87,68.6 139.87,69.64 140.47,70.24 140.74,70.24 141.18,70.68 141.18,71.01 140.78,71.41 140.57,71.41 140.29,71.68 140.29,72.21 v1(140.18,72.33)
  BOTTOM w0.102: v1(140.18,72.33) 140.18,71.86 140.07,71.76 138.36,71.76 137.2,70.61 136.86,70.61 136.86,70.61 136.5,70.61 135.73,70.31 UC1.AC3
APU_DP2_N1_C: length 1.9
  TOP w0.112: JCRT.6 217.25,36.25 217.16,36.34 217.03,36.34 216.91,36.22 216.91,36.17 216.67,35.93 216.39,35.93 216.2,35.74 C303.2
APU_DP2_P0: length 120.6
  TOP w0.112: v1(214.08,37.26) 214.09,37.26 214.7,37.87 215,37.87 215.29,38.16 C300.1
  IN3 w0.135: v1(139.84,72.8) 139.85,72.8 140.17,73.12 140.56,73.12 141.18,72.5 141.18,72.08 143.46,69.81 143.46,65.44 143.63,65.27 143.63,61 143.14,60.52 143.14,59.68 142.68,59.21 142.68,56.57 142.23,56.12 142.23,45.8 150.36,37.66 154.14,37.66 154.97,36.83 162.63,36.83 165.53,33.93 166.76,33.93 167.51,33.18 169.48,33.18 170.24,32.41 172.24,32.41 172.54,32.71 174.89,32.71 176.78,30.82 178.52,30.82 180.47,32.77 182.85,32.77 183.3,33.22 184.07,33.22 184.35,32.94 184.92,32.94 185.2,33.22 187.41,33.22 189.31,35.12 190.23,35.12 190.87,34.48 191.71,34.48 191.93,34.71 192.39,34.71 192.91,34.18 199.05,34.18 199.93,35.06 202.47,35.06 202.72,34.82 207.92,34.82 208.81,35.71 208.81,35.71 210.67,37.57 211.43,37.57 211.71,37.85 214.29,37.85 214.43,37.72 214.43,37.61 214.08,37.27 v1(214.08,37.26)
  BOTTOM w0.102: UC1.AB2 136.14,70.81 137.14,70.81 138.28,71.95 138.51,71.95 139.2,72.64 139.2,73.08 139.3,73.19 139.52,73.19 139.63,73.08 139.63,72.91 139.73,72.8 v1(139.84,72.8)
APU_DP2_P0_C: length 1.8
  TOP w0.112: JCRT.2 217.18,38.25 217.03,38.1 216.76,38.1 216.56,37.89 216.45,37.89 216.2,38.15 C300.2
APU_DP2_P1: length 119.5
  TOP w0.112: v1(214.66,36.36) 214.66,36.35 214.91,36.1 215.03,36.1 215.29,36.35 C302.1
  IN3 w0.135: v1(214.66,36.36) 214.43,36.13 214.31,36.13 214.2,36.23 212.33,36.23 211.16,35.06 208.86,35.06 208.18,34.38 202.36,34.38 201.56,33.57 197.71,33.57 196.92,32.79 191.86,32.79 191.31,33.33 191.31,33.42 190.04,34.68 189.49,34.68 187.02,32.21 180.56,32.21 178.72,30.36 176.61,30.36 174.91,32.07 172.76,32.07 172.58,31.89 168.06,31.89 166.46,33.49 165.22,33.49 162.31,36.39 154.79,36.39 153.96,37.22 150.18,37.22 141.79,45.61 141.79,56.3 142.2,56.72 142.2,59.39 142.7,59.89 142.7,62.54 142.73,62.57 142.73,64.7 142.6,64.83 142.6,66.21 140.12,68.7 140.12,69.54 140.57,70 140.84,70 141.42,70.58 141.42,71.11 140.88,71.65 140.67,71.65 140.53,71.78 140.53,72.1 v1(140.76,72.33)
  BOTTOM w0.102: v1(140.76,72.33) 140.76,72.17 140.66,72.07 140.51,72.07 140.38,71.94 140.38,71.78 140.16,71.56 138.44,71.56 137.29,70.4 137.02,70.4 136.92,70.3 136.92,70.2 136.83,70.11 136.63,70.11 136.53,70.21 UC1.AC1
APU_DP2_P1_C: length 2
  TOP w0.112: C302.2 216.2,36.33 216.38,36.15 216.58,36.15 216.69,36.26 216.69,36.31 216.94,36.56 217.13,36.56 217.32,36.75 JCRT.5
APU_DP3_AUXN: length 135
  IN1 w0.089: 121.23,90.92 121.25,90.91 121.25,90.9 123.72,88.43 123.72,87.69 125.08,86.33 130.35,86.33 131.32,85.36 131.32,83.44 131.32,83.28 131.16,83.11 131.16,82.68 131.15,82.68 131.27,82.57 131.39,82.57 v1(131.73,82.91) ; 76.83,110.38 76.84,110.4 76.85,110.4 77.01,110.55 82.35,110.55 83.94,108.97 101.42,108.97 106.26,104.14 114.61,104.14 116.08,102.67 116.08,102.66 116.58,101.42 116.58,96.69 116.59,96.68 ; 72.81,110.25 72.79,110.26 72.78,110.26 72.74,110.3 68.33,110.3 67.32,111.32 64.12,111.32 63.92,111.12 63.92,110.93 v1(63.72,110.73)
  IN1 w0.099: 116.59,96.68 116.59,96.68 119.68,93.59 119.68,92.47 121.23,90.92
  IN1 w0.102: 76.83,110.38 76.31,109.86 73.19,109.86 72.81,110.25
  BOTTOM w0.089: RT133.2 22.31,115.39 26.96,115.39 29.7,112.64 30.19,112.64 32.7,110.14 45.46,110.14 49.06,113.74 51.6,113.74 52.28,113.06 58.93,113.06 59.87,112.11 62.89,112.11 63.91,111.09 63.91,110.92 v1(63.72,110.73)
  BOTTOM w0.1: UC1.H10 131.33,82.51 v1(131.73,82.91)
APU_DP3_AUXP: length 134.8
  IN1 w0.089: 76.97,110.24 76.98,110.25 76.98,110.26 77.09,110.36 82.28,110.36 83.86,108.78 101.34,108.78 106.18,103.95 114.53,103.95 115.92,102.56 116.39,101.38 116.39,96.61 116.45,96.55 116.45,96.54 116.47,96.53 ; v1(130.73,82.09) 130.73,82.18 130.96,82.41 130.96,82.76 130.96,83.19 131.13,83.36 131.13,85.28 130.27,86.14 125,86.14 123.53,87.61 123.53,88.35 121.11,90.77 121.11,90.77 121.09,90.78 ; v1(64.3,110.73) 64.11,110.92 64.11,111.04 64.2,111.13 67.24,111.13 68.25,110.11 72.66,110.11 72.67,110.1
  IN1 w0.099: 116.47,96.53 119.49,93.51 119.49,92.39 121.09,90.78
  IN1 w0.102: 76.97,110.24 76.39,109.66 73.11,109.66 72.67,110.1
  BOTTOM w0.089: v1(64.3,110.73) 64.1,110.92 64.1,111.17 62.97,112.3 59.95,112.3 59.01,113.25 52.36,113.25 51.68,113.93 48.98,113.93 45.38,110.33 32.77,110.33 30.27,112.83 29.78,112.83 27.03,115.58 22.14,115.58 RT132.2
  BOTTOM w0.1: UC1.J10 131.33,81.49 v1(130.73,82.09)
APU_DP3_HPD: length 167.1
  TOP w0.089: v1(48.56,106.93) v3(47.91,106.93) ; RT116.2 17.05,122.04 v1(16.67,121.66) 16.1,121.09 16.1,120.36 16.57,119.88 17.55,119.88 RT2.2
  IN1 w0.089: v1(16.67,121.66) 16.23,121.22 16.23,119.35 16.8,118.78 v1(16.8,118.3)
  IN2 w0.089: v1(131.73,82.12) 131.73,82.25 132.12,82.64 132.12,84.47 129.77,86.82 129.77,87.84 130.73,88.8 130.73,89.24 130.51,89.45 130.51,91.47 130.69,91.65 130.69,104.38 130.04,105.03 128.4,105.03 128.2,104.83 125.22,104.83 124.46,105.59 119.11,105.59 118.98,105.45 105.51,105.45 100.75,110.2 91.31,110.2 89.38,112.13 83.24,112.13 82.51,111.4 76.73,111.4 75.66,112.48 74.24,112.48 72.75,110.98 65.89,110.98 65.34,111.54 63.9,111.54 62.96,112.48 60.92,112.48 59.44,110.99 53.21,110.99 49.16,106.93 v1(48.56,106.93)
  IN3 w0.089: v1(16.8,118.3) 17.22,118.3 18.18,117.33 24.02,117.33 24.14,117.22 27.7,117.22 29.32,118.84 29.79,118.84 30.41,119.46 34.81,119.46 35.14,119.13 v1(35.14,119.06) 35.92,118.27 38.6,118.27 43.61,113.27 46.24,113.27 48.29,111.22 48.29,107.2 v1(48.56,106.93)
  BOTTOM w0.089: v1(35.14,119.06) 35.14,119.11 35.14,119.11 UT1.18 ; 16.85,121.66 v1(16.67,121.66)
  BOTTOM w0.102: v1(131.73,82.12) 131.73,82 UC1.K8 ; UT9.32 16.85,121.66
APU_FCH_POK: length 2.5
  TOP w0.089: UE1.32 49.75,66.17 RC30.1
APU_FCH_PWRGD: length 43
  TOP w0.089: v1(49.48,60.24) 49.66,60.42 v3(49.66,61.02) 49.66,63.81 v1(49.52,63.95) 49.12,64.35 RC30.2 ; RC28.2 46.14,86.52 46.43,86.81 v1(46.56,86.81) ; RC39.2 RC630.1 43.21,64.24 CC9.2 CC8.1 42.67,62.14 CC10.2 43.53,61.27 UC3.2 43.53,60.17 43.64,60.07 43.64,60.07 43.79,59.92 44.21,59.92 44.33,60.04 45.21,60.04 v1(45.41,60.24)
  IN1 w0.089: v1(45.41,60.24) v1(49.48,60.24)
  IN2 w0.089: v1(46.56,86.81) 46.56,86.69 47.06,86.19 47.06,83.35 47.36,83.04 47.36,81.27 46.77,80.69 46.77,77.02 46.24,76.48 46.24,75.58 47.03,74.78 47.03,74.17 47.22,73.99 47.6,73.61 47.6,70.71 47.2,70.31 47.2,68.65 49.33,66.52 49.33,65.13 49.52,64.94 v1(49.52,63.95)
APU_FCH_PWRGD_R: length 153.7
  TOP w0.089: v1(42.14,58.92) 42.59,58.48 42.77,58.48 42.88,58.59 UC3.4 42.88,59.45 42.55,59.78 42.55,62 41.71,62.84 41.71,64.99 42.26,65.54 RC39.1
  TOP w0.099: RC34.2 132.43,46.87 132.43,48.4 RC33.2 v3(132.88,50.45) 132.88,50.5 133.47,51.09 133.47,52.7 134.43,53.67 134.43,55.34 134.32,55.44 134.32,55.85 v1(133.82,56.36)
  IN2 w0.089: v1(133.82,56.36) 133.82,55.87 134.77,54.91 134.77,53.79 136.11,52.45 136.11,51.89 137.04,50.97 137.04,48.21 136.75,47.93 136.75,43.77 134.92,41.94 134.57,41.42 134.18,40.47 134.18,37.59 133.94,37.35 131.06,37.35 129.6,35.89 128.96,35.89 128.26,35.18 127.72,35.18 125.49,32.96 124.92,32.96 123.7,31.74 116.19,31.74 115.72,31.26 109.45,31.26 108.9,30.71 104.08,30.71 103.25,31.54 97.13,31.54 97.02,31.65 80.31,31.65 80.02,31.94 67.97,31.94 67.62,32.29 62.93,32.29 61.42,33.8 61.42,34.03 60.98,34.46 59.48,34.46 53.14,40.81 52.08,40.81 49.85,43.03 49.85,45.37 47.35,47.88 47.35,51.59 45.3,53.63 45.3,54.69 44.36,55.63 44.36,56.7 42.52,58.54 42.52,58.55 v1(42.14,58.92)
  BOTTOM w0.1: v1(133.82,56.36) 133.69,56.49 133.69,57.06 UC1.AV6
APU_PCIE1_RST#_C: length 2.7
  BOTTOM w0.089: v3(112.02,116.73) 111.92,116.63 CC100.2 RC704.1 RC701.1
APU_PCIE1_RST#_R: length 131
  IN2 w0.089: v1(136.88,52.38) 136.88,52.54 135.34,54.07 135.34,57.44 134.44,58.34 132.8,58.34 132.47,58.67 132.47,59.13 132.58,59.24 132.58,59.85 133.62,60.88 133.62,61.01 133.94,61.34 136.05,61.34 136.24,61.53 138.74,61.53 139.26,62.05 139.26,62.55 139.92,63.2 140.74,63.2 141.31,62.63 142.57,62.63 143.05,63.11 144.5,63.11 145.32,63.93 148.59,63.93 150.15,62.38 v1(150.47,62.38)
  IN3 w0.089: v1(108.99,118.23) 108.49,117.74 108.49,112.9 107.86,112.26 107.86,110.53 108.47,109.92 113.77,109.92 114.46,110.61 115.84,110.61 115.98,110.76 117.91,110.76 118.42,111.27 121.14,111.27 121.66,111.79 124.5,111.79 125.98,113.28 126.27,113.28 126.6,113.6 128.11,113.6 128.7,113.01 130.59,113.01 131.4,112.21 133.07,110.53 133.74,110.53 134.71,109.56 134.71,104.32 134.07,103.69 134.07,99 136.57,96.5 136.57,92.76 139.99,89.34 139.99,87.5 142,85.49 142,77.3 142.4,76.89 144.66,76.89 146.64,74.92 146.64,73.07 149.64,70.07 149.64,63.8 149.86,63.58 149.86,63.26 150.4,62.72 150.4,62.38 v1(150.47,62.38)
  BOTTOM w0.089: v1(108.99,118.23) 109.9,118.23 110.14,117.99 RC704.2 ; UC1.BB6 134.66,54.81 135.14,54.33 135.14,53.96 136.44,52.65 136.61,52.65 v1(136.88,52.38)
APU_PCIE1_RST#_U: length 5.8
  BOTTOM w0.089: RC44.1 108.29,120.4 108.5,120.19 108.5,119.53 108.29,119.31 UC4.2 UC4.1 107.67,118.51 RC700.2 RC703.2 RC701.2
APU_PCIE_RST#: length 216.7
  TOP w0.089: v1(26.32,24.33) 26.32,24.41 RS63.1 25.33,25.39 UC21.1 ; RL5.1 26.12,87.7 26.64,87.19 v1(26.69,87.19)
  IN2 w0.089: v1(70.65,118.51) 71.21,118.51 71.79,117.93 73.67,117.93 73.94,118.2 76.68,118.2 77.71,119.23 87.15,119.23 87.8,118.59 88.33,118.06 91.56,118.06 92.03,117.6 100.69,117.6 102.17,116.12 107.36,116.12 109.07,114.41 109.07,112.69 112.18,109.57 114.29,109.57 v1(114.54,109.82)
  IN3 w0.089: v1(70.65,118.51) 69.89,119.27 65.05,119.27 62.86,117.07 61.82,117.07 54.67,109.93 54.67,95.26 49.3,89.89 29.56,89.89 26.85,87.19 v1(26.69,87.19) 27.93,85.95 27.93,82.65 29.73,80.85 29.73,70.17 29.89,70.01 29.89,66.53 30.2,66.23 30.2,63.4 27.84,61.05 27.84,56.78 26.17,55.11 23.29,55.11 21.02,52.84 21.02,47.58 20.67,47.24 20.67,45.38 21.53,44.52 21.53,35.71 25.43,31.8 25.43,25.22 v1(26.32,24.33)
  BOTTOM w0.089: D6.1 118.64,108.5 117.98,107.84 116.39,107.84 116.14,108.1 116.14,109.37 115.79,109.71 114.65,109.71 v1(114.54,109.82) 115.38,110.66 D5.1 115.38,111.49 113.66,113.2 113.66,116.16 112.42,117.41 112.42,118.42 111.45,119.39 RC49.1 110.24,119.39 UC4.4 109.2,120.43 RC44.2 108.75,121.48 UV2.2 ; RW11.1 70.53,117.99 70.65,118.11 v1(70.65,118.51)
APU_PCIE_RST#_C: length 3.6
  BOTTOM w0.089: v3(107.67,115.72) RC700.1 106.84,117.46 RC29.1 106.84,118.85 CC7.1
APU_PCIE_RST#_R: length 251.5
  IN2 w0.089: v1(107.17,114.92) 106.76,115.34 101.35,115.34 100.81,115.88 88.6,115.88 87.7,116.77 87.7,117.17 86.42,118.45 78.04,118.45 77,117.42 74.27,117.42 72.81,115.96 69.42,115.96 67.18,118.2 60.75,118.2 59.89,117.33 57.98,117.33 57.47,116.82 56.88,116.82 56.67,117.03 55.28,117.03 54.64,116.39 50.02,116.39 48.63,115 47.22,115 44.77,112.55 44.77,111.55 43.75,110.54 43.75,88.47 43.62,88.34 43.62,85.97 42.88,85.23 42.88,81.88 43.03,81.74 43.03,79.02 43.27,78.77 43.27,76.15 43.03,75.9 43.03,72.84 43.38,72.49 43.69,72.17 43.69,71.3 43.59,71.2 43.59,70.87 43.3,70.58 43.3,67.96 43.96,67.3 43.96,66.1 42.78,64.93 42.78,63.6 41.38,62.2 41.38,60.99 43.37,59 43.37,58.72 45.19,56.91 46.05,56.91 50.07,52.88 50.07,48.54 55.48,43.13 55.48,41.16 60.65,35.98 62.24,35.98 62.33,35.89 63.42,35.89 64.77,34.53 78.24,34.53 78.69,34.08 80.03,34.08 80.94,33.16 96.81,33.16 97.8,34.15 100.58,34.15 100.95,33.78 103.47,33.78 105.02,32.23 108.27,32.23 108.84,32.79 115.1,32.79 115.57,33.26 116.47,33.26 117.14,33.93 120.54,33.93 120.72,33.74 123.08,33.74 123.75,34.42 125.07,34.42 128.73,38.09 129.29,38.09 133.02,41.82 133.37,42.68 135.08,44.39 135.08,47.05 133.2,48.94 133.2,49.6 v1(134.45,50.85)
  BOTTOM w0.089: v1(107.17,114.92) 107.17,116.3 RC29.2
  BOTTOM w0.102: v1(134.45,50.85) 134.73,51.13 UC1.BD5
APU_PCIE_RST#_SSD: length 7.8
  TOP w0.089: v1(26.96,24.35) 26.96,24.23 v3(26.55,23.82) 25.99,23.82 RS63.2 24.99,24.82 23.54,24.82 22.98,24.26 UC21.4
  BOTTOM w0.089: JSSD1.50 27.13,24.52 v1(26.96,24.35)
APU_PCIE_WAKE#: length 235.9
  TOP w0.089: v1(47.99,52.97) 47.99,53.86 v4(46.33,55.51) 46.07,55.78 46.07,60.92 46.64,61.49 RE37.1 ; RL10.2 21.96,86.79 22.36,86.39 23,86.39 23.47,85.92 v1(23.47,85.9) 23.47,85.5 23.27,85.3 UL1.21
  IN1 w0.089: v1(42.37,81.61) 40.35,83.62 35.34,83.62 35.13,83.42 30.95,83.42 29.44,84.93 27.27,84.93 26.39,85.81 23.56,85.81 v1(23.47,85.9) ; v1(37.73,52.21) 38.49,52.97 v1(47.99,52.97)
  IN2 w0.089: v1(25.95,27.62) 25.95,27.92 26.56,28.53 28.36,28.53 30.31,30.48 30.31,31.59 30.69,31.98 30.69,36.61 31.59,37.51 31.59,38.5 33.68,40.58 35.31,40.58 36.48,41.75 36.48,42.22 36.23,42.48 36.23,45.65 36.65,46.08 36.65,46.87 38.25,48.47 38.25,51.7 v1(37.73,52.21) ; v1(42.37,81.61) 42.66,81.31 42.66,78.86 42.91,78.62 42.91,76.3 42.66,76.06 42.66,72.69 43.33,72.02 43.33,71.45 43.16,71.28 43.16,70.95 42.94,70.73 42.94,69.63 42.55,69.25 42.55,68.22 43.77,67 43.77,66.18 42.6,65.01 42.6,63.68 41.2,62.28 41.2,60.91 43.19,58.92 43.19,58.65 45.11,56.72 45.97,56.72 47.99,54.71 v1(47.99,52.97) 49.13,52.97 49.89,52.21 49.89,48.47 55.29,43.06 55.29,41.08 60.58,35.8 62.16,35.8 62.25,35.7 63.22,35.7 64.58,34.35 78.03,34.35 78.48,33.89 79.95,33.89 80.86,32.98 96.88,32.98 97.87,33.97 100.5,33.97 100.87,33.6 103.39,33.6 104.95,32.04 108.35,32.04 108.91,32.61 115.18,32.61 115.64,33.07 116.55,33.07 117.22,33.74 120.47,33.74 120.65,33.56 123.9,33.56 124.44,34.11 125.01,34.11 128.81,37.9 129.36,37.9 133.27,41.82 133.63,42.68 135.27,44.32 135.27,47.62 134.9,47.99 134.9,50.92 134.74,51.08 134.74,51.93 132.82,53.86 132.31,53.86 131.07,55.1 131.07,56.45 130.73,56.78 130.73,56.86 v1(130.65,56.94)
  BOTTOM w0.089: JSSD1.54 26.13,27.45 v1(25.95,27.62)
  BOTTOM w0.102: UC1.AV11 130.43,57.31 130.65,57.09 v1(130.65,56.94)
APU_PWRGD: length 193.7
  TOP w0.089: DH1.2 222.47,54.62 222.02,55.08 221.26,55.08 v1(221.15,54.97) ; CC6.2 RC27.2 RC15.2 149.61,60.98 v1(150.42,60.98) 150.48,60.98 150.86,61.36 150.86,61.65 150.54,61.97 150.16,61.97 149.86,62.27 149.86,62.82 148.59,64.09 148.59,69.28 148.5,69.38 v4(148.5,69.97) 148.5,71.47 148.86,71.84 148.86,73 149.37,73.5 149.37,74.52 149.52,74.67 149.52,77.43 148.88,78.08 147.16,78.08 144.31,80.93 144.31,88.94 147.6,92.24 147.84,92.24 148.31,92.71 150.29,92.71 151.19,91.8 152.39,91.8 152.55,91.64
  TOP w0.203: 152.55,91.64 152.55,91.09 153.17,90.47 PUZ01.9
  IN2 w0.089: v1(150.42,60.98) 150.41,60.98 149.11,62.28 143.64,62.28 143.44,62.08 141.08,62.08 140.51,62.66 140.15,62.66 139.81,62.32 139.81,61.89 140,61.7 140,59.74 140.55,59.19 140.55,58.57 140.28,58.3 139.24,58.3 138.8,57.85 138.8,56.41 139.34,55.87 v1(139.34,55.84) 138.86,55.36 138.86,54.02 141.43,51.44 141.43,45.8 142.26,44.97 142.26,44.59 148.99,37.86 151.02,37.86 153.57,35.31 160.38,35.31 162.13,33.56 163.25,33.56 163.38,33.43 167.66,33.43 167.76,33.53 168.97,33.53 169.76,32.74 175.31,32.74 178.14,35.57 179.56,35.57 180.29,34.85 187.37,34.85 188.82,36.3 190.48,36.3 190.81,36.63 191.43,36.63 191.77,36.29 191.77,35.75 192.29,35.23 194.09,35.23 195.52,33.8 201.69,33.8 202.13,34.24 203.68,34.24 203.93,33.98 207.21,33.98 207.43,34.2 211.34,34.2 211.98,34.84 214.92,34.84 216.41,36.33 216.41,41.9 216.66,42.15 216.66,42.67 217.53,43.55 220.78,43.55 221.24,44 221.24,50.04 220.99,50.29 220.99,52.15 220.25,52.88 220.25,54.06 v1(221.15,54.97)
  BOTTOM w0.089: UC1.AW2 136.24,56.7 138.21,56.7 139.07,55.84 v1(139.34,55.84)
APU_PWRGD_BUF: length 1.5
  TOP w0.089: DH1.1 222.47,57.73 T123.1
APU_RST#: length 135.7
  TOP w0.089: v1(221.44,55.51) 222.91,55.51 223.41,55.01 223.41,54.97 DH2.2 225.11,54.25 v4(225.52,53.84)
  IN2 w0.089: v1(221.44,55.51) 221.17,55.51 220.07,54.41 220.07,52.81 220.8,52.07 220.8,50.21 221.06,49.96 221.06,45.54 220.35,44.84 218.56,44.84 216.48,42.75 216.48,42.22 216.22,41.97 216.22,36.4 214.86,35.04 211.92,35.04 211.26,34.39 207.35,34.39 207.15,34.18 203.99,34.18 203.54,34.64 201.37,34.64 201.21,34.79 199.6,34.79 198.97,34.16 195.41,34.16 193.14,36.43 191.88,36.43 191.5,36.82 190.73,36.82 190.4,36.49 188.75,36.49 187.29,35.03 180.36,35.03 179.64,35.75 178.06,35.75 175.23,32.92 170.26,32.92 169.47,33.71 167.69,33.71 167.59,33.61 163.46,33.61 163.32,33.74 162.21,33.74 160.36,35.59 153.54,35.59 151.09,38.05 149.18,38.05 142.44,44.78 142.44,45.14 141.66,45.92 141.66,52.17 139.11,54.72 139.11,55.1 139.35,55.34 v1(139.65,55.34)
  BOTTOM w0.089: UC1.AW4 135.71,56.81 136,56.52 138.15,56.52 139.33,55.34 v1(139.65,55.34) 141.54,55.34 142.64,56.45 RC12.2 CC5.2 CC250.2
APU_RST#_BUF: length 1.5
  TOP w0.089: DH2.1 224.13,57.59 T124.1
APU_SCLK0: length 226.8
  TOP w0.112: v1(218.64,32.6) 218.82,32.77 218.82,33.08 218.51,33.38 218.28,33.38 218.15,33.25 JCRT.12 ; RPC64.1 200.52,31.07 200.56,31.03 200.56,30.79 v1(200.35,30.58) ; v1(203.97,30.89) 204.06,30.81 204.21,30.81 204.45,31.05 US4.1
  IN1 w0.119: v1(119.95,43.71) 119.99,43.67 119.99,43.48 119.82,43.32 117.73,43.32 117.66,43.38 116.91,43.38 116.59,43.7 116.55,43.7 116.05,44.19 116.05,44.21 115.32,44.94 110.17,44.94 109.47,44.25 109.26,44.04 109.22,44.04 107.66,42.48 107.03,42.48 105.11,40.56 103.04,40.56 102.48,39.99 76.96,39.99 76.58,39.61 74.18,39.61 74.06,39.73 74.06,39.9 v1(74.19,40.03) 74.02,40.2 74.02,40.62 73.75,40.88 65.87,40.88 64.76,39.77 63.43,39.77 63.08,40.13 v1(63.08,40.37)
  IN3 w0.135: v1(218.64,32.6) 218.8,32.75 218.8,33 218.68,33.11 216.64,33.11 215.05,31.52 211.94,31.52 210.44,30.02 205.2,30.02 204.91,30.31 204.91,30.58 204.76,30.73 204.14,30.73 v1(203.97,30.89) 204.26,31.19 204.83,31.19 204.96,31.32 204.96,31.55 204.82,31.69 203.38,31.69 203.25,31.81 202.35,31.81 201.79,31.26 201.79,30.18 201.51,29.89 200.77,29.89 200.52,30.14 200.52,30.41 v1(200.35,30.58) 200.51,30.74 200.51,30.95 200.36,31.1 199.64,31.1 198.43,29.88 182.01,29.88 179.91,27.78 174.37,27.78 173.05,29.1 156.12,29.1 150.19,35.03 147.99,35.03 146.42,36.61 146.42,36.85 144.59,38.67 142.94,38.67 v1(142.8,38.53)
  BOTTOM w0.1: 120.65,44.15 120.69,44.2 120.69,45.98 120.67,46.01 120.67,46.27 120.69,46.3 120.69,46.61 122.69,48.61 122.69,50.28 122.91,50.5 122.91,51.3 122.59,51.62 122.59,54.27 UC1.BC20
  BOTTOM w0.112: v1(74.19,40.03) 74.01,40.2 74.01,41.07 74.12,41.18 79.77,41.18 80.64,42.06 80.64,44.74 80.4,44.99 JDIMM1.253 ; 120.65,44.15 120.21,43.71 v1(119.95,43.71) 119.95,43.42 119.76,43.23 119.76,42.81 120.34,42.22 121.32,42.22 122.73,40.82 123.26,40.82 124.33,39.74 125.08,39.74 125.32,39.5 125.32,39.1 124.94,38.71 124.94,35.72 127.39,33.27 129.06,33.27 129.98,32.35 136.41,32.35 141.88,37.83 141.88,38.64 141.99,38.75 142.58,38.75 v1(142.8,38.53) ; JDIMM2.253 67.31,44.99 67.94,44.36 67.94,42.44 66.86,41.36 61.62,41.36 61.51,41.25 61.51,41.14 61.62,41.03 62.58,41.03 62.83,40.78 62.83,40.62 v1(63.08,40.37)
APU_SDATA0: length 229.4
  TOP w0.112: v1(200.94,30.58) 200.8,30.71 200.8,30.94 201.02,31.15 RPC64.2 ; v1(219.23,32.6) 219.06,32.77 219.06,33.17 218.61,33.62 218.29,33.62 218.16,33.75 JCRT.11 ; v1(206.42,30.84) 206.41,30.83 206.18,30.83 205.95,31.06 US4.4
  IN1 w0.119: v1(120.36,43.3) 120.15,43.3 119.92,43.07 117.63,43.07 117.56,43.13 116.8,43.13 115.83,44.1 115.83,44.12 115.23,44.72 110.26,44.72 107.76,42.23 107.13,42.23 105.21,40.31 103.15,40.31 102.58,39.75 77.06,39.75 76.68,39.37 74.08,39.37 73.81,39.63 73.81,39.82 v1(73.6,40.03) 73.77,40.2 73.77,40.52 73.65,40.64 65.97,40.64 64.86,39.53 63.33,39.53 62.49,40.37 v1(62.49,40.37)
  IN3 w0.135: v1(219.23,32.6) 219.06,32.77 219.06,33.1 218.79,33.37 216.53,33.37 214.94,31.78 211.83,31.78 210.33,30.28 205.31,30.28 205.17,30.42 205.17,30.61 205.28,30.72 206.29,30.72 v1(206.42,30.84) 206.18,31.08 205.36,31.08 205.22,31.21 205.22,31.21 205.22,31.66 204.93,31.95 203.49,31.95 203.36,32.08 202.24,32.08 201.53,31.36 201.53,30.29 201.4,30.15 200.88,30.15 200.78,30.25 200.78,30.39 200.94,30.54 v1(200.94,30.58) 200.77,30.74 200.77,31.06 200.47,31.36 199.53,31.36 198.32,30.14 181.91,30.14 179.8,28.04 174.48,28.04 173.16,29.36 156.23,29.36 150.3,35.29 148.1,35.29 146.68,36.71 146.68,36.96 144.7,38.93 142.99,38.93 v1(142.8,39.12)
  BOTTOM w0.1: 120.82,43.98 120.92,44.09 120.92,46.07 120.89,46.1 120.89,46.53 122.89,48.53 122.89,50.2 123.11,50.41 123.11,51.39 123.02,51.48 123.01,51.48 122.79,51.7 122.79,53.99 123.03,54.23 123.03,54.28 123.03,54.28 123.03,54.53 122.73,54.83 UC1.BA20
  BOTTOM w0.112: v1(62.49,40.37) 62.59,40.47 62.59,40.68 62.48,40.79 61.53,40.79 61.27,41.04 61.27,41.27 61.16,41.38 56.57,41.38 55.09,42.87 55.09,44.17 55.66,44.74 JDIMM2.254 ; 120.82,43.98 120.36,43.53 v1(120.36,43.3) 120.16,43.3 120,43.13 120,42.91 120.44,42.46 121.42,42.46 122.83,41.06 123.36,41.06 124.43,39.98 125.18,39.98 125.56,39.6 125.56,39 125.18,38.61 125.18,35.82 127.49,33.51 129.16,33.51 130.08,32.59 136.31,32.59 141.64,37.93 141.64,38.74 141.89,38.99 142.68,38.99 v1(142.8,39.12) ; JDIMM1.254 68.91,44.74 68.36,44.19 68.36,42.61 69.72,41.25 73.57,41.25 73.57,41.24 73.77,40.99 73.77,40.2 v1(73.6,40.03)
APU_SIC: length 20.2
  TOP w0.089: v1(127.24,93.09) 126.84,93.49 RPC3.3 ; RC616.2 127.86,88.2 128.23,87.84 v3(128.23,86.75) 128.23,86.53 127.41,85.71
  TOP w0.099: v1(127.73,82.91) 127.32,83.32 127.32,85.62 127.41,85.71
  IN2 w0.089: v1(127.24,93.09) 127.63,92.71 128.24,92.71 129.39,91.55 129.39,89.05 129.04,88.69 129.04,87.63 127.86,86.45 127.86,84.83 128.17,84.52 128.17,83.35 v1(127.73,82.91)
  BOTTOM w0.1: UC1.H14 127.33,82.51 v1(127.73,82.91)
APU_SID: length 23
  TOP w0.089: RPC3.1 125.84,93.62 v1(126.13,93.33) ; RC617.2 126.95,88.16 v3(126.95,86.99) 126.95,86.25 127.03,86.16 127.03,85.71
  TOP w0.099: 127.03,85.71 127.03,85.23 127.12,85.15 127.12,82.61 v1(127.61,82.11)
  IN2 w0.089: v1(127.61,82.11) 128.36,82.86 128.36,84.63 129.22,85.49 129.22,88.61 130.14,89.54 130.14,91.18 127.86,93.47 126.27,93.47 v1(126.13,93.33)
  BOTTOM w0.1: v1(127.61,82.11) 127.61,82.09 UC1.J14
APU_SPI_CLK: length 32.1
  IN1 w0.099: 124.42,45.37 124.09,45.04 124.09,44.52 124.42,44.19 ; 124.15,43.54 124.15,43.57 124.42,43.84 124.42,43.85
  IN1 w0.119: 124.42,43.85 124.5,43.94 124.5,44.1 124.42,44.19 ; 124.15,43.54 124.03,43.42 124.03,42.61 122.09,40.67 122.09,40.26 121.79,39.96 119.51,39.96 119.17,39.62 v1(119.17,39.43) ; 124.42,45.37 125.48,45.37 126.27,46.16 126.27,47.97 127.09,48.78 130.56,48.78 132.32,50.54 132.71,50.54 133.54,51.37 v1(134.19,51.37)
  BOTTOM w0.089: v1(134.19,51.37) 134.55,51.74 134.55,52.75 134.27,53.03 134.27,54.29 133.75,54.81 UC1.BB7
  BOTTOM w0.112: RC680.1 119.75,37.21 118.7,37.21 118.47,37.44 118.47,39.11 118.76,39.4 119.14,39.4 v1(119.17,39.43) 119.78,39.43 RC74.1
APU_SPI_CLK_R: length 13.6
  TOP w0.099: 119.53,44.06 119.63,44.15 RC47.2 RC622.2
  TOP w0.112: v1(121.46,37.65) 121.27,37.65 v3(120.5,38.42) 119.68,39.24 119.68,40.34 119.49,40.53 119.49,44.01 119.53,44.06
  BOTTOM w0.112: JH1.6 v1(121.46,37.65) 121.46,37.65 121.18,37.65 120.96,37.87 RX4.1 120.58,38.16 120.7,38.27 RC51.1 RC74.2
APU_SPI_CS1#: length 18.3
  BOTTOM w0.1: RC639.1 132.45,40.95 132.45,41.62 132.85,42.03 132.85,42.81 134.39,44.35 134.39,47.7 132.88,49.21 v3(132.88,49.56) 132.88,49.91 131.99,50.8 131.99,51.56 132.09,51.66 132.09,51.87 131.95,52.01 131.95,52.26 131.73,52.49 131.73,53.84 131.73,53.84 UC1.BC9
  BOTTOM w0.112: RC639.1 131.68,40.19 JH1.1 UC7.1
APU_SPI_D0: length 27
  IN3 w0.135: v1(131.62,51.84) 131.62,50.57 129.78,48.73 129.78,46.59 129.57,46.38 129.57,44.61 128.08,43.11 127.42,43.11 127.13,42.81 127.13,40.45 125.58,38.9 v1(124.5,38.9)
  BOTTOM w0.1: v1(131.62,51.84) 131.62,52.33 131.54,52.41 131.54,54.17 131.23,54.48 UC1.BB10
  BOTTOM w0.112: v1(124.5,38.9) 124.52,38.88 124.52,37.48 123.43,36.38 UC7.5 JH1.5 121.71,36.38 RC1706.1 120.7,34.69 RX2.1
APU_SPI_D1: length 20.8
  BOTTOM w0.1: JH1.2 131.02,38.92 131.3,39.2 RX1.1 132.04,39.2 132.32,39.48 132.32,40.4 132.75,40.83 132.75,41.5 133.15,41.9 133.15,42.69 134.69,44.22 v3(134.69,47.92) 133.28,49.33 133.28,50.2 132.28,51.2 132.28,51.94 132.14,52.08 132.14,52.34 131.91,52.56 131.91,53.76 131.93,53.78 131.93,54.13
  BOTTOM w0.112: UC7.2 JH1.2 ; 131.93,54.13 132.11,54.31 132.11,54.45 131.73,54.83 UC1.BA9
APU_SPI_D2: length 25.4
  BOTTOM w0.099: 130.67,40.82 131.28,41.43 131.28,42.14 131.74,42.59 132.11,42.59
  BOTTOM w0.1: UC1.BA10 130.73,54.83 131.03,54.53 131.03,54.23 130.91,54.11 130.91,53.74 130.8,53.64 130.8,53.3 131.02,53.09 131.23,53.09 131.35,52.97 131.35,52.1 131.25,52 v3(131.25,50.3) 131.25,49.68 134.08,46.85 134.08,44.47 132.62,43.01 132.53,43.01 132.11,42.59
  BOTTOM w0.112: RC640.1 131.75,37.65 JH1.3 UC7.3 129.37,37.65 128.87,38.16 128.87,40.4 129.29,40.82 130.67,40.82
APU_SPI_D3: length 23.8
  IN3 w0.135: v1(130.96,52.73) 130.89,52.73 130.48,52.32 130.48,51.72 130.12,51.35 130.12,49.55 128.89,48.32 128.89,46.59 129.24,46.24 129.24,44.75 127.94,43.45 127.28,43.45 126.79,42.95 126.79,40.67 125.44,39.33 v1(124.91,39.33)
  BOTTOM w0.1: v1(130.96,52.73) 130.88,52.73 130.62,52.99 130.62,53.72 130.71,53.81 130.71,54.38 UC1.BC10
  BOTTOM w0.112: v1(124.91,39.33) 123.86,39.33 123.45,38.92 UC7.7 JH1.7 122.02,38.92 120.7,40.24 RC642.1
APU_SPI_TPMCS#: length 45.8
  TOP w0.099: v1(132.64,51.73) 132.5,51.73 130.64,49.87 130.64,46.85 RC646.1
  IN3 w0.135: v1(108.91,36.38) 108.91,36.38 109.15,36.38 111.01,34.52 115.65,34.52 116.15,35.01 117.29,35.01 117.96,35.68 119.89,35.68 121.44,37.23 124.38,37.23 127.03,39.88 128.13,40.97 128.13,42.68 129.93,44.48 129.93,46.26 130.63,46.96 130.63,49.1 132.64,51.12 v1(132.64,51.73)
  BOTTOM w0.102: UC1.BD8 132.14,53.91 132.14,53.72 132.1,53.68 132.1,52.64 132.32,52.42 132.32,52.16 132.58,51.9 132.58,51.79 v1(132.64,51.73)
  BOTTOM w0.112: v1(108.91,36.38) 108.91,36.5 108.72,36.69 108.19,36.69 108.08,36.58 108.08,36.57 107.76,36.25 RX5.1
APU_SPKR: length 162.4
  TOP w0.089: v1(30.73,28.05) 30.85,27.94 30.85,24.82 v3(31.22,24.45) 31.22,23.61 32.07,22.76 33.51,22.76 34.22,22.04 DA3.3
  TOP w0.099: v1(125.68,57.77) 125.68,57.72 125.36,57.4 123.65,57.4 123.57,57.48 CC11.1
  IN1 w0.089: v1(40.12,48.65) 40.12,48.89 40.71,49.49 46.08,49.49 47.63,47.94 50.51,47.94 v1(52.33,49.77)
  IN2 w0.089: 57.79,42.64 57.79,44.04 52.33,49.5 v1(52.33,49.77) ; v1(125.68,57.77) 125.68,57.76 125.21,57.29 125.21,55.2 123.77,53.77 123.77,52.86 125.45,51.19 125.45,49.59 127.35,47.69 127.35,47.32 128.44,46.22 129.94,46.22 130.84,45.33 130.84,44.48 130.82,44.48 130.63,44.29 129.45,44.29 128.3,43.15 127.38,43.15 126.64,42.41 126.64,41.36 125.29,40.01 123.84,40.01 122.34,38.5 122.34,37.89 121.51,37.06 119.92,37.06 119.72,37.26 118.55,37.26 117.05,35.76 116.38,35.76 115.71,35.09 114.8,35.09 114.53,34.82 112.13,34.82 110.77,35.35 109.87,35.98 108.73,35.98 108.61,35.86 107.84,35.86 106.69,37.01 105.17,37.01 104.99,36.83 100.19,36.83 99.47,36.11 99.15,36.11 98.75,36.52 94.98,36.52 94.27,35.81 81.96,35.81 81.66,36.11 79.72,36.11 79.22,36.61 66.17,36.61 64.12,38.65 61.46,38.65 57.79,42.33 57.79,42.35 ; v1(30.73,28.05) 30.77,28.05 31.21,28.49 31.4,28.49 32.38,29.46 32.38,30.52 38.64,36.79 38.64,39.9 37.89,40.66 37.89,42.63 37.51,43.01 37.51,44.44 40.12,47.05 v1(40.12,48.65)
  IN2 w0.102: 57.79,42.64 57.79,42.35
  BOTTOM w0.1: v1(125.68,57.77) 125.68,57.82 125.39,58.11 UC1.AU16
APU_SVC: length 36.5
  TOP w0.089: RC7.2 v1(126.21,89.78) RC18.1
  TOP w0.203: v1(156.02,91.56) 155.57,91.11 PUZ01.3
  BOTTOM w0.089: v1(156.02,91.56) 155.68,91.56 152.49,94.74 143.44,94.74 140.99,92.29 132.25,92.29 131.06,91.09 v3(130.69,91.09) 127.19,91.09 126.21,90.11 v1(126.21,89.78)
APU_SVC_R: length 5.3
  TOP w0.089: 126.48,85.71 v3(126.37,85.82) 126.21,85.98 RC18.2
  TOP w0.099: v1(125.83,84.44) 125.84,84.43 125.98,84.43 126.75,85.21 126.75,85.43 126.48,85.71
  BOTTOM w0.1: v1(125.83,84.44) 125.76,84.37 125.59,84.37 UC1.F16
APU_SVD: length 36.1
  TOP w0.089: RC8.2 125.38,89.83 125.4,89.81 v1(125.4,89.78) 125.38,89.76 RC20.1
  TOP w0.203: PUZ01.5 154.77,91.37 154.58,91.56 v1(154.58,91.73)
  BOTTOM w0.089: v1(125.4,89.78) 125.42,89.78 125.82,89.38 126.47,89.38 126.63,89.54 126.63,89.96 v3(127.34,90.67) 131.28,90.67 132.6,91.99 141.11,91.99 143.57,94.45 151.86,94.45 v1(154.58,91.73)
APU_SVD_R: length 6.4
  TOP w0.089: RC20.2 125.38,87.63 125.7,87.31 v3(125.7,87.24) 125.7,85.71
  TOP w0.099: 125.7,85.71 125.7,85.08 125.45,84.83 125.45,83.31 v1(125.77,82.99)
  BOTTOM w0.089: UC1.H16 125.23,82.53 125.69,82.99 v1(125.77,82.99)
APU_SVT: length 34
  TOP w0.089: RC6.2 v1(124.56,89.78) RC22.1
  TOP w0.203: v1(153.41,91.47) 153.41,91.22 153.97,90.66 PUZ01.7
  BOTTOM w0.089: v1(124.56,89.78) 125.25,89.09 126.95,89.09 127.44,89.58 127.44,90.06 127.69,90.32 v3(129.24,90.32) 131.34,90.32 132.72,91.7 147.27,91.7 147.55,91.98 148.41,91.98 148.7,91.7 149.27,91.7 149.52,91.45 151.31,91.45 151.33,91.47 v1(153.41,91.47)
APU_SVT_R: length 7.4
  TOP w0.089: RC22.2 v3(124.56,86.29) 124.56,86.1 124.94,85.71
  TOP w0.099: v1(125.74,82.04) 125.74,82.19 125.64,82.29 125.64,82.29 125.25,82.68 125.25,85.4 124.94,85.71
  BOTTOM w0.102: UC1.J16 125.54,82.08 125.69,82.09 v1(125.74,82.04)
APU_TCK: length 134
  TOP w0.089: v1(220.43,64.32) 220.62,64.13 220.95,64.13 v4(221.48,63.6) 221.52,63.56 RH27.2 222.87,63.8 RPH1.1
  IN2 w0.089: v1(139.52,57.74) 140.17,57.09 140.17,56.77 142.77,54.16 142.77,46.4 150.21,38.96 151.47,38.96 153.74,36.69 162.32,36.69 163.43,35.58 169.46,35.58 170.88,34.15 173.38,34.15 173.97,34.75 173.97,35.07 174.75,35.85 176.78,35.85 177.68,36.75 181.75,36.75 182.55,35.95 186.74,35.95 187.01,36.22 187.01,36.91 187.3,37.2 188.17,37.2 188.37,37.4 190.02,37.4 190.35,37.73 191.88,37.73 192.26,37.35 193.52,37.35 193.73,37.14 195.75,35.12 198.64,35.12 199.22,35.7 201.59,35.7 201.75,35.55 203.92,35.55 204.31,35.16 206.83,35.16 206.97,35.3 210.72,35.3 214.57,39.15 214.91,39.15 215.31,39.55 215.31,42.35 215.56,42.6 215.56,45.07 216.25,45.75 219.71,45.75 220.14,46.19 220.14,49.58 219.15,50.57 219.15,54.81 220.53,56.19 220.53,58.95 221.1,59.51 221.1,63.6 220.43,64.27 v1(220.43,64.32)
  BOTTOM w0.089: v1(139.52,57.74) 138.95,58.31 UC1.AU1
APU_TDI: length 139.8
  TOP w0.089: RPH1.3 223.87,65.37 223.73,65.5 222.58,65.5 221.81,64.74 CH4.1 221.28,64.74 v1(220.37,65.65) 219.76,65.65 RH28.2 v4(218.27,65.36)
  IN2 w0.089: v1(220.37,65.65) 221.33,64.69 221.33,59.84 221.95,59.22 221.95,57.35 219.33,54.73 219.33,50.65 220.32,49.66 220.32,45.97 219.93,45.57 216.32,45.57 215.74,44.99 215.74,42.53 215.49,42.28 215.49,39.48 214.98,38.97 214.64,38.97 210.79,35.12 207.05,35.12 206.86,34.93 204.28,34.93 203.84,35.37 201.67,35.37 201.52,35.52 199.29,35.52 198.71,34.94 195.67,34.94 193.45,37.17 192.19,37.17 191.81,37.55 190.43,37.55 190.1,37.22 188.44,37.22 188.24,37.02 187.41,37.02 187.19,36.8 187.19,36.02 186.93,35.76 182.47,35.76 181.67,36.57 177.76,36.57 176.86,35.67 174.83,35.67 174.16,35 174.16,34.67 173.24,33.75 171.03,33.75 169.49,35.29 163.24,35.29 162.02,36.51 153.66,36.51 151.4,38.78 150.04,38.78 142.59,46.23 142.59,54.08 139.5,57.18 v1(139.37,57.18)
  BOTTOM w0.089: v1(139.37,57.18) 138.78,57.18 137.84,58.12 136.77,58.12 136.46,57.81 UC1.AU2
APU_TDO: length 133.4
  TOP w0.089: v1(222.13,60.47) 222.13,62.28 220.62,63.79 220.14,63.79 RH28.1
  IN2 w0.089: v1(222.13,60.47) 222.13,57.27 219.52,54.66 219.52,50.72 220.51,49.73 220.51,45.77 220.13,45.39 216.4,45.39 215.93,44.91 215.93,42.45 215.67,42.2 215.67,39.4 214.94,38.67 214.6,38.67 210.87,34.93 207.12,34.93 206.92,34.73 204.22,34.73 203.76,35.19 201.59,35.19 201.44,35.34 199.37,35.34 198.75,34.71 195.64,34.71 193.37,36.98 192.11,36.98 191.73,37.37 190.5,37.37 190.17,37.03 188.52,37.03 187.07,35.58 180.59,35.58 179.87,36.3 177.83,36.3 175,33.47 170.49,33.47 169.7,34.26 167.46,34.26 167.36,34.16 164.03,34.16 161.91,36.28 153.63,36.28 151.32,38.59 149.61,38.59 143.05,45.16 143.05,45.51 142.35,46.21 142.35,53.87 139.63,56.59 v1(139.4,56.59)
  BOTTOM w0.089: v1(139.4,56.59) 139.12,56.59 137.78,57.93 136.85,57.93 136.53,57.61 136.42,57.61 136.31,57.51 136.01,57.51 135.71,57.81 UC1.AU4
APU_TEST4: length 2.1
  TOP w0.099: v1(127.73,60.11) 127.29,59.66 127.29,59.25 127.22,59.19 T5.1
  BOTTOM w0.25: UC1.AP14 127.33,60.51 v1(127.73,60.11)
