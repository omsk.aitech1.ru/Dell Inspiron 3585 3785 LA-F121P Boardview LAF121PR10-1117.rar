# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQ46: length 63.5
  IN1 w0.099: 102.47,51.63 107.64,56.8 113.58,56.8 113.84,57.06 114.27,57.06 114.88,57.67 115.5,57.67 115.96,57.2 116.54,57.2 116.95,57.61 116.95,57.83 117.55,58.44 117.79,58.44 118.08,58.73 118.08,59.15 118.31,59.38 119.23,59.38 119.41,59.56 v1(119.41,59.81)
  IN1 w0.102: v1(75.56,56.1) 75.38,56.28 74.95,56.28 74.44,55.77 74.44,55.49 74.18,55.24 73.72,55.24 73.62,55.14 73.62,54.81 73.69,54.74 74.94,54.74 75.04,54.84 75.04,55.68 75.15,55.79 75.35,55.79 75.45,55.68 75.45,54.84 75.55,54.74 75.78,54.74 75.89,54.85 75.89,55.61 76,55.71 76.2,55.71 76.3,55.61 76.3,54.84 76.4,54.74 77.44,54.74 79.95,52.22 81.94,52.22
  IN1 w0.109: 102.47,51.63 82.53,51.63 81.94,52.22
  BOTTOM w0.1: UC1.AP24 119.05,60.31 119.41,59.94 v1(119.41,59.81)
  BOTTOM w0.102: v1(75.56,56.1) 75.56,56.98 75.99,57.41 78.28,57.41 78.35,57.49 JDIMM1.203
DDR_A_DQ47: length 59.8
  IN1 w0.099: v1(120.01,60.76) 120.01,59.88 119.19,59.05 118.55,59.05 118.28,58.78 118.28,58.65 117.88,58.24 117.63,58.24 117.14,57.75 117.14,57.53 116.62,57 115.47,57 115.33,56.86 113.92,56.86 113.67,56.61 107.73,56.61 102.34,51.21
  IN1 w0.102: 77.35,54.53 73.07,54.53 72.97,54.63 72.97,55.41 73.07,55.51 73.64,55.51 v1(74.23,56.1)
  IN1 w0.109: 102.34,51.21 82.36,51.21 81.76,51.81 80.07,51.81 77.35,54.53
  BOTTOM w0.1: v1(120.01,60.76) 120.01,60.69 UC1.AP23
  BOTTOM w0.102: v1(74.23,56.1) 73.1,57.24 70.95,57.24 JDIMM1.204
DDR_A_DQ48: length 57.4
  IN1 w0.099: 101.75,49.48 103.27,49.48 106.15,52.36 108.23,52.36 108.51,52.64 108.51,53.82 108.3,54.03 107.22,54.03 107.12,54.13 107.12,54.85 108.06,55.79 113.78,55.79 114.3,55.27 116.26,55.27 116.76,55.78 v1(116.76,55.8)
  IN1 w0.109: 101.75,49.48 81.64,49.48 81.04,50.08 80.2,50.08 77.63,52.65 74.96,52.65 74.85,52.76 74.85,52.91 74.74,53.02 74.52,53.02 74.41,52.91 74.41,52.76 74.3,52.65 74.07,52.65 73.48,53.23 73.48,53.39 v1(73.92,53.82)
  BOTTOM w0.102: UC1.AW26 117.23,56.42 116.76,55.96 v1(116.76,55.8) ; JDIMM1.216 71.7,54.24 71.76,54.3 73.69,54.3 73.92,54.08 v1(73.92,53.82)
DDR_A_DQ49: length 59.9
  IN1 w0.099: v1(117.64,56.96) 117.01,56.96 116.85,56.81 115.58,56.81 115.44,56.66 114,56.66 113.72,56.38 107.8,56.38 105.46,54.04 105.46,53.9 105.81,53.55 105.81,53.41 105.67,53.27 105.53,53.27 105.17,53.62 105.03,53.62 104.83,53.42 104.83,53.28 105.46,52.65 105.46,52.51 105.32,52.37 105.18,52.37 104.55,53 104.41,53 104.27,52.86 104.27,52.72 104.9,52.09 104.9,51.95 104.76,51.81 104.62,51.81 103.99,52.43 103.85,52.43 103.61,52.2 103.61,52.06 104.18,51.49 104.18,51.35 104.04,51.21 103.9,51.21 103.33,51.78 103.19,51.78 103.05,51.64 103.05,51.5 103.62,50.93 103.62,50.79 103.48,50.65 103.34,50.65 102.77,51.22 102.63,51.22 102.14,50.72 101.58,50.72
  IN1 w0.102: 80.55,51.32 80.27,51.32 79.8,51.79 79.66,51.79 79.58,51.71 79.44,51.71 79.29,51.86 79.29,52 79.37,52.07 79.37,52.22 79.23,52.36 79.08,52.36 79.01,52.29 78.86,52.29 78.72,52.43 78.72,52.57 78.79,52.65 78.79,52.79 78.65,52.94 78.51,52.94 78.43,52.86 78.29,52.86 78.14,53.01 78.14,53.15 78.22,53.22 78.22,53.37 77.61,53.98 77.26,54.33 76.45,54.33 76.34,54.22 76.34,54.07 v1(76.98,53.44)
  IN1 w0.109: 101.58,50.72 82.16,50.72 81.56,51.32 80.55,51.32
  BOTTOM w0.1: v1(117.64,56.96) 117.69,56.91 117.83,56.91 UC1.AV25
  BOTTOM w0.102: JDIMM1.215 77.44,54.49 76.98,54.03 v1(76.98,53.44)
DDR_A_DQ50: length 58.2
  IN1 w0.099: v1(119.73,57.01) 119.73,56.76 120.03,56.46 120.03,56.11 119.85,55.93 119.85,54.73 119.01,53.88 118.99,53.88 118.26,53.15 118.26,52.27 117.92,51.93 113.09,51.93
  IN1 w0.109: v1(73.66,51.24) 75.41,49.49 77.4,49.49 80.33,46.55 102.49,46.55 102.9,46.96 105.17,46.96 107.37,49.16 108.34,49.16 109.25,50.08 111.23,50.08 113.09,51.93
  BOTTOM w0.1: v1(119.73,57.01) 120.03,57.31 UC1.AV22
  BOTTOM w0.102: JDIMM1.228 70.95,51.24 71.71,51.24 72.17,50.78 73.1,50.78 73.56,51.24 v1(73.66,51.24)
DDR_A_DQ51: length 60.2
  IN1 w0.099: 101.58,46.97 102.62,46.97 103.32,47.67 103.46,47.67 103.83,47.29 103.97,47.29 104.11,47.43 104.11,47.57 103.74,47.95 103.74,48.09 103.88,48.23 104.27,48.23 104.96,47.54 105.1,47.54 105.24,47.68 105.24,47.82 104.48,48.58 104.48,48.72 105.13,49.37 105.36,49.37 105.52,49.2 105.52,48.16 105.62,48.06 105.82,48.06 105.92,48.16 105.92,49.27 106.01,49.37 106.62,49.37 106.72,49.47 106.72,49.83 106.82,49.92 107.02,49.92 107.12,49.83 107.12,49.47 107.21,49.37 108.26,49.37 109.17,50.28 110.28,50.28 110.38,50.38 110.38,50.82 110.48,50.92 110.68,50.92 110.78,50.82 110.78,50.38 110.87,50.28 111.14,50.28 113.01,52.14 117.85,52.14 118.07,52.36 118.07,53.24 118.91,54.08 118.93,54.08 119.66,54.81 119.66,56.26 v1(119.65,56.27)
  IN1 w0.109: 101.58,46.97 80.5,46.97 77.49,49.99 v1(76.97,49.99)
  BOTTOM w0.1: v1(119.65,56.27) 120,56.61 UC1.AW22
  BOTTOM w0.102: v1(76.97,49.99) 77.97,50.99 JDIMM1.229
DDR_A_DQ52: length 60.3
  IN1 w0.099: 101.88,49.89 103.41,49.89 106.07,52.56 108.09,52.56 108.31,52.79 108.31,53.64 108.12,53.83 107.02,53.83 106.92,53.93 106.92,54.94 107.97,55.99 114.46,55.99 114.56,55.89 114.56,55.57 114.66,55.47 114.86,55.47 114.96,55.57 114.96,55.97 115.06,56.07 115.96,56.07 115.97,56.05 116.48,56.05 116.61,56.18 117.15,56.18 117.56,56.59 117.84,56.59 118.04,56.79 118.04,57.54 118.06,57.56 118.06,58.06 118.67,58.67 v1(118.7,58.67)
  IN1 w0.102: v1(75.46,53.44) 75.41,53.38 75.41,53.01 75.57,52.85 77.72,52.85 80.08,50.49 81.21,50.49
  IN1 w0.109: 81.21,50.49 81.81,49.89 101.88,49.89
  BOTTOM w0.099: v1(118.7,58.67) 118.65,58.67 118.59,58.73 118.14,58.73 117.72,58.31 UC1.AU26
  BOTTOM w0.102: v1(75.46,53.44) 77.52,55.49 JDIMM1.211
DDR_A_DQ53: length 57.8
  IN1 w0.099: 102,50.31 102.23,50.31 102.62,50.7 102.76,50.7 103.16,50.31 103.54,50.31 105.99,52.76 108,52.76 108.12,52.87 108.12,53.53 108.02,53.63 106.03,53.63 105.88,53.79 105.88,54.18 107.88,56.18 113.98,56.18 114.16,56.36 114.38,56.36 114.56,56.18 114.79,56.18 114.97,56.36 116.13,56.36 v1(116.2,56.43)
  IN1 w0.102: 81.39,50.9 79.96,50.9 77.8,53.06 76.13,53.06 75.88,53.31 75.88,53.56 76.14,53.82 76.14,54.21 76.02,54.33 75.28,54.33 75.18,54.23 v1(75.18,53.92)
  IN1 w0.109: 81.39,50.9 81.98,50.31 102,50.31
  BOTTOM w0.099: 116.53,56.76 v1(116.2,56.43)
  BOTTOM w0.102: UC1.AV27 116.53,56.76 ; JDIMM1.212 71.93,55.24 72.02,55.15 73.95,55.15 v1(75.18,53.92)
DDR_A_DQ54: length 57.7
  IN1 w0.099: v1(118.84,56.21) 118.84,55.73 118.65,55.54 118.65,55.21 117.12,53.68 117.07,53.68 116.85,53.46 116.85,52.64 116.76,52.54 112.19,52.54 111.14,51.49 106.58,51.49 102.89,47.8 102.71,47.8
  IN1 w0.109: 102.71,47.8 80.85,47.8 77.73,50.92 74.92,50.92 72.94,52.89 72.29,52.89 71.76,52.37 71.76,51.73 v1(72.18,51.31)
  BOTTOM w0.1: UC1.AW23 119.03,56.61 118.81,56.38 118.81,56.24 v1(118.84,56.21)
  BOTTOM w0.102: v1(72.18,51.31) 72.18,51.86 71.81,52.24 70.95,52.24 JDIMM1.224
DDR_A_DQ55: length 60.1
  IN1 w0.099: v1(119.85,58.49) 119.73,58.38 119.73,58.24 119.35,57.86 119.35,56.96 119.28,56.88 119.28,55.88 118.85,55.46 118.85,54.3 117.87,53.32 117.87,52.44 117.77,52.34 112.28,52.34 111.22,51.29 108.34,51.29 108.25,51.19 108.25,51.02 108.15,50.92 107.95,50.92 107.85,51.02 107.85,51.19 107.75,51.29 107.55,51.29 107.45,51.19 107.45,51.02 107.35,50.92 107.16,50.92 107.06,51.02 107.06,51.19 106.96,51.29 106.66,51.29 102.75,47.38 101.58,47.38
  IN1 w0.109: v1(75.63,49.96) 75.37,49.96 75.14,50.2 75.14,50.6 75.25,50.71 77.35,50.71 80.68,47.38 101.58,47.38
  BOTTOM w0.1: 119.92,58.7 119.85,58.62 v1(119.85,58.49)
  BOTTOM w0.102: UC1.AT22 120.13,58.91 119.92,58.7 ; v1(75.63,49.96) 76.5,50.83 76.7,50.83 77.85,51.99 JDIMM1.225
DDR_A_DQ56: length 69.7
  IN1 w0.099: v1(120.81,56.24) 120.81,56.24 120.82,56.24 121.06,56 121.06,54.87 121.06,54.87 121.06,54.23 120.6,53.77 120.46,53.77 120.28,53.94 120.14,53.94 120,53.8 120,53.66 120.18,53.49 120.18,53.35 118.17,51.34 113.34,51.34 112.63,50.63 112.63,50.49 112.79,50.34 112.79,50.2 112.65,50.06 112.51,50.06 112.35,50.21 112.21,50.21 112.07,50.07 112.07,49.93 112.23,49.78 112.23,49.64 112.09,49.5 111.95,49.5 111.79,49.65 111.65,49.65 111.48,49.48 109.8,49.48 108.26,47.93 108.12,47.93 107.67,48.38 107.53,48.38 107.34,48.18 107.34,48.04 107.83,47.55 107.83,47.41 107.73,47.31 107.59,47.31 107.14,47.76 106.92,47.76 106.78,47.62 106.78,47.47 107.33,46.91 107.33,46.77 107.19,46.63 107.05,46.63 106.49,47.19 106.35,47.19 106.25,47.09 106.25,46.95 106.72,46.48 106.72,46.34 106.58,46.2 106.44,46.2 106.28,46.36 105.74,46.36 105.64,46.26 105.64,45.89 105.54,45.79 105.34,45.79 105.24,45.89 105.24,46.26 105.14,46.36 104.92,46.36 104.82,46.26 104.82,45.89 104.72,45.79 104.52,45.79 104.42,45.89 104.42,46.26 104.32,46.36 104.12,46.36 104.03,46.26 104.03,45.89 103.93,45.79 103.73,45.79 103.63,45.89 103.63,46.26 103.53,46.36 103.15,46.36 102.58,45.79 102.14,45.79 101.58,45.24
  IN1 w0.102: v1(76.96,47.96) 76.94,47.96 76.56,47.59 76.45,47.59 76.27,47.41 76.27,47.18 76.47,46.99 76.61,46.99 76.92,47.29 77.72,47.29 77.82,47.39 77.82,47.48 77.99,47.65 78.14,47.65 78.54,47.25 78.54,47.1 78.27,46.83 78.27,46.68 78.41,46.54 78.55,46.54 78.83,46.81 78.97,46.81 79.13,46.65 79.13,46.51 78.69,46.06 78.69,45.92 78.83,45.77 78.97,45.77 79.42,46.22 79.57,46.22 79.71,46.08 79.71,45.93 79.26,45.49 79.26,45.34 79.41,45.2 79.55,45.2 80,45.65 80.14,45.65 80.55,45.24
  IN1 w0.109: 101.58,45.24 80.55,45.24
  BOTTOM w0.1: UC1.AW21 121.08,56.61 120.82,56.34 120.82,56.26 120.81,56.25 v1(120.81,56.24)
  BOTTOM w0.102: v1(76.96,47.96) 77.98,48.99 JDIMM1.237
DDR_A_DQ57: length 66.6
  IN1 w0.099: v1(120.62,57.72) 120.35,57.45 120.35,56.8 120.43,56.73 120.43,56.08 120.86,55.64 120.86,54.95 119.61,53.69 119.61,53.06 118.09,51.54 113.26,51.54 111.39,49.67 109.42,49.67 108.51,48.76 107.54,48.76 105.33,46.56 103.07,46.56 102.5,45.99 101.93,45.99 101.58,45.65
  IN1 w0.102: 80.55,45.65 77.86,48.34 77.08,48.34 76.98,48.45 76.98,48.51 76.88,48.61 76.68,48.61 76.58,48.51 76.58,48.45 76.47,48.34 76.25,48.34 76.14,48.45 76.14,48.9 76.04,49 75.84,49 75.74,48.9 75.74,48.45 75.64,48.34 75.43,48.34 75.33,48.45 75.33,48.9 75.23,49 75.03,49 74.92,48.9 74.92,48.45 74.82,48.34 74.41,48.34 74.41,48.33 74.15,48.08 71.57,48.08 71.37,48.28 71.37,49.14 71.61,49.39 72.79,49.39 72.89,49.28 v1(72.89,48.71)
  IN1 w0.109: 80.55,45.65 101.58,45.65
  BOTTOM w0.1: UC1.AU21 121.01,58.11 v1(120.62,57.72)
  BOTTOM w0.102: v1(72.89,48.71) 72.36,49.24 70.95,49.24 JDIMM1.236
DDR_A_DQ58: length 70.4
  IN1 w0.099: v1(121.73,60.11) 121.73,60.37 122,60.64 122.27,60.64 122.35,60.56 122.35,59.06 122.82,58.6 122.82,54.64 122.43,54.26 122.43,53.03 118.48,49.08 114.91,49.08 113.09,47.26 110.3,47.26 106.99,43.96 103.21,43.96 102.79,43.54
  IN1 w0.102: 80.55,42.72 79.57,42.72 79.47,42.82 79.47,43.07 79.36,43.18 79.16,43.18 79.06,43.07 79.06,42.82 78.96,42.72 78.08,42.72 77.5,43.31 77.5,44.28 77.4,44.38 76.9,44.38 76.67,44.15 76.67,42.9 76.56,42.8 76.42,42.8 74.97,44.25 74.97,44.39 75.32,44.74 75.5,44.74 75.79,44.45 75.98,44.45 76.3,44.76 76.71,44.76 77.14,45.19 v1(77.21,45.19)
  IN1 w0.109: 102.79,43.54 101.97,42.72 80.55,42.72
  BOTTOM w0.1: UC1.AP21 121.46,60.28 121.56,60.28 v1(121.73,60.11)
  BOTTOM w0.112: v1(77.21,45.19) 77.32,45.31 77.76,45.31 78.44,45.99 JDIMM1.249
DDR_A_DQ59: length 67.5
  IN1 w0.099: 107.15,43.54 110.47,46.86 113.25,46.86 114.89,48.5 118.58,48.5 122.83,52.75 122.83,54.09 123.3,54.57 123.3,58.95 123.11,59.14 123.11,60.26 122.73,60.64 v1(122.73,60.91)
  IN1 w0.102: 80.89,41.9 76.57,41.9 75.34,43.12 74.8,43.12 72.71,45.22 v1(72.71,45.31)
  IN1 w0.109: 80.89,41.9 102.32,41.9 103.97,43.54 107.15,43.54
  BOTTOM w0.1: v1(122.73,60.91) 122.63,60.91 UC1.AN20
  BOTTOM w0.102: JDIMM1.250 72.61,45.74 72.71,45.64 v1(72.71,45.31)
DDR_A_DQ60: length 67
  IN1 w0.099: 101.58,46.06 101.87,46.35 102.58,46.35 102.98,46.76 105.25,46.76 107.46,48.96 108.43,48.96 109.34,49.87 111.31,49.87 113.17,51.73 118,51.73 118.46,52.19 118.46,53.07 119.07,53.68 119.32,53.68 120.62,54.99 120.62,55.6 120.23,55.99 120.23,56.58 120.16,56.66 120.16,58.14 120.3,58.29 120.3,59.03 120.16,59.18 120.16,59.63 v1(120.63,60.1)
  IN1 w0.102: v1(74.35,48.73) 72.69,50.38 72.69,50.52 73.07,50.91 73.36,50.91 74.98,49.28 77.31,49.28 80.53,46.06 80.55,46.06
  IN1 w0.109: 80.55,46.06 101.58,46.06
  BOTTOM w0.1: v1(120.63,60.1) 120.61,60.1 120.61,60.08 UC1.AR22
  BOTTOM w0.102: v1(74.35,48.73) 72.83,50.24 JDIMM1.232
DDR_A_DQ61: length 69.7
  IN1 w0.099: 101.58,44.41 102,44.41 102.99,45.4 107.31,45.4 110.44,48.52 111.68,48.52 114.09,50.94 115.09,50.94 115.19,50.84 115.19,50.21 115.37,50.03 118.21,50.03 120.82,52.65 120.82,53.43 121.46,54.07 121.46,55.04 121.46,56.61 121.4,56.67 121.4,58.38 121.26,58.53 121.21,58.53 121.11,58.62 121.11,58.82 121.21,58.92 121.26,58.92 121.35,59.02 121.35,59.22 121.26,59.32 121.21,59.32 121.11,59.42 121.11,59.61 121.21,59.71 121.26,59.71 121.35,59.81 121.35,60.95 121.26,61.05 120.97,61.05 v1(120.83,60.91)
  IN1 w0.102: v1(75.84,47.91) 75.63,48.13 75.15,48.13 74.91,47.89 74.91,47.04 75.03,46.92 75.3,46.92 75.4,47.02 75.4,47.39 75.5,47.49 75.94,47.49 76.04,47.39 76.04,46.34 76.21,46.17 77.86,46.17 79.62,44.41 80.55,44.41
  IN1 w0.109: 80.55,44.41 101.58,44.41
  BOTTOM w0.1: UC1.AN22 v1(120.83,60.91)
  BOTTOM w0.102: v1(75.84,47.91) 75.84,48.66 76.65,49.46 77.24,49.46 77.76,49.99 JDIMM1.233
DDR_A_DQ62: length 69.9
  IN1 w0.099: 102.21,43.54 102.82,44.15 103.43,44.15 103.53,44.25 103.53,44.59 103.63,44.69 103.82,44.69 103.92,44.59 103.92,44.25 104.02,44.15 106.91,44.15 110.21,47.46 113.01,47.46 114.98,49.43 118.5,49.43 122.23,53.17 122.23,54.34 122.61,54.72 122.61,57.6 122.51,57.7 122.37,57.7 122.27,57.8 122.27,58 122.37,58.1 122.51,58.1 122.61,58.2 122.61,58.52 121.84,59.29 v1(121.74,59.29)
  IN1 w0.102: 80.55,43.14 79.97,43.14 79.37,43.73 79.23,43.73 78.56,43.07 78.42,43.07 78.28,43.21 78.28,43.36 78.94,44.02 78.94,44.16 78.8,44.31 78.65,44.31 77.99,43.65 77.85,43.65 77.7,43.79 77.7,43.93 78.37,44.6 78.37,44.74 77.53,45.58 75.7,45.58 75.57,45.45 75.57,44.95 75.79,44.74 75.89,44.74 75.99,44.84 v1(75.99,45.13)
  IN1 w0.109: 80.55,43.14 101.8,43.14 102.21,43.54
  BOTTOM w0.1: v1(121.74,59.29) 121.8,59.29 122.19,58.91 UC1.AT20
  BOTTOM w0.112: JDIMM1.245 78.36,46.99 77.8,46.43 77.3,46.43 v1(75.99,45.13)
DDR_A_DQ63: length 67
  IN1 w0.099: v1(122.73,59.22) 123.1,58.84 123.1,54.65 122.63,54.17 122.63,52.95 118.38,48.7 114.81,48.7 113.17,47.06 110.38,47.06 107.07,43.75
  IN1 w0.102: 80.89,42.31 80.89,42.31 76.52,42.31 75.02,43.82 74.88,43.82 74.71,43.65 74.56,43.65 74.42,43.79 74.42,43.93 74.59,44.1 74.59,44.25 74.45,44.39 74.3,44.39 74.13,44.22 73.99,44.22 73.85,44.37 73.85,44.51 74.02,44.68 74.02,44.82 73.87,44.97 v1(73.87,45.32)
  IN1 w0.109: 107.07,43.75 103.59,43.75 102.15,42.31 80.89,42.31
  BOTTOM w0.1: UC1.AR20 122.72,59.22 v1(122.73,59.22)
  BOTTOM w0.102: v1(73.87,45.32) 73.87,45.82 72.95,46.74 JDIMM1.246
DDR_A_DQS0: length 69
  IN1 w0.099: 109.09,96.53 109.26,96.36 109.27,96.36 110.17,95.45 110.17,95.31 110.05,95.19 110.05,94.88 110.31,94.63 110.61,94.63 110.73,94.75 110.88,94.75 111.02,94.61 111.02,94.47 110.89,94.35 110.89,94.04 111.15,93.79 111.45,93.79 111.58,93.91 111.72,93.91 112.37,93.26 113.11,93.26 113.21,93.16 113.21,93.02 113.43,92.81 113.79,92.81 114,93.02 114,93.16 114.1,93.26 115.83,93.26 116.75,92.34 116.75,91.34 116.65,91.24 116.19,91.24 115.98,91.02 115.98,90.66 116.19,90.45 116.65,90.45 116.75,90.35 116.75,89.94 118.65,88.03 118.65,86.74 119.66,85.73 119.66,85.02 120.13,84.54 120.13,84.05 120.33,83.87 120.34,83.73 120.12,83.49 119.98,83.48 v1(119.81,83.63)
  IN1 w0.102: v1(77.01,105.95) 76.78,106.18 76.78,106.85 76.88,106.95 77.22,106.95 77.32,106.85 77.32,106.48 77.53,106.27 77.9,106.27 78.11,106.48 78.11,106.85 78.21,106.95 78.72,106.95 79.15,106.52 79.15,105.49 79.37,105.28 79.73,105.28 79.94,105.49 79.94,106.52 80.04,106.62 80.51,106.62 80.53,106.6 80.55,106.6
  IN1 w0.13: 109.09,96.53 100.01,105.6 98.51,105.6 98.38,105.47 98.38,105.32 98.12,105.06 97.68,105.06 97.43,105.32 97.43,105.47 97.3,105.6 82.13,105.6 81.12,106.6 80.55,106.6
  BOTTOM w0.102: v1(77.01,105.95) 76.91,105.95 76.78,106.08 76.78,106.12 76.66,106.25 76.66,106.5 77.44,107.29 78.03,107.29 78.12,107.2 78.12,107.13 78.13,107.12 78.14,107.12 78.27,106.99 JDIMM1.13
  BOTTOM w0.122: UC1.F22 120.18,84.01 119.81,83.63 v1(119.81,83.63)
DDR_A_DQS0#: length 69.2
  IN1 w0.099: v1(120.72,83.69) 120.71,83.69 120.71,83.81 120.33,84.14 120.33,84.63 119.85,85.1 119.85,85.81 118.85,86.82 118.85,88.12 116.95,90.02 116.95,90.43 116.73,90.64 116.27,90.64 116.17,90.74 116.17,90.94 116.27,91.04 116.73,91.04 116.95,91.26 116.95,92.42 115.91,93.45 114.02,93.45 113.81,93.24 113.81,93.1 113.71,93.01 113.51,93.01 113.41,93.1 113.41,93.24 113.2,93.45 112.45,93.45 111.8,94.11 111.49,94.11 111.37,93.98 111.23,93.98 111.09,94.13 111.09,94.26 111.21,94.39 111.21,94.7 110.96,94.95 110.65,94.95 110.53,94.83 110.39,94.83 110.25,94.97 110.25,95.11 110.37,95.23 110.37,95.54 109.41,96.5 109.41,96.51 109.4,96.53
  IN1 w0.102: 80.55,106.82 80.53,106.82 80.51,106.81 79.96,106.81 79.75,106.59 79.75,105.57 79.65,105.47 79.45,105.47 79.34,105.57 79.34,106.59 78.8,107.14 78.13,107.14 77.92,106.93 77.92,106.56 77.82,106.46 77.61,106.46 77.51,106.56 77.51,106.93 77.3,107.14 76.8,107.14 76.59,106.93 76.59,106.17 v1(76.38,105.95)
  IN1 w0.13: 80.55,106.82 81.21,106.82 82.22,105.82 97.39,105.82 97.64,105.56 97.64,105.41 97.77,105.28 98.03,105.28 98.16,105.41 98.16,105.56 98.42,105.82 100.1,105.82 109.24,96.68 109.4,96.53
  BOTTOM w0.099: v1(120.72,83.69) 120.61,83.69 UC1.G22
  BOTTOM w0.102: v1(76.38,105.95) 76.46,106.03 76.46,106.59 77.36,107.49 JDIMM1.11
DDR_A_DQS1: length 59.9
  IN1 w0.099: 102.45,96.53 102.62,96.36 102.64,96.36 106.6,92.4 107.72,92.4 112.34,87.78 114.6,87.78 115.66,86.72 115.66,84.34 115.56,84.24 115.56,83.77 115.9,83.43 116.25,83.43 116.57,83.11 116.57,82.92 116.45,82.8 116.31,82.8 116.26,82.85 v1(116.23,82.85)
  IN1 w0.102: 80.55,100.4 80.53,100.38 80.51,100.38 79.94,99.81 73.49,99.81 73.17,100.12 73.17,100.79 v1(72.96,101)
  IN1 w0.13: 102.45,96.53 98.57,100.4 97.58,100.4 97.45,100.27 97.45,99.99 97.19,99.73 96.75,99.73 96.5,99.99 96.5,100.27 96.37,100.4 96.11,100.4 95.98,100.27 95.98,99.99 95.72,99.73 95.28,99.73 95.02,99.99 95.02,100.27 94.89,100.4 80.56,100.4 80.55,100.4
  BOTTOM w0.099: v1(116.23,82.85) 116.3,82.78 116.3,82.74 116.53,82.51 UC1.H27
  BOTTOM w0.102: v1(72.96,101) 73.16,101.2 73.16,101.73 73.05,101.84 72.09,101.84 72.08,101.85 71.97,101.74 JDIMM1.34
DDR_A_DQS1#: length 60.1
  IN1 w0.099: 102.76,96.53 102.78,96.51 102.78,96.5 106.68,92.59 107.8,92.59 112.42,87.98 114.68,87.98 115.85,86.81 115.85,84.26 115.76,84.16 115.76,83.85 115.98,83.63 116.33,83.63 116.77,83.19 116.77,82.97 v1(116.93,82.81)
  IN1 w0.102: 80.4,100.55 80.38,100.53 80.38,100.51 79.86,100 73.56,100 73.36,100.2 73.36,100.82 v1(73.55,101)
  IN1 w0.13: 102.76,96.53 98.67,100.62 97.49,100.62 97.23,100.36 97.23,100.08 97.1,99.95 96.85,99.95 96.72,100.08 96.72,100.36 96.46,100.62 96.02,100.62 95.76,100.36 95.76,100.08 95.63,99.95 95.37,99.95 95.24,100.08 95.24,100.36 94.99,100.62 80.47,100.62 80.4,100.55
  BOTTOM w0.099: v1(116.93,82.81) 117.23,82.51 UC1.H26
  BOTTOM w0.102: v1(73.55,101) 73.52,101 73.36,101.16 73.36,101.82 73.13,102.04 72.17,102.04 71.97,102.24 JDIMM1.32
DDR_A_DQS2: length 59.6
  IN1 w0.099: v1(116.27,78.81) 116.45,78.81 116.55,78.91 116.55,79.09 116.4,79.24 114.79,79.24 113.88,80.15 113.88,81.13 113.44,81.57 113.44,82.65 113.25,82.84 113.25,83.4 113.44,83.58 113.44,84.03 113.18,84.29 108.52,84.29 101.59,91.22 101.59,91.3 101.58,91.3
  IN1 w0.102: v1(76.83,94.52) 76.73,94.52 76.43,94.83 76.43,95.17 76.82,95.56 77.62,95.56 78.01,95.17 78.01,94.49 78.22,94.28 78.58,94.28 78.8,94.49 78.8,95.25 78.9,95.35 79.1,95.35 79.2,95.25 79.2,94.49 79.42,94.28 79.78,94.28 79.99,94.49 79.99,95.25 80.09,95.35 80.32,95.35 80.55,95.11
  IN1 w0.13: 101.58,91.3 98.29,94.6 81.06,94.6 80.55,95.11
  BOTTOM w0.099: v1(116.27,78.81) 116.27,78.77 116.53,78.51 UC1.N27
  BOTTOM w0.102: JDIMM1.55 78.51,96.49 78.37,96.63 78.27,96.63 77.63,95.99 76.86,95.99 76.4,95.53 76.4,95.06 76.49,94.97 76.84,94.97 76.97,94.83 76.97,94.66 v1(76.83,94.52)
DDR_A_DQS2#: length 59.7
  IN1 w0.099: v1(116.93,78.81) 116.75,78.99 116.75,79.17 116.48,79.44 114.88,79.44 114.08,80.23 114.08,81.21 113.64,81.66 113.64,82.74 113.45,82.92 113.45,83.32 113.64,83.5 113.64,84.12 113.26,84.49 108.6,84.49 101.79,91.3 101.79,91.41 101.58,91.61
  IN1 w0.102: 80.55,95.41 80.42,95.54 80.01,95.54 79.8,95.32 79.8,94.57 79.7,94.47 79.5,94.47 79.39,94.57 79.39,95.32 79.18,95.54 78.82,95.54 78.61,95.32 78.61,94.57 78.5,94.47 78.3,94.47 78.2,94.57 78.2,95.25 77.69,95.75 76.74,95.75 76.24,95.25 76.24,95.15 76.2,95.1 v1(76.2,94.52)
  IN1 w0.13: 101.58,91.61 98.38,94.82 81.15,94.82 80.57,95.41 80.55,95.41
  BOTTOM w0.099: UC1.N26 117.23,78.51 v1(116.93,78.81)
  BOTTOM w0.102: v1(76.2,94.52) 76.2,95.62 76.77,96.19 77.55,96.19 78.19,96.83 78.26,96.83 78.42,96.99 JDIMM1.53
DDR_A_DQS3: length 60.8
  IN1 w0.099: 101.58,85.7 101.74,85.7 102.52,85.7 103.29,84.93 103.69,84.93 106.24,82.39 106.67,82.39 110.11,78.95 111.22,78.95 112.57,77.59 113.04,77.59 113.2,77.43 113.2,76.52 113.73,76 114.41,76 114.92,75.48 116.47,75.48 116.6,75.35 117.01,75.35 117.24,75.58 119.13,75.58 119.95,76.4 121.23,76.4 121.34,76.51 121.34,76.73 121.16,76.9 120.93,76.9 v1(120.83,76.81)
  IN1 w0.102: 80.55,89.46 80.53,89.46 80.51,89.45 75.46,89.45 74.22,90.69 73.58,90.69 73.27,90.99 73.27,91.32 v1(73.53,91.58)
  IN1 w0.13: 80.55,89.46 94.51,89.46 98.27,85.7 101.58,85.7
  BOTTOM w0.099: UC1.R21 121.23,76.41 v1(120.83,76.81)
  BOTTOM w0.102: v1(73.53,91.58) 73.29,91.33 73.29,91.25 73.06,91.02 72.44,91.02 72.08,91.39 71.92,91.39 71.78,91.24 JDIMM1.76
DDR_A_DQS3#: length 60.9
  IN1 w0.099: v1(121.74,76.8) 121.74,76.46 121.41,76.14 119.97,76.14 119.21,75.38 117.32,75.38 117.1,75.15 116.52,75.15 116.39,75.28 114.84,75.28 114.32,75.8 113.65,75.8 113.01,76.44 113.01,77.34 112.96,77.39 112.49,77.39 111.13,78.75 110.03,78.75 106.59,82.19 106.16,82.19 103.61,84.73 103.21,84.73 102.44,85.5 101.74,85.51 101.67,85.51 101.67,85.5 101.61,85.5 101.6,85.49 101.58,85.49
  IN1 w0.102: v1(72.88,91.61) 73.08,91.41 73.08,90.91 73.5,90.5 74.14,90.5 75.38,89.25 80.51,89.25 80.53,89.24 80.55,89.24
  IN1 w0.13: 80.55,89.24 94.42,89.24 98.17,85.49 101.58,85.49
  BOTTOM w0.099: UC1.P21 v1(121.74,76.8)
  BOTTOM w0.102: JDIMM1.74 71.81,91.74 71.96,91.59 72.16,91.59 72.52,91.23 72.98,91.23 73.09,91.33 73.09,91.4 73.09,91.41 v1(72.88,91.61)
DDR_A_DQS4: length 56.9
  IN1 w0.099: 101.58,57.66 101.6,57.66 101.61,57.67 101.67,57.67 101.67,57.68 101.72,57.68 101.93,57.89 101.93,58.45 102.23,58.76 102.37,58.76 102.59,58.54 102.89,58.54 103.15,58.8 103.15,59.1 102.93,59.32 102.93,59.46 103.07,59.6 103.21,59.6 103.52,59.6 103.77,59.86 103.77,60.16 103.77,60.3 103.98,60.51 104.58,60.51 106.04,61.97 113.15,61.97 113.41,62.23 114.52,62.23 115.09,61.66 115.88,61.66 116.1,61.44 116.52,61.44 116.87,61.79 v1(116.87,61.82)
  IN1 w0.102: v1(76.6,62.57) 76.5,62.57 76.4,62.67 76.4,63.06 76.5,63.17 76.83,63.17 77,62.99 77.54,62.99 77.71,63.17 78.09,63.17 78.32,62.93 78.32,62.79 77.89,62.35 77.89,62.05 78.15,61.8 78.45,61.8 78.88,62.23 79.02,62.23 79.49,61.76 80.51,61.76 80.53,61.75 80.55,61.75
  IN1 w0.13: 101.58,57.66 99.95,57.66 99.7,57.92 99.7,57.98 99.57,58.11 99.31,58.11 99.18,57.98 99.18,57.92 98.92,57.66 98.48,57.66 98.22,57.92 98.22,57.98 98.09,58.11 97.84,58.11 97.71,57.98 97.71,57.92 97.45,57.66 97.01,57.66 96.75,57.92 96.75,57.98 96.62,58.11 96.36,58.11 96.23,57.98 96.23,57.92 95.98,57.66 95.53,57.66 95.28,57.92 95.28,57.98 95.15,58.11 94.89,58.11 94.76,57.98 94.76,57.92 94.5,57.66 94.06,57.66 93.8,57.92 93.8,57.98 93.67,58.11 93.42,58.11 93.29,57.98 93.29,57.92 93.03,57.66 92.59,57.66 92.33,57.92 92.33,57.98 92.2,58.11 91.26,58.11 90.81,57.66 85.03,57.66 84.14,58.55 84.14,59.01 83.91,59.24 83.45,59.24 83.1,59.6 83.1,60.05 82.87,60.28 82.41,60.28 82.05,60.64 82.05,61.1 81.82,61.33 81.36,61.33 80.94,61.75 80.55,61.75
  BOTTOM w0.102: 117.23,62.09 116.97,61.82 v1(116.87,61.82) ; JDIMM1.179 78.15,63.49 78,63.64 76.66,63.64 76.36,63.34 76.36,62.81 v1(76.6,62.57)
  BOTTOM w0.112: UC1.AM26 117.23,62.09
DDR_A_DQS4#: length 56.7
  IN1 w0.099: 101.58,57.88 101.63,57.88 101.73,57.97 101.73,58.53 102.15,58.96 102.45,58.96 102.67,58.74 102.81,58.74 102.95,58.88 102.95,59.02 102.73,59.24 102.73,59.54 102.99,59.8 103.29,59.8 103.3,59.8 103.44,59.8 103.58,59.94 103.58,60.08 103.58,60.38 103.9,60.71 104.5,60.71 105.96,62.16 113.07,62.16 113.33,62.43 114.6,62.43 115.17,61.86 116.19,61.86 116.22,61.82 v1(116.25,61.82)
  IN1 w0.102: 80.55,61.97 80.53,61.97 80.51,61.95 79.57,61.95 79.1,62.42 78.8,62.42 78.37,61.99 78.23,61.99 78.08,62.13 78.08,62.28 78.51,62.71 78.51,63.01 78.17,63.36 77.64,63.36 77.46,63.18 77.08,63.18 76.9,63.36 76.42,63.36 76.21,63.14 76.21,62.73 76.05,62.57 v1(75.88,62.57)
  IN1 w0.13: 80.55,61.97 81.03,61.97 81.45,61.54 81.91,61.54 82.27,61.19 82.27,60.73 82.5,60.5 82.96,60.5 83.31,60.15 83.31,59.69 83.54,59.46 84,59.46 84.36,59.1 84.36,58.64 85.12,57.88 90.71,57.88 91.17,58.33 92.29,58.33 92.55,58.07 92.55,58.01 92.68,57.88 92.94,57.88 93.07,58.01 93.07,58.07 93.33,58.33 93.77,58.33 94.02,58.07 94.02,58.01 94.15,57.88 94.41,57.88 94.54,58.01 94.54,58.07 94.8,58.33 95.24,58.33 95.5,58.07 95.5,58.01 95.63,57.88 95.88,57.88 96.01,58.01 96.01,58.07 96.27,58.33 96.71,58.33 96.97,58.07 96.97,58.01 97.1,57.88 97.36,57.88 97.49,58.01 97.49,58.07 97.74,58.33 98.19,58.33 98.44,58.07 98.44,58.01 98.57,57.88 98.83,57.88 98.96,58.01 98.96,58.07 99.22,58.33 99.66,58.33 99.92,58.07 99.92,58.01 100.05,57.88 101.58,57.88
  BOTTOM w0.102: v1(116.25,61.82) 116.28,61.82 116.53,62.07 UC1.AM27 ; v1(75.88,62.57) 76.16,62.85 76.16,63.42 76.57,63.84 78,63.84 78.15,63.99 JDIMM1.177
DDR_A_DQS5: length 59.6
  IN1 w0.099: v1(119.23,60.81) 119.1,60.65 119.1,60.42 118.84,60.16 118.13,60.16 117.99,60.01 117.99,59.55 117.66,59.23 117.48,59.23 116.51,58.26 112.87,58.26 112.31,58.82 111.98,58.82 111.77,58.6 111.31,58.6 111.09,58.82 106.71,58.82 106.4,58.51 106.4,56.41 102.98,52.99 101.58,52.99 101.57,52.98
  IN1 w0.13: v1(73.14,57.95) 73.17,57.95 73.35,57.77 73.35,56.81 73.66,56.5 74.97,56.5 75.23,56.76 75.23,57.16 75.36,57.29 75.67,57.29 75.8,57.16 75.8,56.86 76.06,56.6 76.5,56.6 76.75,56.86 76.75,57.16 76.88,57.29 77.59,57.29 80.33,54.55 81.52,54.55 83.09,52.98 101.57,52.98
  BOTTOM w0.099: v1(119.23,60.81) 118.83,61.21 UC1.AN24
  BOTTOM w0.102: v1(73.14,57.95) 73.31,58.13 73.31,58.27 73.19,58.4 71.99,58.4 71.83,58.24 70.95,58.24 JDIMM1.200
DDR_A_DQS5#: length 59.5
  IN1 w0.099: v1(118.55,60.76) 118.72,60.77 118.88,60.66 118.89,60.5 118.75,60.35 118.05,60.35 117.79,60.09 117.79,59.64 117.58,59.43 117.4,59.43 116.43,58.46 112.95,58.46 112.4,59.02 111.9,59.02 111.68,58.8 111.39,58.8 111.17,59.02 106.63,59.02 106.2,58.59 106.2,56.49 102.9,53.19 101.59,53.19 101.58,53.2
  IN1 w0.13: 101.58,53.2 83.18,53.2 81.61,54.77 80.42,54.77 77.68,57.51 76.79,57.51 76.54,57.25 76.54,56.95 76.41,56.82 76.15,56.82 76.02,56.95 76.02,57.25 75.76,57.51 75.27,57.51 75.01,57.25 75.01,56.85 74.88,56.72 73.75,56.72 73.57,56.9 73.57,57.8 v1(73.73,57.95)
  BOTTOM w0.099: v1(118.55,60.76) 118.03,61.28 UC1.AN25
  BOTTOM w0.102: v1(73.73,57.95) 73.51,58.17 73.51,58.35 73.27,58.6 71.97,58.6 71.83,58.74 JDIMM1.198
DDR_A_DQS6: length 60.3
  IN1 w0.099: v1(118.86,57.69) 118.91,57.64 119.06,57.64 119.16,57.74 119.16,58 119.06,58.09 118.69,58.09 118.46,57.86 118.46,57.39 118.43,57.37 118.43,56.06 117.05,54.68 113.85,54.68 113.48,54.31 112.64,54.31 112.55,54.21 112.55,54.02 112.33,53.81 111.76,53.81 111.54,54.02 111.54,54.21 111.44,54.31 110.22,54.31 110.12,54.21 110.12,53.07 110.66,52.54 110.66,52.24 110.26,51.84 109.97,51.84 109.45,52.36 109.27,52.36 108.6,51.68 106.5,51.68 103.15,48.34 101.61,48.34 101.6,48.32 101.58,48.32
  IN1 w0.102: 80.4,48.99 80.38,49.01 80.38,49.03 77.58,51.82 75.48,51.82 75.41,51.75 75.41,51.6 75.7,51.3 v1(75.79,51.3)
  IN1 w0.13: 101.58,48.32 81.07,48.32 80.4,48.99
  BOTTOM w0.099: v1(118.86,57.69) 118.86,58.01 118.96,58.11 UC1.AU23
  BOTTOM w0.122: JDIMM1.221 78.55,52.99 78.39,53.14 78.14,53.14 77.6,52.61 76.08,52.61 75.6,52.13 75.6,51.5 v1(75.79,51.3)
DDR_A_DQS6#: length 60.3
  IN1 w0.099: 101.58,48.54 101.6,48.56 101.64,48.56 101.67,48.53 103.07,48.53 106.41,51.88 108.51,51.88 109.19,52.56 109.53,52.56 110.05,52.04 110.18,52.04 110.46,52.32 110.46,52.45 109.93,52.99 109.93,54.29 110.14,54.5 111.53,54.5 111.74,54.29 111.74,54.1 111.84,54 112.25,54 112.35,54.1 112.35,54.29 112.56,54.5 113.39,54.5 113.76,54.88 116.95,54.88 118.24,56.16 118.24,57.45 118.26,57.48 118.26,57.94 118.61,58.29 118.91,58.29 119.27,58.66 v1(119.29,58.66)
  IN1 w0.102: v1(75.14,51.33) 75.14,51.8 75.35,52.01 77.66,52.01 80.52,49.16 80.53,49.16 80.55,49.14
  IN1 w0.13: 101.58,48.54 81.16,48.54 80.55,49.14
  BOTTOM w0.099: UC1.AT23 119.11,59.18 119.11,59.04 119.18,58.97 119.18,58.77 v1(119.29,58.66)
  BOTTOM w0.122: JDIMM1.219 78.55,53.49 78.42,53.37 78.05,53.37 77.51,52.83 75.98,52.83 75.38,52.22 75.38,51.57 v1(75.14,51.33)
DDR_A_DQS7: length 67.4
  IN1 w0.099: 101.58,43.66 101.82,43.66 103.04,44.89 104.75,44.89 104.85,44.79 104.85,44.57 105.07,44.35 105.62,44.35 105.83,44.56 105.83,44.79 105.93,44.89 107.37,44.89 110.6,48.13 111.68,48.13 112.16,47.66 112.45,47.66 112.81,48.02 112.81,48.31 112.49,48.64 112.49,48.78 112.8,49.09 112.93,49.09 113.49,48.53 113.79,48.53 114.07,48.81 114.07,49.22 113.57,49.72 113.57,49.86 113.7,49.98 114.04,49.98 114.49,49.53 114.8,49.53 114.9,49.63 118.37,49.63 121.85,53.12 121.85,53.49 121.85,53.7 121.85,54.23 121.85,55.28 121.85,55.79 122.41,56.34 122.41,57.18 121.83,57.76 v1(121.78,57.76)
  IN1 w0.102: v1(73.18,47.41) 73.26,47.32 73.26,46.87 73.6,46.53 75.1,46.53 75.85,45.78 77.61,45.78 79.73,43.66 80.55,43.66
  IN1 w0.13: 101.58,43.66 80.55,43.66
  BOTTOM w0.099: v1(121.78,57.76) UC1.AV20
  BOTTOM w0.102: v1(73.18,47.41) 73.41,47.64 73.41,47.78 73.31,47.88 71.86,47.88 71.72,47.74 JDIMM1.242
DDR_A_DQS7#: length 67.2
  IN1 w0.099: 101.58,43.88 101.75,43.88 102.96,45.09 104.84,45.09 105.05,44.87 105.05,44.65 105.15,44.55 105.54,44.55 105.63,44.64 105.63,44.87 105.85,45.09 107.28,45.09 110.52,48.33 111.77,48.33 112.24,47.85 112.37,47.85 112.62,48.1 112.62,48.23 112.29,48.56 112.29,48.86 112.72,49.28 113.01,49.28 113.57,48.73 113.71,48.73 113.87,48.89 113.87,49.13 113.37,49.63 113.37,49.94 113.61,50.18 114.12,50.18 114.58,49.73 114.72,49.73 114.82,49.83 118.29,49.83 121.66,53.2 121.66,53.9 121.66,53.99 121.66,54.15 121.66,55.2 121.66,55.87 122.21,56.43 122.21,57.1 122.08,57.24 121.87,57.24 121.77,57.14 121.77,56.98 v1(121.79,56.95)
  IN1 w0.102: 80.55,43.88 79.78,43.88 77.69,45.97 75.93,45.97 75.18,46.72 73.68,46.72 73.45,46.95 73.45,47.14 73.54,47.23 73.54,47.3 73.68,47.44 73.86,47.44 v1(73.9,47.41)
  IN1 w0.13: 80.55,43.88 101.58,43.88
  BOTTOM w0.099: v1(121.79,56.95) 122.14,56.61 UC1.AW20
  BOTTOM w0.102: JDIMM1.240 71.74,48.24 71.9,48.08 73.39,48.08 73.61,47.86 73.61,47.55 73.75,47.41 v1(73.9,47.41)
DDR_A_EVENT#: length 59.3
  TOP w0.099: RC2.2 119.72,68.19 118.75,68.19 v1(118.43,67.87)
  IN1 w0.099: 101.58,68.82 103.7,68.82 104.57,67.95 111.98,67.95 112.75,67.19 114.33,67.19 114.7,67.56 115.96,67.56 116.05,67.47 116.38,67.47 116.41,67.5 117.36,67.5 117.49,67.37 117.81,67.37 118.31,67.87 v1(118.43,67.87)
  IN1 w0.102: 69.63,74.86 76.01,74.86 76.39,74.48 78.96,74.48 80.22,73.23 80.55,73.23
  IN1 w0.109: v1(68.61,75.5) 69.25,74.86 69.63,74.86 ; 101.58,68.82 88.72,68.82 84.32,73.23 80.55,73.23
  BOTTOM w0.1: UC1.AE24 118.83,68.21 118.5,67.87 v1(118.43,67.87)
  BOTTOM w0.102: 69.63,76.64 69.73,76.74 JDIMM1.134
  BOTTOM w0.104: v1(68.61,75.5) 68.61,76.07 69.19,76.64 69.63,76.64
DDR_A_MA0: length 52
  IN1 w0.099: v1(118.45,66.94) 118.39,66.94 118.35,66.97 117.47,66.97 116.92,66.42 116.61,66.42 116.18,66.86 115.82,66.86 115.71,66.96 114.95,66.96 114.58,66.59 112.15,66.59 111.65,67.09 104.59,67.09 104.45,67.23 101.41,67.23
  IN1 w0.188: 101.41,67.23 87.86,67.23 83.46,71.64 79.66,71.64 78.98,72.32 75.71,72.32 v1(75.09,72.93)
  BOTTOM w0.1: UC1.AF25 118.03,67.13 118.27,66.89 118.41,66.89 v1(118.45,66.94)
  BOTTOM w0.168: v1(75.09,72.93) 73.79,74.24 JDIMM1.144
DDR_A_MA1: length 52.1
  IN1 w0.099: v1(119.32,68.83) 118.87,68.83 118.63,69.07 118.32,69.07 118.23,69.16 117.01,69.16 116.89,69.04 115.76,69.04 115.67,69.14 114.84,69.14 114.64,68.93 112.94,68.93 111.46,70.41 103.85,70.41 101.91,72.35 101.58,72.35
  IN1 w0.188: 101.58,72.35 93.34,72.35 89.15,76.54 78.4,76.54 77.78,77.15 76.54,77.15 v1(75.73,77.96)
  BOTTOM w0.1: v1(119.32,68.83) 119.32,68.62 UC1.AE23
  BOTTOM w0.168: v1(75.73,77.96) 76.7,76.99 JDIMM1.133
DDR_A_MA2: length 50.4
  IN1 w0.099: v1(116.26,69.85) 116.14,69.73 114.53,69.73 114.15,70.11 112.69,70.11 110.82,71.98 103.58,71.98 101.43,74.12
  IN1 w0.188: v1(73.12,77.91) 73.12,77.94 73.94,78.76 78.66,78.76 79.15,78.27 89.99,78.27 94.13,74.12 101.43,74.12
  BOTTOM w0.1: v1(116.26,69.85) 116.26,69.58 UC1.AD27
  BOTTOM w0.168: JDIMM1.132 72.45,77.24 v1(73.12,77.91)
DDR_A_MA3: length 51.6
  IN1 w0.099: v1(120.83,67.81) 120.83,68.43 120.06,69.2 118.77,69.2 118.71,69.27 118.41,69.27 118.31,69.36 116.93,69.36 116.81,69.24 115.84,69.24 115.75,69.34 114.36,69.34 113.99,69.71 112.44,69.71 111.12,71.03 103.51,71.03 101.74,72.79 101.58,72.79
  IN1 w0.188: 101.58,72.79 93.76,72.79 89.57,76.98 78.65,76.98 78.19,77.44 77.54,77.44 v1(76.98,78)
  BOTTOM w0.1: UC1.AE21 121.23,68.21 v1(120.83,67.81)
  BOTTOM w0.168: JDIMM1.131 77.49,77.49 v1(76.98,78)
DDR_A_MA4: length 52.8
  IN1 w0.099: 101.72,73.24 103.56,71.39 111.03,71.39 112.52,69.91 114.07,69.91 114.45,69.53 115.83,69.53 115.92,69.44 116.73,69.44 116.85,69.56 118.06,69.56 118.27,69.77 v1(118.51,69.77)
  IN1 w0.188: v1(74.27,77.91) 74.82,78.47 77.77,78.47 78.35,77.88 78.35,77.85 78.78,77.42 89.91,77.42 94.09,73.24 101.72,73.24
  BOTTOM w0.1: UC1.AC24 118.51,69.99 v1(118.51,69.77)
  BOTTOM w0.168: v1(74.27,77.91) 74.27,77.99 73.67,78.58 72.36,78.58 72.02,78.24 JDIMM1.128
DDR_A_MA5: length 52
  IN1 w0.099: v1(116.99,70.81) 116.99,70.82 116.62,71.19 116.1,71.19 116.05,71.14 114.8,71.14 114.22,71.71 112.46,71.71 110.14,74.04 103.31,74.04 102.59,74.76 102.59,75.3 101.88,76.01 101.88,76.39 101.58,76.69
  IN1 w0.188: v1(72.78,79.18) 73.8,80.2 78.26,80.2 78.52,80.46 90.45,80.46 94.23,76.69 101.58,76.69
  BOTTOM w0.1: v1(116.99,70.81) 117.05,70.81 117.23,70.63 UC1.AC26
  BOTTOM w0.168: v1(72.78,79.18) 72.24,79.18 71.79,78.74 JDIMM1.126
DDR_A_MA6: length 54
  IN1 w0.099: v1(120.83,69.81) 120.29,70.34 117.12,70.34 117.02,70.44 116.1,70.44 115.79,70.74 114.6,70.74 114.36,70.51 113.11,70.51 110.23,73.39 103.39,73.39 102.02,74.76 102.02,75.05 101.63,75.45 101.34,75.45 101.29,75.5
  IN1 w0.188: 101.29,75.5 94.01,75.5 90.36,79.15 79.09,79.15 78.62,79.62 76.23,79.62 v1(75.79,79.18)
  BOTTOM w0.1: v1(120.83,69.81) 121.23,69.41 UC1.AD21
  BOTTOM w0.168: v1(75.79,79.18) 75.86,79.18 76.47,78.57 78.12,78.57 78.2,78.49 JDIMM1.127
DDR_A_MA7: length 51.4
  IN1 w0.099: 101.58,76.05 101.63,76.05 101.63,75.97 101.65,75.96 101.68,75.96 101.68,75.93 102.39,75.22 102.39,74.68 103.37,73.69 110.2,73.69 113.19,70.7 114.28,70.7 114.52,70.94 116.17,70.94 v1(116.3,70.81)
  IN1 w0.188: 101.58,76.05 101.54,76.09 94.04,76.09 90.11,80.02 84.87,80.02 84.44,79.59 79.45,79.59 79.13,79.91 74.65,79.91 74.11,79.37 74.11,79.21 v1(74.08,79.18)
  BOTTOM w0.1: v1(116.3,70.81) 116.3,70.81 116.3,70.8 116.31,70.8 116.53,70.57 UC1.AC27
  BOTTOM w0.168: v1(74.08,79.18) 74.08,79.19 73.42,79.85 72.74,79.85 72.64,79.75 72.14,79.75 72.12,79.74 JDIMM1.122
DDR_A_MA8: length 50
  IN1 w0.099: 101.58,74.72 101.59,74.72 103.31,73 110.33,73 113.03,70.31 114.23,70.31 114.61,69.93 115.44,69.93 115.75,70.24 116.94,70.24 117.03,70.15 119.8,70.15 120.03,69.91 v1(120.03,69.81)
  IN1 w0.188: v1(77.06,79.18) 78.65,79.18 79.12,78.71 90.17,78.71 93.98,74.9 101.4,74.9 101.58,74.72
  BOTTOM w0.1: UC1.AD22 120.43,69.41 v1(120.03,69.81)
  BOTTOM w0.168: v1(77.06,79.18) 77.1,79.22 77.34,79.22 77.52,79.05 78.31,79.05 78.37,78.99 JDIMM1.125
DDR_A_MA9: length 54.1
  IN1 w0.099: v1(120.83,70.81) 120.83,70.87 120.51,71.18 119.79,71.18 119.64,71.33 118.5,71.33 118.4,71.43 116.94,71.43 116.78,71.59 115.94,71.59 115.88,71.53 114.96,71.53 114.39,72.11 112.63,72.11 110.2,74.53 103.37,74.53 103.06,74.85 103.06,75.67 102.65,76.08 102.65,77.65 101.83,78.47 101.58,78.47
  IN1 w0.188: 101.58,78.47 93.69,78.47 90.82,81.34 78.58,81.34 78.47,81.24 76.97,81.24 76.51,80.77 v1(76.51,80.77)
  BOTTOM w0.1: v1(120.83,70.81) 121.23,70.41 UC1.AC21
  BOTTOM w0.168: JDIMM1.121 77.52,79.99 77.48,80.04 77.21,80.04 76.51,80.74 v1(76.51,80.77)
DDR_A_MA10: length 54.3
  IN1 w0.099: 102.25,66.46 111.08,66.46 111.34,66.2 114.49,66.2 114.81,65.87 115.42,65.87 115.78,66.23 116.24,66.23 116.45,66.03 117.09,66.03 117.64,66.58 117.96,66.58 118.19,66.35 119.56,66.35 120.01,66.81 v1(120.03,66.81)
  IN1 w0.188: 102.25,66.46 102.14,66.35 87.49,66.35 83.55,70.29 79.67,70.29 78.22,71.74 73.76,71.74 v1(72.55,72.94)
  BOTTOM w0.1: v1(120.03,66.81) 120.43,67.21 UC1.AF22
  BOTTOM w0.168: JDIMM1.146 71.77,71.74 72.55,72.52 v1(72.55,72.94)
DDR_A_MA11: length 55.9
  IN1 w0.099: v1(118.43,71.82) 118.26,71.82 117.88,72.2 117.45,72.2 117.23,71.98 115.71,71.98 115.66,71.93 115.12,71.93 114.55,72.5 112.79,72.5 111.24,74.06 111.24,75.12 110.65,75.72 103.57,75.72 103.21,76.08 103.14,76.15 103.12,76.17 103.12,77.82 101.82,79.12 101.82,79.48 101.73,79.58 101.58,79.58
  IN1 w0.188: 101.58,79.58 94.15,79.58 91.11,82.63 80.14,82.63 79.66,82.14 76.06,82.14 75.68,81.76 v1(75.68,81.71)
  BOTTOM w0.1: UC1.AA24 118.83,71.36 118.43,71.76 v1(118.43,71.82)
  BOTTOM w0.168: 74.71,80.32 72.54,80.32 72.46,80.24 JDIMM1.120
  BOTTOM w0.183: 74.71,80.32 75.68,81.29 v1(75.68,81.71)
DDR_A_MA12: length 48.9
  IN1 w0.099: 101.58,77.28 101.83,77.28 102.18,76.93 102.18,75.99 102.82,75.35 102.82,74.8 103.31,74.32 110.14,74.32 112.54,71.91 114.3,71.91 114.88,71.34 115.97,71.34 116.02,71.39 116.7,71.39 116.85,71.24 118.31,71.24 118.63,70.92 v1(119.26,70.92)
  IN1 w0.188: v1(77.75,80.77) 77.79,80.77 77.8,80.76 78.41,80.76 78.55,80.9 90.64,80.9 94.26,77.28 101.58,77.28
  BOTTOM w0.1: v1(119.26,70.92) 119.29,70.92 119.63,70.57 UC1.AC23
  BOTTOM w0.168: JDIMM1.119 77.99,80.49 77.75,80.73 v1(77.75,80.77)
DDR_A_MA13: length 53.7
  IN1 w0.099: v1(118.43,64.7) 118.43,64.4 118.12,64.09 115.99,64.09 115.59,63.69 113.93,63.69 113.69,63.94 105.81,63.94 104.34,62.47 102.74,62.47 101.54,61.27
  IN1 w0.188: v1(72.3,68.7) 73.12,67.88 74.33,67.88 75.91,66.3 78.96,66.3 80.55,64.7 82.63,64.7 86.7,60.63 89.56,60.63 90.2,61.27 101.54,61.27
  BOTTOM w0.102: UC1.AJ25 118.03,65.21 118.43,64.81 v1(118.43,64.7)
  BOTTOM w0.168: JDIMM1.158 72.1,68.74 72.13,68.7 v1(72.3,68.7)
DDR_A_MA14_WE#: length 49.2
  IN1 w0.099: 101.5,65.36 102.11,65.98 102.25,65.98 102.45,65.77 102.59,65.77 102.69,65.87 102.69,66.16 102.79,66.26 103.19,66.26 103.22,66.23 104.24,66.23 104.49,65.97 113.47,65.97 113.57,65.87 113.57,65.77 113.67,65.67 113.87,65.67 113.97,65.77 113.97,65.87 114.07,65.97 114.4,65.97 114.69,65.67 115.91,65.67 v1(116.09,65.85)
  IN1 w0.188: v1(77.6,70.5) 77.52,70.5 77.07,70.94 77.07,71.26 77.26,71.45 78.1,71.45 79.05,70.49 79.05,70.08 79.43,69.69 83.31,69.69 87.64,65.36 87.95,65.36 88.14,65.55 88.14,65.57 88.33,65.75 88.71,65.75 88.89,65.57 88.89,65.55 89.08,65.36 89.46,65.36 89.64,65.55 89.64,65.57 89.83,65.75 90.21,65.75 90.4,65.57 90.4,65.55 90.58,65.36 90.96,65.36 91.15,65.55 91.15,65.57 91.34,65.75 91.71,65.75 91.9,65.57 91.9,65.55 92.09,65.36 92.46,65.36 92.65,65.55 92.65,65.57 92.84,65.75 93.22,65.75 93.4,65.57 93.4,65.55 93.59,65.36 93.97,65.36 94.16,65.55 94.16,65.57 94.34,65.75 94.72,65.75 94.91,65.57 94.91,65.55 95.1,65.36 95.47,65.36 95.66,65.55 95.66,65.57 95.85,65.75 96.22,65.75 96.41,65.57 96.41,65.55 96.6,65.36 96.98,65.36 97.16,65.55 97.16,65.57 97.35,65.75 97.73,65.75 97.92,65.57 97.92,65.55 98.1,65.36 98.48,65.36 98.67,65.55 98.67,65.57 98.86,65.75 99.23,65.75 99.42,65.57 99.42,65.55 99.61,65.36 101.5,65.36
  BOTTOM w0.1: UC1.AG27 116.09,65.86 v1(116.09,65.85)
  BOTTOM w0.168: v1(77.6,70.5) 77.6,70.49 JDIMM1.151
DDR_A_MA15_CAS#: length 53
  IN1 w0.099: 100.53,62.9 100.57,62.86 101.49,62.86 102.12,63.49 104.2,63.49 105.25,64.53 114.64,64.53 114.99,64.88 116.49,64.88 116.69,65.09 117.2,65.09 117.22,65.07 117.77,65.07 118.03,65.32 118.78,65.32 119.23,65.78 v1(119.23,65.78)
  IN1 w0.188: 100.53,62.9 86.74,62.9 82.96,66.68 80.09,66.68 77.88,68.89 73.67,68.89 v1(73.52,68.74)
  BOTTOM w0.1: v1(119.23,65.78) 119.23,65.78 119.63,66.18 UC1.AG23
  BOTTOM w0.183: JDIMM1.156 73.02,69.24 v1(73.52,68.74)
DDR_A_MA16_RAS#: length 51.2
  IN1 w0.099: v1(117.71,65.83) 117.66,65.83 117.31,65.48 116.53,65.48 116.32,65.28 114.06,65.28 113.71,64.93 104.95,64.93 104.47,64.45 101.81,64.45 101.49,64.13
  IN1 w0.188: 101.49,64.13 87.19,64.13 83.05,68.27 79.55,68.27 78.35,69.47 76.73,69.47 v1(75.66,70.54)
  BOTTOM w0.1: v1(117.71,65.83) UC1.AG26
  BOTTOM w0.183: JDIMM1.152 72.92,70.24 73.21,69.95 75.15,69.95 75.66,70.45 v1(75.66,70.54)
DDR_A_ODT0: length 49.8
  IN1 w0.099: v1(118.4,65.9) 118.36,65.9 117.88,66.38 117.72,66.38 117.04,65.7 116.46,65.7 116.24,65.48 113.33,65.48 113.13,65.68 112.43,65.68 111.96,65.21 102.99,65.21 102.79,65.41 102.19,65.41 101.55,64.77
  IN1 w0.188: 101.55,64.77 87.39,64.77 83.3,68.86 79.37,68.86 78.47,69.76 77.05,69.76 76.28,70.54 v1(76.28,70.54)
  BOTTOM w0.1: v1(118.4,65.9) 118.4,65.9 118.81,66.31 UC1.AG24
  BOTTOM w0.168: JDIMM1.155 78.98,69.49 78.95,69.46 77.16,69.46 76.28,70.35 v1(76.28,70.54)
DDR_A_ODT1: length 54
  IN1 w0.099: 101.54,61.86 102.39,62.72 104.17,62.72 105.59,64.14 113.77,64.14 114.01,63.89 115.47,63.89 115.86,64.29 117.8,64.29 118.05,64.55 118.05,64.85 118.27,65.08 118.81,65.08 118.98,65.25 119.59,65.25 v1(120.03,64.81)
  IN1 w0.188: v1(75.93,68.39) 75.93,67.28 76.63,66.58 79.08,66.58 80.37,65.3 82.87,65.3 86.95,61.22 89.3,61.22 89.94,61.86 101.54,61.86
  BOTTOM w0.1: UC1.AJ22 120.43,65.21 v1(120.03,64.81)
  BOTTOM w0.168: JDIMM1.161 76.33,67.99 v1(75.93,68.39)
DDR_A_PAR: length 52.8
  IN1 w0.099: 101.58,68.27 103.97,68.27 104.59,67.65 111.9,67.65 112.56,66.99 114.41,66.99 114.79,67.36 115.87,67.36 115.96,67.27 116.46,67.27 116.5,67.3 117.28,67.3 117.41,67.17 117.89,67.17 118.21,67.5 118.71,67.5 118.99,67.78 v1(119.25,67.78)
  IN1 w0.102: v1(74.93,74.42) 75.51,73.85 78.94,73.85 80.11,72.67 80.55,72.67
  IN1 w0.188: 101.58,68.27 88.49,68.27 84.09,72.67 80.55,72.67
  BOTTOM w0.102: v1(119.25,67.78) 119.25,67.73 UC1.AF24 ; JDIMM1.143 74.93,74.49 v1(74.93,74.42)
DDR_A_RST#: length 58.7
  TOP w0.102: v1(72.24,83.24) 72.23,83.23 CD1.1
  IN1 w0.099: v1(118.59,73.78) 118.55,73.74 117.47,73.74 117.05,74.16 116.39,74.16 115.96,73.73 114.46,73.73 113.9,74.29 113.75,74.29 113.65,74.4 112.76,74.4 112.43,74.73 112.43,75.45 112.43,75.62 111.08,76.97 111.08,77.27 110.64,77.71 105.95,77.71 103.35,80.32 103.35,81.18 102.11,82.42 102.11,82.69 101.59,83.21 101.58,83.21
  IN1 w0.102: v1(72.24,83.24) 72.24,83.91 74.74,86.41 80.55,86.41
  IN1 w0.109: 80.55,86.41 92.48,86.41 95.68,83.21 101.58,83.21
  BOTTOM w0.1: UC1.Y24 118.83,72.81 118.69,72.95 118.48,73.16 118.48,73.16 118.46,73.18 118.46,73.65 v1(118.59,73.78)
  BOTTOM w0.102: v1(72.24,83.24) JDIMM1.108
DDR_B_ACT#: length 62.9
  IN3 w0.102: v1(60.34,81.44) 61.41,82.51 69.89,82.51 72.22,80.17 78.58,80.17 79.47,79.28 81.11,79.28 81.3,79.08
  IN3 w0.183: 81.3,79.08 97.1,79.08 99.62,76.57 107.76,76.57 108.08,76.89 v1(108.08,77.13)
  BOTTOM w0.099: v1(108.08,77.13) 108.87,77.92 110.62,77.92 112.16,76.38 112.16,74.82 112.78,74.2 113.63,74.2 113.63,74.18 113.81,74.01 114.06,74.01 114.36,74.31 UC1.V30
  BOTTOM w0.168: v1(60.34,81.44) 60.03,81.74 JDIMM2.114
DDR_B_ALERT#: length 62.3
  IN3 w0.102: 82.26,77.94 80.84,77.94 80.55,78.22 79.5,78.22 78.1,79.62 71.6,79.62 70.05,81.17 64.84,81.17 64.63,80.96 62.22,80.96 v1(61.7,81.47)
  IN3 w0.107: v1(103.86,75.33) 103.71,75.33 103.61,75.43 99.15,75.43 96.63,77.94 82.26,77.94
  BOTTOM w0.099: UC1.W30 114.36,73.31 114.06,73.01 113.13,73.01 111.57,74.57 111.57,75.85 110.9,76.52 105.05,76.52 v1(103.86,75.33)
  BOTTOM w0.102: v1(61.7,81.47) 61.26,81.02 59.91,81.02 59.7,81.24 JDIMM2.116
DDR_B_BA0: length 62.1
  IN3 w0.102: 81.24,69.58 79.05,69.58 77.45,71.18 72.3,71.18 71.03,72.45 70.65,72.45 70.43,72.67 66.2,72.67 65.54,73.34 62.8,73.34 v1(62.39,72.93)
  IN3 w0.183: 81.24,69.58 93.72,69.58 95.79,67.51 107.34,67.51 108.14,66.71 v1(108.14,65.59)
  BOTTOM w0.099: UC1.AH31 113.65,65.81 113.32,66.13 112.91,66.13 112.41,66.63 108.83,66.63 108.14,65.93 v1(108.14,65.59)
  BOTTOM w0.168: JDIMM2.150 59.21,70.74 60.12,71.65 61.22,71.65 62.39,72.83 v1(62.39,72.93)
DDR_B_BA1: length 57.7
  IN3 w0.102: v1(63.69,72.93) 65.65,72.93 66.35,72.23 70.58,72.23 72.72,70.1 78.12,70.1 79.07,69.14 80.55,69.14
  IN3 w0.183: v1(106.97,65.59) 106.97,66.34 106.24,67.07 95.61,67.07 93.54,69.14 80.55,69.14
  BOTTOM w0.099: UC1.AG32 113.84,66.4 112.92,66.4 112.5,66.83 108.01,66.83 106.97,65.78 v1(106.97,65.59)
  BOTTOM w0.168: JDIMM2.145 64.64,71.99 v1(63.69,72.93)
DDR_B_BG0: length 64.2
  IN3 w0.102: 80.95,83.01 73,83.01 72.4,83.62 71.29,83.62 69.68,85.23 63.56,85.23 v1(62.12,83.79)
  IN3 w0.183: v1(110.44,77.09) 110.42,77.12 110.42,77.57 108.86,79.13 100.68,79.13 98.17,81.65 82.31,81.65 80.95,83.01
  BOTTOM w0.099: UC1.V31 114.23,73.9 114.14,73.81 113.72,73.81 113.53,74 112.7,74 111.96,74.73 111.96,76.3 111.21,77.05 110.49,77.05 v1(110.44,77.09)
  BOTTOM w0.168: JDIMM2.115 64.16,81.49 62.12,83.53 v1(62.12,83.79)
DDR_B_BG1: length 62.5
  IN3 w0.102: v1(63.31,83.73) 63.31,84.23 63.95,84.87 69.53,84.87 71.8,82.6 80.4,82.6 80.42,82.62
  IN3 w0.183: v1(109.25,77.13) 107.69,78.69 100.5,78.69 97.98,81.21 82.13,81.21 80.72,82.62 80.42,82.62
  BOTTOM w0.099: v1(109.25,77.13) 109.25,77.02 109.55,76.72 111.26,76.72 111.76,76.22 111.76,74.65 112.61,73.8 113.45,73.8 113.64,73.61 114.05,73.61 114.16,73.51 114.21,73.51 114.47,73.51 114.77,73.81 UC1.V29
  BOTTOM w0.168: v1(63.31,83.73) 63.31,83.38 64.7,81.99 JDIMM2.113
DDR_B_CKE0: length 59.6
  IN3 w0.102: 80.59,81.39 79.41,81.39 78.48,82.32 72.98,82.32 72.49,81.83 71.95,81.83 69.75,84.04 66.63,84.04 66.53,84.13 64.96,84.13 v1(64.62,83.79)
  IN3 w0.183: v1(106.91,77.12) 106.91,77.19 106,78.1 100.26,78.1 97.74,80.62 81.89,80.62 81.63,80.88 81.47,80.88 80.96,81.39 80.59,81.39
  BOTTOM w0.099: v1(106.91,77.12) 107.91,78.12 110.71,78.12 112.36,76.46 112.36,74.9 112.86,74.4 113.6,74.4 113.81,74.61 114.1,74.61 114.21,74.51 114.46,74.51 114.63,74.68 114.63,74.68 114.76,74.81 UC1.U29
  BOTTOM w0.168: JDIMM2.109 64.84,82.99 64.62,83.21 v1(64.62,83.79)
DDR_B_CKE1: length 64.1
  IN3 w0.102: 80.59,80.95 78.43,80.95 78.24,81.15 74.52,81.15 74.39,81.02 72.24,81.02 69.62,83.64 66.79,83.64 66.2,83.06 61.25,83.06 60.98,83.32 v1(60.98,83.73)
  IN3 w0.183: v1(105.75,77.12) 105.75,77.21 105.29,77.67 100.08,77.67 97.56,80.19 81.7,80.19 81.44,80.45 81.29,80.45 80.78,80.95 80.59,80.95 80.59,80.95
  BOTTOM w0.099: UC1.T30 114.37,75.31 113.87,74.81 113.72,74.81 113.51,74.59 112.94,74.59 112.56,74.98 112.56,76.54 110.79,78.31 106.94,78.31 v1(105.75,77.12)
  BOTTOM w0.168: JDIMM2.110 60.57,82.74 60.98,83.15 v1(60.98,83.73)
DDR_B_CLK0: length 60.3
  IN3 w0.102: 80.62,72.22 80.59,72.22 80.55,72.19 79.07,72.19 77.61,73.66 71.98,73.66 70.89,74.75 68.47,74.75 68.11,75.12 64.95,75.12 64.85,75.22 64.85,75.46 64.75,75.56 64.55,75.56 64.45,75.46 64.45,75.24 64.32,75.12 64.09,75.12 63.75,75.46 63.75,75.81 64.23,76.29 v1(64.28,76.29)
  IN3 w0.178: 80.62,72.22 94.66,72.22 97.01,69.87 107.13,69.87 107.46,70.2 110.27,70.2 110.66,69.81 110.66,69.43 v1(110.92,69.18)
  BOTTOM w0.099: UC1.AC31 114.2,69.81 114.2,69.81 114.14,69.81 113.5,69.81 113.39,69.91 112.61,69.91 112.21,69.51 112.21,68.98 111.96,68.73 111.5,68.73 111.36,68.88 111.19,68.88 111.04,68.73 110.75,68.73 110.65,68.83 110.65,68.97 110.86,69.18 v1(110.92,69.18)
  BOTTOM w0.163: JDIMM2.137 66.45,75.99 65.81,75.99 65.69,75.88 65.31,75.88 64.95,75.52 64.52,75.52 64.17,75.87 64.17,76.19 v1(64.28,76.29)
DDR_B_CLK0#: length 60.4
  IN3 w0.102: 80.62,71.93 80.59,71.93 80.55,71.97 78.99,71.97 77.52,73.44 71.89,73.44 70.8,74.53 68.38,74.53 68.02,74.9 64,74.9 63.53,75.37 63.53,75.9 63.69,76.06 v1(63.69,76.29)
  IN3 w0.178: 80.62,71.93 94.54,71.93 96.89,69.58 107.23,69.58 107.57,69.93 110.15,69.93 110.33,69.75 v1(110.33,69.18)
  BOTTOM w0.099: v1(110.33,69.18) 110.46,69.06 110.46,68.75 110.67,68.53 112.04,68.53 112.4,68.9 112.4,69.43 112.69,69.71 113.31,69.71 113.41,69.61 113.81,69.61 114.06,69.61 114.36,69.31 UC1.AD30
  BOTTOM w0.163: v1(63.69,76.29) 63.83,76.16 63.83,75.73 64.38,75.18 65.09,75.18 65.45,75.54 65.78,75.54 65.83,75.49 JDIMM2.139
DDR_B_CLK1: length 63.1
  IN3 w0.102: 80.55,70.47 80.54,70.47 80.5,70.51 80.45,70.51 80.41,70.55 79.14,70.55 77.74,71.94 72.31,71.94 70.75,73.5 67.69,73.5 67.43,73.76 67.06,73.76 66.71,73.4 66.14,73.4 65.85,73.69 64.38,73.69 62.92,75.15 61.54,75.15 61.17,75.52 61.17,76.04 v1(61.11,76.1)
  IN3 w0.178: 80.55,70.47 94.09,70.47 96.16,68.4 108.43,68.4 108.81,68.78 108.81,69 v1(108.97,69.17)
  BOTTOM w0.099: UC1.AD29 114.76,68.81 114.46,69.11 114.21,69.11 114.05,68.95 113.99,68.95 113.95,68.91 113.15,68.91 112.57,68.34 109.04,68.34 108.79,68.59 108.79,68.98 v1(108.97,69.17)
  BOTTOM w0.163: v1(61.11,76.1) 61.14,76.07 61.14,75.65 61.06,75.58 59.14,75.58 58.97,75.74 JDIMM2.138
DDR_B_CLK1#: length 63
  IN3 w0.102: 80.55,70.76 79.23,70.76 77.83,72.16 72.4,72.16 70.84,73.72 67.78,73.72 67.52,73.97 66.97,73.97 66.62,73.62 66.23,73.62 65.94,73.91 64.47,73.91 63.01,75.37 61.63,75.37 61.39,75.61 61.39,75.83 61.65,76.1 v1(61.7,76.1)
  IN3 w0.178: v1(108.39,69.17) 108.53,69.02 108.53,68.89 108.33,68.69 96.28,68.69 94.21,70.76 80.55,70.76
  BOTTOM w0.099: v1(108.39,69.17) 108.56,68.99 108.58,68.99 108.59,68.98 108.59,68.5 108.95,68.14 112.65,68.14 113.23,68.71 113.95,68.71 114.26,68.4 114.4,68.4 114.52,68.52 114.52,68.62 UC1.AD31
  BOTTOM w0.163: JDIMM2.140 61.2,75.24 61.48,75.51 61.48,75.88 v1(61.7,76.1)
DDR_B_CS0#: length 60.8
  IN3 w0.099: 102.42,63.88 103.89,63.88 104.44,64.44 104.9,64.44 105.04,64.57 109.46,64.57 v1(110.47,65.59)
  IN3 w0.102: 79.69,65.08 78.84,65.93 72.15,65.93 69.84,68.24 67.24,68.24 67.09,68.39 65.72,69.75 65.72,70.39 65.16,70.95 63.36,70.95 v1(62.96,70.54)
  IN3 w0.183: 102.42,63.88 94.34,63.88 93.14,65.08 79.69,65.08
  BOTTOM w0.099: v1(110.47,65.59) 110.47,65.87 110.68,66.08 111.99,66.08 112.34,65.73 112.34,65.15 112.68,64.81 UC1.AJ31
  BOTTOM w0.168: JDIMM2.149 65.44,70.99 65.19,71.24 63.36,71.24 62.96,70.84 v1(62.96,70.54)
