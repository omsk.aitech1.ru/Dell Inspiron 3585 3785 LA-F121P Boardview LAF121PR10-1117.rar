# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_DP3_MRX_DTX_P3: length 159.8
  IN1 w0.119: v1(25.8,119.54) 25.95,119.69 26.18,119.69 26.29,119.8 27.17,119.8 29.1,117.88 29.53,117.88 32.59,114.81 37.39,114.81 37.88,115.31 42.86,115.31 43.57,114.59 56.8,114.59 58.5,116.29 58.85,116.29 59.31,116.74 63.3,116.74 64.51,117.95 67.66,117.95 68.62,116.99 70.82,116.99 71.67,116.13 73.87,116.13 75.13,117.4 78.17,117.4 78.42,117.15 79.06,117.15 79.53,116.68 81.32,116.68 81.61,116.97 84.5,116.97 86.66,114.8 92.34,114.8 92.53,114.99 98.35,114.99 99.58,113.76 103.6,113.76 108.21,109.15 115.39,109.15 115.67,109.43 117.13,109.43 118.8,107.76 118.8,106.32 120.04,105.08 121.61,101.17 123.67,99.1 129.83,99.1 130.14,98.8 134.95,93.98 136.02,93.98 140.27,89.73 140.27,82.31 139.39,81.43 139.39,76.96 138.65,76.23 138.65,74.57 139.13,74.09 139.13,72.67 138.16,71.7 138.16,70.89 138.49,70.56 138.72,70.56 v1(138.87,70.41)
  BOTTOM w0.102: UC1.AC2 135.99,69.81 135.89,69.7 135.89,69.56 136,69.45 136.25,69.45 136.52,69.72 137.16,69.72 138.23,70.79 138.49,70.79 v1(138.87,70.41)
  BOTTOM w0.112: CT39.1 25.53,119.71 25.63,119.71 v1(25.8,119.54)
USB3_DP3_MRX_L_DTX_N0: length 4.8
  TOP w0.112: RT111.1 11.64,120.05 LU16.3 11.38,119.79 10.54,119.79 DT5.1 10.18,119.7 9.58,119.7 9.08,119.2 v2(8.63,119.2) 8.07,119.2 7.95,119.32 JUSBC1.A10
USB3_DP3_MRX_L_DTX_N3: length 8.9
  TOP w0.102: 6.51,123.35 6.66,123.5 arc(6.7,123.56) 6.71,123.63 6.71,123.84 arc(6.74,123.99) 6.82,124.11 6.84,124.13 arc(6.92,124.19) 7.01,124.22 7.01,124.23 arc(7.41,124.33) 7.75,124.56 8.81,125.62 v2(10.82,125.62) 11.68,125.62 arc(11.94,125.57) DT8.1
  TOP w0.112: RT109.1 13.23,125.37 LU15.2 12.26,125.54 DT8.1 ; JUSBC1.B10 5.75,123.07 5.84,123.07 arc(6.2,123.15) 6.51,123.35
USB3_DP3_MRX_L_DTX_P0: length 4.8
  TOP w0.112: RT110.1 11.64,119.21 LU16.2 11.36,119.5 10.6,119.5 DT6.1 10.25,119.44 9.69,119.44 9.07,118.82 JUSBC1.A11
USB3_DP3_MRX_L_DTX_P3: length 8.8
  TOP w0.102: 6.63,124.28 6.75,124.4 arc(6.84,124.46) 6.96,124.48 arc(7.29,124.55) 7.57,124.74 8.71,125.88 v2(9.23,125.88) 11.72,125.88 arc(11.95,125.92) DT7.1
  TOP w0.112: DT7.1 12.29,125.91 12.94,125.91 LU15.3 13.23,126.21 RT108.1 ; JUSBC1.B11 5.75,123.58 6.06,123.58 arc(6.24,123.61) 6.39,123.71 arc(6.43,123.78) 6.46,123.85 arc(6.5,124.09) 6.63,124.28
USB3_DP3_MRX_RD_DTX_N0: length 15.7
  TOP w0.112: RT111.2 12.56,120.05 LU16.4 13.04,119.88 13.17,119.76 13.8,119.76 14.07,119.48 14.07,119.14 v1(14.24,118.97)
  BOTTOM w0.112: v1(14.24,118.97) 14.08,119.13 14.08,119.39 14.45,119.76 14.45,120.9 14.19,121.15 14.19,126.61 14.31,126.72 16.14,126.72 16.26,126.59 16.26,124.8 16.54,124.53 16.8,124.53 16.87,124.46 UT9.39
USB3_DP3_MRX_RD_DTX_N3: length 9.8
  TOP w0.112: RT109.2 14.14,125.37 LU15.1 14.61,125.54 14.69,125.63 15.27,125.63 15.54,125.89 15.54,126.07 v1(15.78,126.31)
  BOTTOM w0.112: v1(15.78,126.31) 15.64,126.17 15.64,125.33 15.04,124.72 15.04,121.59 15.39,121.23 17.14,121.23 17.17,121.26 UT9.31
USB3_DP3_MRX_RD_DTX_P0: length 15.7
  TOP w0.112: v1(13.65,118.97) 13.8,119.12 13.8,119.38 13.69,119.49 13.21,119.49 13.09,119.38 LU16.1 12.56,119.21 RT110.2
  BOTTOM w0.112: v1(13.65,118.97) 13.81,119.13 13.81,119.5 14.18,119.87 14.18,120.79 13.93,121.04 v2(13.93,124.6) 13.93,126.72 14.2,126.98 16.24,126.98 16.53,126.7 16.53,124.91 16.64,124.79 16.8,124.79 16.87,124.86 UT9.40
USB3_DP3_MRX_RD_DTX_P3: length 9.8
  TOP w0.112: RT108.2 14.14,126.21 LU15.4 14.57,126.04 14.72,125.89 15.16,125.89 15.27,126 15.27,126.23 v1(15.19,126.31)
  BOTTOM w0.112: v1(15.19,126.31) 15.38,126.12 15.38,125.44 14.77,124.83 v2(14.77,122.84) 14.77,121.48 15.28,120.97 16.93,120.97 17.04,120.86 UT9.30
USB3_DP3_MTX_C_DRX_N1: length 1.5
  TOP w0.112: CT60.2 14.69,118.02 14.46,117.79 14.3,117.79 14.18,117.91 LU14.2 13.51,118.08 RT106.1
USB3_DP3_MTX_C_DRX_N2: length 1.3
  TOP w0.112: RT105.1 12.24,122.96 LU13.3 13.29,123.13 CT59.2
USB3_DP3_MTX_C_DRX_P1: length 1.5
  TOP w0.112: CT61.2 14.69,117.3 14.46,117.53 14.3,117.53 14.18,117.41 LU14.3 13.51,117.24 RT107.1
USB3_DP3_MTX_C_DRX_P2: length 1.4
  TOP w0.112: RT104.1 12.24,123.79 LU13.2 13.16,123.63 CT58.2
USB3_DP3_MTX_C_RD_DRX_N1: length 2.9
  BOTTOM w0.102: 22.62,123.33 22.6,123.33 22.59,123.33 22.09,123.33 22.02,123.26 UT9.13
  BOTTOM w0.112: 22.62,123.33 v2(22.96,123.33) 23.21,123.33 23.29,123.24 23.97,123.24 CT42.2
USB3_DP3_MTX_C_RD_DRX_N2: length 3.1
  BOTTOM w0.102: 22.9,122.15 22.89,122.17 22.88,122.17 22.66,122.39 22.3,122.39 22.23,122.46 UT9.15
  BOTTOM w0.112: 22.9,122.15 v2(23.04,122.02) 23.33,121.72 23.96,121.72 CT44.2
USB3_DP3_MTX_C_RD_DRX_P1: length 2.9
  BOTTOM w0.102: UT9.12 22.04,123.66 22.11,123.59 22.59,123.59 22.6,123.59 22.62,123.59
  BOTTOM w0.112: CT41.2 23.97,123.51 23.4,123.51 23.32,123.59 22.62,123.59
USB3_DP3_MTX_C_RD_DRX_P2: length 3.1
  BOTTOM w0.102: UT9.16 22.2,122.06 22.27,122.13 22.56,122.13 22.7,121.99 22.7,121.98 22.72,121.96
  BOTTOM w0.112: CT43.2 23.97,121.46 23.22,121.46 22.72,121.96
USB3_DP3_MTX_DRX_N1: length 165.9
  IN1 w0.119: v1(140.58,69.41) 140.58,69.55 140.91,69.88 140.91,70.1 141.18,70.37 141.61,70.37 141.95,70.71 141.95,72.9 141.06,73.79 141.06,76.54 140.95,76.65 140.95,80.78 141.83,81.66 141.83,90.38 136.66,95.54 135.6,95.54 130.48,100.66 124.51,100.66 122.81,102.36 122.5,103.13 122.48,103.18 121.36,105.99 120.62,106.73 120.62,108.15 117.31,111.46 116.96,111.46 116.8,111.61 113.77,111.61 113.69,111.7 112.3,111.7 111.93,112.07 107.93,112.07 104.68,115.32 100.52,115.32 99.15,116.69 91.87,116.69 91.26,117.3 86.97,117.3 86.83,117.43 86.24,117.43 85.14,118.53 81.3,118.53 80.36,119.47 77.59,119.47 77.09,118.96 74.49,118.96 73.52,117.99 72.02,117.99 71.07,118.94 70.24,118.94 69.67,119.51 63.87,119.51 62.98,118.63 61.1,118.63 60.77,118.3 58.5,118.3 58.22,118.02 55.58,118.02 54.01,116.46 52.38,116.46 51.6,117.24 38.36,117.24 38.06,117.54 33.88,117.54 27.97,123.45 26.82,123.45 26.49,123.12 v1(26.48,123.12)
  BOTTOM w0.102: v1(140.58,69.41) 140.5,69.41 140.39,69.31 140.39,69.1 140.5,68.99 140.86,68.99 140.97,68.89 140.97,68.69 140.85,68.58 138.16,68.58 137.59,68 136.91,68 136.71,67.8 136.14,67.8 UC1.AF2
  BOTTOM w0.112: CT42.1 25.39,122.73 25.55,122.73 25.66,122.84 25.66,123.36 25.74,123.44 26.16,123.44 v1(26.48,123.12)
USB3_DP3_MTX_DRX_N2: length 163.8
  IN1 w0.119: v1(26.48,121.9) 27.15,121.9 28.8,120.25 28.8,119.64 29.53,118.91 30.42,118.91 33.48,115.85 36.06,115.85 36.56,116.34 44.84,116.34 45.56,115.63 54.39,115.63 55.85,117.09 57.46,117.09 57.76,117.38 58.32,117.38 58.72,117.78 60.99,117.78 61.32,118.11 63.2,118.11 64.09,118.99 68.18,118.99 69.08,118.1 71.17,118.1 72.1,117.17 73.44,117.17 74.7,118.43 77.81,118.43 78.25,118.87 79.71,118.87 80.58,118 84.93,118 87.09,115.84 91.91,115.84 92.24,116.16 98.91,116.16 100.28,114.8 104.03,114.8 107.28,111.55 111.71,111.55 112.08,111.17 113.47,111.17 113.56,111.09 116.58,111.09 116.74,110.93 117.1,110.93 119.84,108.19 119.84,106.75 120.93,105.66 122.49,101.75 124.1,100.14 130.26,100.14 135.38,95.02 136.44,95.02 141.3,90.16 141.3,81.88 140.42,81 140.42,76.44 140.54,76.32 140.54,73.57 141.43,72.68 141.43,71.62 141.16,71.36 140.48,71.36 140.24,71.11 v1(140.24,70.63)
  BOTTOM w0.102: v1(140.24,70.63) 140.21,70.6 140.21,70.11 139.87,69.77 138.53,69.77 137.5,68.74 136.55,68.74 136.32,68.51 136.05,68.51 UC1.AD4
  BOTTOM w0.112: CT44.1 25.33,121.9 v1(26.48,121.9)
USB3_DP3_MTX_DRX_P1: length 165.9
  IN1 w0.119: v1(26.48,123.71) 28.07,123.71 33.98,117.8 38.16,117.8 38.46,117.49 51.7,117.49 52.48,116.71 53.91,116.71 55.47,118.28 58.11,118.28 58.39,118.56 60.66,118.56 60.99,118.89 62.88,118.89 63.76,119.77 69.77,119.77 70.35,119.19 71.18,119.19 72.13,118.25 73.41,118.25 74.38,119.21 76.98,119.21 77.49,119.72 80.47,119.72 81.4,118.78 85.25,118.78 86.35,117.69 86.94,117.69 87.07,117.56 91.37,117.56 91.98,116.94 99.26,116.94 100.62,115.58 104.79,115.58 108.04,112.33 112.03,112.33 112.41,111.95 113.8,111.95 113.88,111.87 116.91,111.87 117.07,111.71 117.42,111.71 120.87,108.26 120.87,106.84 121.58,106.13 122.72,103.27 122.74,103.23 123.03,102.51 124.62,100.92 130.58,100.92 135.7,95.8 136.77,95.8 142.08,90.48 142.08,81.55 141.2,80.67 141.2,76.76 141.32,76.64 141.32,73.9 142.21,73 142.21,70.61 141.72,70.11 141.29,70.11 141.17,69.99 v1(141.17,69.41)
  BOTTOM w0.102: v1(141.17,69.41) 141.17,68.6 140.94,68.37 138.24,68.37 137.67,67.8 136.99,67.8 136.79,67.6 136.4,67.6 136.31,67.51 136.08,67.51 135.33,67.8 UC1.AF4
  BOTTOM w0.112: v1(26.48,123.71) 25.31,123.71 CT41.1
USB3_DP3_MTX_DRX_P2: length 163.7
  IN1 w0.119: v1(26.48,121.32) 26.49,121.32 26.82,121.65 27.04,121.65 28.55,120.15 28.55,119.53 29.42,118.66 30.32,118.66 33.38,115.59 36.17,115.59 36.67,116.09 44.73,116.09 45.45,115.37 54.49,115.37 55.96,116.84 57.57,116.84 57.86,117.13 58.43,117.13 58.82,117.52 61.09,117.52 61.42,117.85 63.31,117.85 64.19,118.73 68.08,118.73 68.97,117.84 71.07,117.84 72,116.91 73.54,116.91 74.81,118.18 77.92,118.18 78.35,118.61 79.61,118.61 80.47,117.75 84.82,117.75 86.99,115.58 92.02,115.58 92.35,115.91 98.81,115.91 100.17,114.54 103.93,114.54 107.18,111.29 111.6,111.29 111.98,110.92 113.37,110.92 113.45,110.83 116.48,110.83 116.64,110.68 116.99,110.68 119.58,108.08 119.58,106.64 120.71,105.52 122.27,101.61 124,99.88 130.15,99.88 135.27,94.76 136.34,94.76 141.05,90.05 141.05,81.98 140.17,81.1 140.17,76.33 140.28,76.22 140.28,73.47 141.17,72.57 141.17,71.73 141.06,71.61 140.38,71.61 139.98,71.21 139.98,70.96 139.65,70.63 v1(139.65,70.63)
  BOTTOM w0.102: v1(139.65,70.63) 139.71,70.63 140,70.34 140,70.19 139.79,69.97 138.45,69.97 137.42,68.94 136.48,68.94 136.21,69.21 136.05,69.21 135.93,69.09 135.93,68.94 136.06,68.81 UC1.AD2
  BOTTOM w0.112: CT43.1 25.53,121.15 25.64,121.27 25.64,121.53 25.75,121.64 26.16,121.64 v1(26.48,121.32)
USB3_DP3_MTX_L_DRX_N1: length 8.3
  TOP w0.102: JUSBC1.B3 6.18,119.57 6.7,119.06 6.7,118.89
  TOP w0.112: 6.7,118.89 6.7,118.25 7.03,117.91 8.54,117.91 8.59,117.86 v2(8.82,117.86) 11.05,117.86 DT9.1 11.39,117.84 11.9,117.84 11.97,117.91 LU14.1 12.59,118.08 RT106.2
USB3_DP3_MTX_L_DRX_N2: length 4.6
  TOP w0.112: RT105.2 11.32,122.96 LU13.4 10.65,123.13 10.53,123.24 10.18,123.24 DT4.1 9.57,123.38 8.8,123.38 8.36,122.94 8.07,122.94 7.95,122.82 JUSBC1.A3
USB3_DP3_MTX_L_DRX_P1: length 8.2
  TOP w0.102: JUSBC1.B2 6.3,119.07 6.38,118.99 6.38,118.89
  TOP w0.112: 6.38,118.89 6.38,118.19 6.92,117.65 8.43,117.65 8.48,117.6 v2(10.14,117.6) 11.02,117.6 DT10.1 11.39,117.58 11.81,117.58 11.98,117.41 LU14.4 12.59,117.24 RT107.2
USB3_DP3_MTX_L_DRX_P2: length 4.5
  TOP w0.112: RT104.2 11.32,123.79 LU13.1 10.65,123.63 10.53,123.51 10.18,123.51 DT3.1 9.83,123.64 v2(8.94,123.64) 8.69,123.64 8.25,123.21 8.09,123.21 7.98,123.32 JUSBC1.A2
USB3_DP3_MTX_RD_DRX_N1: length 11.5
  TOP w0.112: v1(16.27,117.95) 16.01,117.7 15.79,117.7 15.6,117.89 CT60.1
  IN1 w0.119: v1(16.27,117.95) 16.16,118.06 16.04,118.06 15.92,117.94 15.92,117.78 15.81,117.66 15.65,117.66 15.5,117.81 15.5,118.51 15.52,118.53 15.52,120.18 15.03,120.68 15.03,123.81 15.16,123.94 15.33,123.94 15.6,123.67 v1(15.65,123.67)
  BOTTOM w0.102: UT9.36 17.15,123.26 17.01,123.41 16.52,123.41 16,123.92 15.89,123.92 15.65,123.68 v1(15.65,123.67)
USB3_DP3_MTX_RD_DRX_N2: length 5.1
  TOP w0.112: CT59.1 14.65,123.31 14.97,123.31 15.61,122.67 15.61,121.92 v1(15.45,121.76)
  BOTTOM w0.112: UT9.34 16.89,122.46 16.82,122.39 15.93,122.39 15.68,122.14 15.68,121.99 v1(15.45,121.76)
USB3_DP3_MTX_RD_DRX_P1: length 11.5
  TOP w0.112: CT61.1 15.82,117.43 16.12,117.43 16.14,117.42 16.22,117.42 v1(16.27,117.37)
  IN1 w0.119: v1(16.27,117.37) 15.58,117.37 15.24,117.71 15.24,118.61 15.27,118.64 15.27,120.08 14.78,120.57 14.78,123.92 15.06,124.2 15.59,124.2 v1(15.65,124.25)
  BOTTOM w0.102: UT9.37 16.62,123.66 16.11,124.18 15.73,124.18 v1(15.65,124.25)
USB3_DP3_MTX_RD_DRX_P2: length 5
  TOP w0.112: CT58.1 14.65,123.57 15.08,123.57 15.87,122.78 15.87,121.92 v1(16.03,121.76)
  BOTTOM w0.112: UT9.33 16.89,122.06 16.82,122.13 16.04,122.13 15.93,122.03 15.93,121.85 v1(16.03,121.76)
USB20_0_N0: length 186.3
  IN1 w0.119: v1(30.55,129.68) 30.55,129 28.99,127.44 25.16,127.44 24.67,126.95 24.67,120.08 26.35,118.41 26.98,118.41 29.35,116.04 30.62,116.04 32.37,114.29 34.21,114.29 34.57,113.93 39.84,113.93 40.46,114.55 41.94,114.55 42.43,114.07 57.51,114.07 59.66,116.22 64.51,116.22 65.41,117.11 67.75,117.11 68.87,116 70.93,116 71.33,115.61 74.08,115.61 75.35,116.87 77.95,116.87 78.48,116.35 78.99,116.35 80.1,115.24 83.88,115.24 85.55,113.57 97.42,113.57 98.4,112.6 102.37,112.6 107.6,107.37 116.07,107.37 118.89,104.55 120.42,100.7 123.19,97.93 129.3,97.93 132.67,94.56 132.67,94.28 135.19,91.76 135.19,88.58 135.58,88.18 138.06,88.18 139.1,87.14 139.1,82.79 138.16,81.85 137.32,81.85 137.17,82 136.3,82 135.5,82.8 134.95,82.8 133.46,81.31 130.56,81.31 129.96,80.7 129.88,80.7 128.37,79.2 128.37,78.59 129.13,77.82 129.13,75.64 129.35,75.42 133.73,75.42 134.15,75 134.15,69.42 134.34,69.23 134.34,68.52 134.25,68.43 v1(134.25,67.73)
  BOTTOM w0.089: v1(134.25,67.73) 133.93,68.05 UC1.AE6
  BOTTOM w0.112: v1(30.55,129.68) 30.44,129.79 30.44,130.2 30.08,130.56 29.67,130.56 29.55,130.67 UT10.7
USB20_0_N1: length 160.6
  TOP w0.112: RU6.1 32.37,57.94 LU3.2 32.82,57.78 32.86,57.73 33.34,57.73 33.45,57.84 33.45,58.58 33.93,59.06 v1(33.93,59.9)
  IN3 w0.099: v1(132.03,65.81) 131.86,65.64 131.86,65.5 131.96,65.4 133.93,65.4 134.15,65.18 134.15,62.15 134.82,61.48 134.82,60.6 134.81,60.59 134.81,60.47 134.8,60.46 134.8,60.15 134.81,60.15 134.81,56.33 134.17,55.69 134.17,55.13 134.25,55.05
  IN3 w0.135: 134.25,55.05 134.25,54.71 134.62,54.35 134.62,52.57 134.9,52.3 134.9,51.44 135.34,51 135.34,49.44 134.9,49 134.9,48.27 131.96,45.33 131.96,44.39 131.58,44.01 131.58,42.52 131.25,42.19 131.25,41.44 131.13,41.33 131.13,41.11 130.73,40.7 130.73,34.53 130.92,34.33 130.92,32.74 130.58,32.39 127.92,32.39 127.01,33.31 123.28,33.31 123.21,33.24 121.41,33.24 119.92,31.75 116.79,31.75 116.76,31.72 109.22,31.72 108.68,31.18 104.06,31.18 103.57,31.66 97.81,31.66 97.4,32.07 67.66,32.07 63.71,36.02 62.03,36.02 61.59,36.46 60.76,36.46 55.38,41.85 49.22,41.85 49.05,41.68 42.34,41.68 41.57,42.45 38.27,42.45 35.96,44.76 35.96,57.51 34.08,59.38 34.08,59.75 v1(33.93,59.9)
  BOTTOM w0.1: UC1.AG9 131.63,66.21 v1(132.03,65.81)
USB20_0_N1_R: length 19.8
  TOP w0.112: RU6.2 31.45,57.94 LU3.1 30.78,57.78 30.66,57.66 30.2,57.66 30.01,57.47 29.36,57.47 29.24,57.58 29.24,58.2 EU2.3 28.99,58.15 28.99,57.57 28.88,57.46 28.29,57.46 28.03,57.2 28.03,57.01 27.02,56 v2(25.08,56) 23.66,56 22.8,55.15 20.94,53.28 15.99,53.28 15.88,53.39 JUSB1.2
USB20_0_N2: length 150
  IN3 w0.099: 135.34,55.05 135.34,55.07 135.3,55.11 135.3,55.43 135.36,55.49 135.36,58.9 135.76,59.3 135.76,64.55 134.84,65.46 134.84,66.01 134.47,66.38 132.49,66.38 132.47,66.4 130.34,66.4 130.24,66.5 130.24,66.64 v1(130.41,66.81)
  IN3 w0.135: v1(34.78,42.07) 34.99,41.85 34.99,41.72 35.29,41.41 37.4,41.41 37.55,41.56 41.38,41.56 41.98,40.95 49.35,40.95 49.52,41.12 55.08,41.12 60.46,35.74 61.29,35.74 61.73,35.3 63.41,35.3 67.36,31.34 97.1,31.34 97.51,30.94 103.27,30.94 103.76,30.45 108.98,30.45 109.52,30.99 116.98,30.99 117,31.01 120.45,31.01 121.3,31.86 122.86,31.86 123.58,32.59 126.5,32.59 127.42,31.67 131.02,31.67 132.67,33.31 132.67,35.25 132.34,35.57 132.34,40.14 132.73,40.52 132.73,40.9 134.29,44.45 135.62,45.78 135.62,48.7 136.06,49.14 136.06,51.45 135.62,51.9 135.62,52.6 135.34,52.87 135.34,55.05
  BOTTOM w0.089: v1(130.41,66.81) 130.03,67.18 UC1.AF11
  BOTTOM w0.112: RU12.1 32.56,39.91 LU6.3 34.11,39.74 34.78,40.41 v1(34.78,42.07)
USB20_0_N2_R: length 26.8
  BOTTOM w0.112: JUSB2.2 15.88,29.49 15.99,29.38 16.66,29.38 16.85,29.57 16.85,34.65 18.28,36.07 22.85,36.07 23.52,36.75 23.52,38.2 24.39,39.06 v2(25.1,39.06) 26.13,39.06 26.65,39.58 26.83,39.58 27.1,39.85 27.1,40.31 EU4.3 27.43,40.28 27.43,39.73 27.54,39.62 27.85,39.62 28.77,40.54 30.04,40.54 30.96,39.62 31.02,39.62 31.14,39.74 LU6.4 31.64,39.91 RU12.2
USB20_0_N3: length 139.1
  TOP w0.099: 136.59,70.56 136.57,70.54 136.57,70.49 136.43,70.35 136.43,68.69 135.1,67.35 131.15,67.35 131.01,67.49 131.01,67.71 131.11,67.81 v1(131.2,67.81)
  TOP w0.112: v1(147.76,74.73) 147.61,74.57 143.92,74.57 142.1,72.75 142.1,72.11 141.83,71.84 137.88,71.84 136.59,70.56 ; R8.1 215.57,44.55 L1.4 216.01,44.38 216.19,44.2 216.26,44.2 v1(216.46,44.41)
  IN1 w0.119: v1(147.76,74.73) 148.03,74.47 148.94,74.47 149.21,74.2 149.21,64.86 148.61,64.26 148.61,62.91 149.29,62.23 149.29,56.17 148.29,55.18 148.29,52.94 148.67,52.56 148.67,52.45 149.01,52.1 149.01,50.46 148.68,50.13 148.68,43.26 150.56,41.39 150.56,40.76 153.41,37.9 153.63,37.9 155.46,36.07 159.92,36.07 161.12,34.87 163.69,34.87 164.19,34.36 171.86,34.36 173.8,36.3 175.85,36.3 175.99,36.16 177.22,36.16 177.83,36.77 179.82,36.77 181.47,35.12 187.56,35.12 188.76,36.33 190.5,36.33 190.92,36.75 191.88,36.75 191.91,36.72 192.4,36.72 193.36,35.76 195.48,35.76 196.14,35.1 202.23,35.1 202.29,35.05 210.93,35.05 213.83,37.96 214.62,37.96 215.85,39.19 215.85,43.88 216.12,44.15 216.2,44.15 v1(216.46,44.41)
  BOTTOM w0.1: UC1.AE9 131.63,68.25 v1(131.2,67.81)
USB20_0_N3_R: length 2.6
  TOP w0.112: R8.2 214.65,44.55 L1.3 214.25,44.38 214.15,44.28 213.62,44.28 v1(213.42,44.48)
  BOTTOM w0.112: JEDP1.33 212.87,44.45 213,44.32 213.26,44.32 v1(213.42,44.48)
USB20_0_P0: length 186.3
  IN1 w0.119: v1(29.96,129.68) 29.96,129.61 30.3,129.28 30.3,129.11 28.88,127.69 25.05,127.69 24.42,127.06 24.42,119.98 26.24,118.16 26.87,118.16 29.25,115.79 30.52,115.79 32.27,114.03 34.11,114.03 34.47,113.68 39.95,113.68 40.56,114.3 41.84,114.3 42.32,113.81 57.61,113.81 59.76,115.96 64.62,115.96 65.52,116.86 67.65,116.86 68.76,115.75 70.83,115.75 71.22,115.35 74.19,115.35 75.46,116.62 77.85,116.62 78.37,116.09 78.89,116.09 79.99,114.99 83.78,114.99 85.45,113.32 97.31,113.32 98.29,112.34 102.27,112.34 107.49,107.12 115.96,107.12 118.67,104.41 120.2,100.56 123.08,97.68 129.19,97.68 132.41,94.46 132.41,94.17 134.93,91.65 134.93,88.48 135.48,87.93 137.96,87.93 138.85,87.04 138.85,82.89 138.05,82.1 137.43,82.1 137.28,82.25 136.41,82.25 135.61,83.05 134.84,83.05 133.36,81.56 130.46,81.56 129.85,80.96 129.77,80.96 128.11,79.3 128.11,78.48 128.88,77.72 128.88,75.54 129.24,75.17 133.63,75.17 133.89,74.9 133.89,69.32 134.09,69.12 134.09,68.63 134,68.54 134,68.18 v1(133.55,67.73)
  BOTTOM w0.089: v1(133.55,67.73) 133.23,68.05 UC1.AE7
  BOTTOM w0.112: v1(29.96,129.68) 30.17,129.89 30.17,130.09 29.97,130.29 29.67,130.29 29.55,130.17 UT10.8
USB20_0_P1: length 160.5
  TOP w0.112: RU5.1 32.37,57.11 LU3.3 32.8,57.28 32.99,57.47 33.45,57.47 33.71,57.73 v2(33.71,58.11) 33.71,58.47 34.19,58.95 34.19,59.58 v1(34.51,59.9)
  IN3 w0.099: v1(131.23,65.81) 131.43,65.81 131.67,65.57 131.67,65.42 131.88,65.2 133.85,65.2 133.95,65.1 133.95,62.07 134.62,61.4 134.62,60.68 134.61,60.67 134.61,60.55 134.61,60.55 134.61,60.07 134.61,60.07 134.61,56.41 133.97,55.78 133.97,55.05
  IN3 w0.135: 133.97,55.05 133.97,54.6 134.34,54.23 134.34,52.45 134.61,52.18 134.61,51.33 135.06,50.88 135.06,49.56 134.61,49.12 134.61,48.39 131.67,45.45 131.67,44.51 131.3,44.13 131.3,42.64 130.96,42.3 130.96,41.56 130.85,41.44 130.85,41.22 130.45,40.82 130.45,34.41 130.64,34.21 130.64,32.86 130.46,32.68 128.04,32.68 127.12,33.6 123.17,33.6 123.09,33.52 121.3,33.52 119.8,32.03 116.68,32.03 116.65,32 109.1,32 108.56,31.46 104.18,31.46 103.69,31.94 97.93,31.94 97.52,32.35 67.78,32.35 63.82,36.31 62.15,36.31 61.71,36.75 60.88,36.75 55.5,42.13 49.1,42.13 48.93,41.96 42.46,41.96 41.69,42.73 38.39,42.73 36.24,44.87 36.24,57.63 34.37,59.5 34.37,59.76 v1(34.51,59.9)
  BOTTOM w0.1: v1(131.23,65.81) 131.23,66.03 130.95,66.31 UC1.AG10
USB20_0_P1_R: length 19.8
  TOP w0.112: RU5.2 31.45,57.11 LU3.4 30.78,57.28 30.66,57.39 30.31,57.39 30.12,57.2 29.36,57.2 29.24,57.09 29.24,56.47 EU2.2 28.99,56.52 28.99,57.09 28.88,57.2 28.4,57.2 28.29,57.09 28.29,56.9 27.13,55.74 23.77,55.74 v2(22.99,54.96) 21.04,53.02 15.99,53.02 15.88,52.91 JUSB1.3
USB20_0_P2: length 149.9
  IN3 w0.099: 135.06,55.05 135.06,55.07 135.1,55.11 135.1,55.52 135.16,55.57 135.16,58.98 135.56,59.38 135.56,64.46 134.65,65.38 134.65,65.93 134.39,66.18 132.41,66.18 132.39,66.2 130.26,66.2 130.04,66.42 130.04,66.57 129.81,66.81 v1(129.61,66.81)
  IN3 w0.135: 135.06,55.05 135.06,52.75 135.33,52.48 135.33,51.78 135.78,51.33 135.78,49.26 135.33,48.82 135.33,45.9 134.05,44.61 132.44,40.96 132.44,40.64 132.05,40.25 132.05,35.45 132.38,35.13 132.38,33.43 130.9,31.95 127.53,31.95 126.62,32.87 123.47,32.87 122.74,32.15 121.19,32.15 120.33,31.29 116.88,31.29 116.86,31.28 109.4,31.28 108.86,30.74 103.88,30.74 103.39,31.22 97.63,31.22 97.22,31.63 67.48,31.63 63.52,35.58 61.85,35.58 61.41,36.02 60.58,36.02 55.2,41.41 49.4,41.41 49.23,41.24 42.1,41.24 41.5,41.84 37.43,41.84 37.28,41.7 35.41,41.7 35.28,41.83 35.28,41.98 v1(35.36,42.07)
  BOTTOM w0.089: UC1.AF12 129.23,67.18 v1(129.61,66.81)
  BOTTOM w0.112: RU11.1 32.56,39.07 LU6.2 33.23,39.24 33.47,39.48 v2(33.78,39.48) 34.22,39.48 34.79,40.05 35.04,40.3 35.04,41.75 v1(35.36,42.07)
USB20_0_P2_R: length 26.8
  BOTTOM w0.112: JUSB2.3 15.88,29.01 15.99,29.12 16.77,29.12 17.12,29.46 17.12,34.54 18.39,35.81 22.96,35.81 23.79,36.64 v2(23.79,37.42) 23.79,38.09 24.5,38.8 26.24,38.8 26.76,39.32 26.97,39.32 27.14,39.15 27.14,38.64 EU4.2 27.43,38.71 27.43,39.24 27.54,39.36 27.96,39.36 28.88,40.28 29.93,40.28 30.85,39.36 31.02,39.36 31.14,39.24 LU6.1 31.64,39.07 RU11.2
USB20_0_P3: length 139.2
  TOP w0.099: 136.78,70.41 136.77,70.41 136.63,70.27 136.63,68.61 135.18,67.16 131.06,67.16 130.92,67.3 130.92,67.3 v1(130.4,67.81)
  TOP w0.112: v1(147.76,74.15) 147.6,74.31 144.03,74.31 142.36,72.64 142.36,72 141.94,71.58 137.98,71.58 136.82,70.41 136.78,70.41 ; R7.1 215.57,43.71 L1.1 216.03,43.88 216.09,43.94 216.35,43.94 v1(216.46,43.82)
  IN1 w0.119: v1(147.76,74.15) 147.83,74.21 148.84,74.21 148.96,74.1 148.96,64.97 148.35,64.37 148.35,62.8 149.03,62.12 149.03,56.28 148.03,55.28 148.03,52.83 148.42,52.45 148.42,52.34 148.76,52 148.76,50.56 148.43,50.23 148.43,43.16 150.3,41.29 150.3,40.65 153.31,37.65 153.52,37.65 155.36,35.81 159.82,35.81 161.01,34.62 163.58,34.62 164.09,34.11 171.97,34.11 173.9,36.05 175.74,36.05 175.89,35.9 177.32,35.9 177.94,36.52 179.72,36.52 181.37,34.87 187.66,34.87 188.87,36.07 190.6,36.07 191.02,36.49 191.77,36.49 191.8,36.47 192.29,36.47 193.25,35.5 195.37,35.5 196.03,34.84 202.13,34.84 202.18,34.79 211.03,34.79 213.94,37.7 214.73,37.7 216.11,39.08 216.11,43.77 216.23,43.89 216.4,43.89 v1(216.46,43.82)
  BOTTOM w0.1: v1(130.4,67.81) 130.83,68.25 UC1.AE10
USB20_0_P3_R: length 2.6
  TOP w0.112: v1(213.42,43.9) 213.54,44.01 214.08,44.01 214.22,43.88 L1.2 214.65,43.71 R7.2
  BOTTOM w0.112: JEDP1.34 212.78,43.95 212.89,44.06 212.89,44.05 213.26,44.05 v1(213.42,43.9)
USB20_1_N0: length 132.5
  TOP w0.099: 136.78,67.04 136.76,67.02 136.71,67.02 135.37,65.68 134.93,65.68 134.46,65.21 130.12,65.21 129.98,65.07 129.98,64.93 130.1,64.8 v1(130.36,64.8)
  TOP w0.112: v1(207.3,33) 207.54,33.23 207.54,33.36 207.37,33.53 LU8.3 207.27,33.88 RU16.1 ; 136.78,67.04 137.61,67.88 137.61,68.07 138.82,69.28 139.87,69.28 140.57,69.97 141.57,69.97 143.02,71.42 144.8,71.42 146.68,73.29 147.2,73.29 v1(147.52,72.97)
  IN1 w0.119: v1(207.3,33) 207.3,33 207.64,33.33 207.64,33.77 207.45,33.96 202.47,33.96 201.5,32.98 196.6,32.98 194.76,34.82 190.95,34.82 190.37,35.39 189.15,35.39 187.57,33.82 185.1,33.82 184.76,34.16 184.5,34.16 184.16,33.82 182.44,33.82 182.22,34.04 181.23,34.04 179.44,35.84 178.22,35.84 177.6,35.23 175.58,35.23 175.44,35.37 174.49,35.37 174.14,35.01 174.14,34.39 173.17,33.43 163.81,33.43 163.66,33.58 161.76,33.58 161.4,33.94 160.73,33.94 159.54,35.13 155.08,35.13 153.24,36.97 152.42,36.97 147.39,42 147.39,44.8 146.29,45.9 143.41,45.9 143.08,46.23 143.08,52.43 143.99,53.35 143.99,55.69 144.51,56.21 146.86,56.21 148.35,57.7 148.35,61.84 147.68,62.52 147.68,64.65 148.28,65.25 148.28,72.82 147.86,73.24 147.79,73.24 v1(147.52,72.97)
  BOTTOM w0.1: UC1.AJ11 130.03,64.93 130.16,64.8 v1(130.36,64.8)
USB20_1_N0_R: length 2.3
  TOP w0.112: v1(207.33,35.75) 207.51,35.56 207.51,35.42 207.37,35.27 LU8.4 207.37,34.93 RU16.2
  BOTTOM w0.112: v1(207.33,35.75) 207.49,35.91 207.49,36.18 207.2,36.47 JIOB1.7
USB20_1_N1: length 153.1
  TOP w0.099: v1(132.81,69.72) 132.67,69.72 132.55,69.6 132.55,69.46 132.75,69.26 133.15,69.26 133.23,69.33 135.22,69.33 135.94,70.05 135.94,73.57 136.57,74.2 136.57,74.25 136.59,74.27
  TOP w0.112: v1(148.01,76.03) 147.75,75.76 146.81,75.76 146.3,75.25 143.62,75.25 143.33,74.96 141.31,74.96 140.99,74.65 136.97,74.65 136.59,74.27 ; v1(211.24,60.19) 211.36,60.32 RC103.2
  IN1 w0.119: v1(148.01,76.03) 148.28,75.77 149.35,75.77 149.89,75.23 149.89,64.59 149.29,63.98 149.29,63.19 149.96,62.51 149.96,55.89 149.51,55.44 149.51,52.67 149.69,52.49 149.69,50.16 149.36,49.83 149.36,43.55 151.24,41.67 151.24,41.04 153.69,38.58 153.91,38.58 155.75,36.74 160.21,36.74 161.4,35.55 163.97,35.55 164.27,35.25 165.24,35.25 165.76,35.77 169.17,35.77 170.01,36.61 172.24,36.61 172.61,36.98 175.4,36.98 176.2,37.78 178.15,37.78 178.48,37.45 181.17,37.45 182.62,36 187.48,36 188.49,37.02 190.23,37.02 190.64,37.42 192.37,37.42 192.4,37.4 193.52,37.4 193.8,37.68 196,37.68 196.21,37.46 200.33,37.46 200.54,37.25 206.01,37.25 208.6,39.84 209.59,39.84 210.71,40.97 211.47,40.97 211.89,41.39 211.89,41.9 213.01,43.02 213.92,43.02 214.15,43.24 214.15,45.99 213.63,46.52 213.1,46.52 211.68,47.93 211.68,51.15 211.28,51.55 211.28,54.25 208.25,57.28 208.25,58.86 209.4,60 211.04,60 v1(211.24,60.19)
  BOTTOM w0.089: v1(132.81,69.72) 132.43,69.34 UC1.AD8
USB20_1_N1_R: length 1.6
  TOP w0.112: RC103.1 213.15,60.07 U58.15
USB20_1_P0: length 132.5
  TOP w0.099: 136.59,67.23 136.57,67.21 136.57,67.16 135.29,65.88 134.85,65.88 134.38,65.41 130.03,65.41 129.81,65.19 v1(129.62,64.78)
  TOP w0.112: RU15.1 208.01,33.91 LU8.2 207.87,33.43 207.81,33.37 207.81,33.08 v1(207.89,33) ; v1(147.52,73.56) 146.57,73.56 144.69,71.69 v2(144.22,71.69) 142.91,71.69 141.46,70.24 140.46,70.24 139.76,69.55 138.72,69.55 137.35,68.18 137.35,67.99 136.59,67.23
  IN1 w0.119: v1(207.89,33) 207.89,33.87 207.55,34.21 202.37,34.21 201.39,33.24 196.7,33.24 194.87,35.07 191.05,35.07 190.47,35.65 189.04,35.65 187.46,34.07 185.2,34.07 184.86,34.41 184.4,34.41 184.06,34.07 182.55,34.07 182.33,34.29 181.34,34.29 179.54,36.09 178.11,36.09 177.5,35.48 175.69,35.48 175.55,35.62 174.39,35.62 173.88,35.12 173.88,34.5 173.07,33.68 163.91,33.68 163.77,33.83 161.87,33.83 161.51,34.19 160.84,34.19 159.64,35.39 155.18,35.39 153.35,37.22 152.53,37.22 147.65,42.11 147.65,44.9 146.4,46.15 143.52,46.15 143.33,46.34 143.33,52.33 144.25,53.24 144.25,55.58 144.62,55.95 146.96,55.95 148.61,57.6 148.61,61.95 147.93,62.62 147.93,64.54 148.53,65.14 148.53,72.92 147.96,73.49 147.59,73.49 v1(147.52,73.56)
  BOTTOM w0.089: UC1.AJ12 v1(129.62,64.78)
USB20_1_P0_R: length 2.4
  TOP w0.112: RU15.2 207.87,34.99 LU8.1 207.87,35.31 207.78,35.41 207.78,35.61 v1(207.91,35.75)
  BOTTOM w0.112: JIOB1.6 208.2,36.5 207.76,36.06 207.76,35.9 v1(207.91,35.75)
USB20_1_P1: length 153.1
  TOP w0.099: v1(132.03,69.7) 132.67,69.06 133.23,69.06 133.31,69.13 135.3,69.13 136.14,69.97 136.14,73.49 136.73,74.08 136.77,74.08 136.78,74.08
  TOP w0.112: 136.78,74.08 137.08,74.38 141.1,74.38 141.42,74.7 143.44,74.7 143.73,74.99 146.41,74.99 146.92,75.5 147.96,75.5 v1(148.01,75.45) ; v1(211.24,59.56) 211.3,59.49 RC102.2
  IN1 w0.119: v1(211.24,59.56) 211.04,59.75 209.5,59.75 208.5,58.75 208.5,57.38 211.54,54.35 211.54,51.65 211.94,51.25 211.94,48.03 213.2,46.77 213.74,46.77 214.41,46.1 214.41,43.14 214.03,42.76 213.11,42.76 212.15,41.8 212.15,41.28 211.58,40.71 210.82,40.71 209.69,39.59 208.7,39.59 206.11,37 200.43,37 200.22,37.21 196.11,37.21 195.89,37.42 193.9,37.42 193.62,37.14 192.29,37.14 192.27,37.17 190.74,37.17 190.33,36.76 188.6,36.76 187.58,35.75 182.52,35.75 181.07,37.19 178.37,37.19 178.05,37.52 176.3,37.52 175.5,36.72 172.72,36.72 172.35,36.36 170.12,36.36 169.28,35.52 165.86,35.52 165.34,34.99 164.16,34.99 163.86,35.3 161.29,35.3 160.1,36.49 155.64,36.49 153.8,38.33 153.59,38.33 150.98,40.93 150.98,41.57 149.11,43.44 149.11,49.93 149.44,50.26 149.44,52.38 149.26,52.56 149.26,55.55 149.71,56 149.71,62.4 149.03,63.08 149.03,64.09 149.64,64.69 149.64,75.12 149.24,75.51 148.08,75.51 v1(148.01,75.45)
  BOTTOM w0.089: v1(132.03,69.7) UC1.AD9
USB20_1_P1_R: length 1.6
  TOP w0.112: RC102.1 213.27,59.49 213.33,59.43 U58.16
USB20_CR_N1: length 41.8
  TOP w0.112: RU14.1 209.88,33.94 LU7.3 210.03,33.49 210.27,33.26 210.27,33.05 v1(209.98,32.77) ; U58.10 220.57,57.53 220.83,57.78 221.05,57.78 v1(221.28,57.55)
  IN3 w0.135: v1(221.28,57.55) 221.49,57.76 222.03,57.76 222.76,57.03 222.76,52.16 224.35,50.58 224.35,49.32 224.03,49 224.03,45.36 222.22,43.55 222.22,36.41 220.32,34.52 215.99,34.52 215.54,34.97 212.26,34.97 211.46,34.16 210.63,34.16 210.28,33.81 210.28,33.08 209.98,32.78 v1(209.98,32.77)
USB20_CR_N1_R: length 2.4
  TOP w0.112: v1(210.03,35.76) 210.16,35.63 210.16,35.37 210.03,35.24 LU7.4 209.87,34.87 RU14.2
  BOTTOM w0.112: JIOB1.4 210.2,36.55 210.43,36.32 210.43,36.16 v1(210.03,35.76)
USB20_CR_P1: length 41.8
  TOP w0.112: U58.11 220.56,58.16 220.67,58.05 221.19,58.05 v1(221.28,58.14) ; RU13.1 210.68,33.94 LU7.2 210.53,32.8 v1(210.57,32.77)
  IN3 w0.135: v1(210.57,32.77) 210.56,32.77 210.56,33.69 210.75,33.88 211.58,33.88 212.38,34.68 215.42,34.68 215.87,34.23 220.44,34.23 222.51,36.3 222.51,43.43 224.32,45.25 224.32,48.89 224.63,49.2 224.63,50.69 223.05,52.28 223.05,57.15 222.14,58.05 221.37,58.05 v1(221.28,58.14)
USB20_CR_P1_R: length 2.4
  TOP w0.112: RU13.2 210.69,34.88 LU7.1 210.53,35.31 210.42,35.41 210.42,35.57 v1(210.61,35.76)
  BOTTOM w0.112: v1(210.61,35.76) 210.61,35.97 211.2,36.56 JIOB1.3
USB20_FP_N3: length 34.2
  TOP w0.112: v1(218.46,55.02) 218.68,55.24 218.79,55.24 219.05,54.99 U58.6
  IN3 w0.135: v1(221.06,37.18) 221.26,37.38 221.26,38.14 220.73,38.67 220.73,44.26 221.5,45.03 222.63,45.03 223.31,45.71 223.31,49.47 223.6,49.76 223.6,50.22 221.35,52.47 220.78,52.47 219.41,53.84 219.41,54.89 219.05,55.25 218.69,55.25 v1(218.46,55.02)
  BOTTOM w0.112: v1(221.06,37.18) 221.31,36.93 221.31,36.2 219.99,34.88 219.63,34.88 219.36,34.61 219.36,34.23 219.25,34.12 218.89,34.12 DU2.3 219.26,33.75 219.38,33.64 219.38,33.1 219.67,32.81 219.67,32.33 219.43,32.1 219.26,31.93 218.74,31.4 218.74,31.36 218.5,31.13 JFP1.6
USB20_FP_P3: length 34.2
  TOP w0.112: U58.7 219.05,55.62 218.93,55.51 218.57,55.51 v1(218.46,55.61)
  IN3 w0.135: v1(218.46,55.61) 218.54,55.54 219.17,55.54 219.69,55.01 219.69,53.96 220.9,52.75 221.47,52.75 223.88,50.34 223.88,49.64 223.59,49.35 223.59,45.59 222.74,44.75 221.62,44.75 221.01,44.14 221.01,38.79 221.54,38.26 221.54,37.29 221.57,37.26 221.57,37.25 v1(221.64,37.18)
  BOTTOM w0.112: v1(221.64,37.18) 221.57,37.12 221.57,36.09 220.09,34.61 219.74,34.61 219.63,34.5 219.63,34.26 219.72,34.17 220.04,34.17 DU2.2 219.78,33.75 219.64,33.61 219.64,33.21 219.93,32.92 219.93,32.22 v2(219.62,31.91) 219,31.29 JFP1.5
USB20_MINI1_N4: length 185.6
  TOP w0.112: U58.4 219.15,53.72 218.93,53.93 218.82,53.93 218.54,53.65 217.33,53.65 v1(217.14,53.46)
  IN3 w0.135: v1(148.78,106.28) 148.65,106.41 148.65,106.57 148.79,106.71 149.84,106.71 150.81,105.74 153.74,105.74 159.77,99.71 159.77,97.27 167.01,90.03 167.01,82.62 171.91,77.72 171.91,74.94 175.98,70.87 177.2,70.87 183,65.08 183.91,65.08 185.4,63.59 192.51,63.59 193.24,62.87 197.74,62.87 201.31,59.3 208.91,59.3 210.34,60.73 213.28,60.73 214.47,59.54 214.47,55.54 216.42,53.59 217.01,53.59 v1(217.14,53.46)
  BOTTOM w0.112: JWLAN1.5 79.66,121.65 79.83,121.48 88.85,121.48 89.35,120.98 89.35,120.25 93.77,115.84 95.16,115.84 98.53,112.47 109.14,112.47 116.07,105.55 124.71,105.55 126.37,103.88 132.3,103.88 136.53,105.38 136.59,105.39 136.62,105.39 139.3,105.39 140.98,103.72 141.74,103.72 142.37,104.35 142.37,105.32 144.02,106.98 148.35,106.98 148.62,106.71 148.62,106.44 v1(148.78,106.28)
USB20_MINI1_P4: length 185.6
  TOP w0.112: v1(217.14,54.05) 217.27,53.92 218.43,53.92 218.71,54.19 219.07,54.19 219.22,54.35 U58.5
  IN3 w0.135: v1(217.14,54.05) 216.97,53.87 216.54,53.87 214.76,55.65 214.76,59.65 213.39,61.02 210.22,61.02 208.79,59.59 201.43,59.59 197.86,63.15 193.35,63.15 192.63,63.88 185.52,63.88 184.03,65.36 183.11,65.36 177.32,71.16 176.1,71.16 172.2,75.06 172.2,77.83 167.29,82.74 167.29,90.15 160.05,97.39 160.05,99.83 153.86,106.03 150.92,106.03 149.96,106.99 148.67,106.99 148.37,106.69 148.37,106.46 v1(148.2,106.28)
  BOTTOM w0.112: v1(148.2,106.28) 148.36,106.44 148.36,106.6 148.24,106.71 144.13,106.71 142.63,105.21 142.63,104.24 141.84,103.45 140.87,103.45 139.19,105.13 136.64,105.13 136.62,105.13 132.34,103.62 v2(130.15,103.62) 126.26,103.62 124.6,105.28 115.96,105.28 109.03,112.21 98.42,112.21 95.05,115.58 93.66,115.58 89.09,120.14 89.09,120.87 88.74,121.21 79.79,121.21 79.72,121.15 JWLAN1.3
USB20_TOUCH_N2: length 48.5
  TOP w0.112: U58.8 219.06,56.26 218.94,56.37 218.59,56.37 v1(218.5,56.28)
  IN3 w0.135: v1(218.5,56.28) 218.33,56.45 217.67,56.45 217.43,56.2 217.43,55.46 217.88,55.01 217.88,54.19 220.32,51.76 220.76,51.76 221.65,50.87 221.65,49.9 222.75,48.8 222.75,46.24 222.23,45.72 220.26,45.72 219.87,45.32 219.87,40.1 218.66,38.89 216.09,38.89 215.73,38.53 212.4,38.53 211.52,39.41 210.49,39.41 210.35,39.27 210.35,38.38 209.83,37.86 v1(208.89,37.86)
  BOTTOM w0.112: v1(208.89,37.86) 207.35,37.86 206.69,38.52 206.69,39.86 207.23,40.41 207.75,40.41 207.86,40.52 207.86,41.04 DX3.3 208.11,41.02 208.11,40.57 208.22,40.46 208.64,40.46 209.37,41.19 209.67,41.19 210.78,42.31 211.43,42.95 JEDP1.36
USB20_TOUCH_P2: length 48.6
  TOP w0.112: v1(218.5,56.87) 218.73,56.63 218.88,56.63 219.13,56.89 U58.9
  IN3 w0.135: v1(218.5,56.87) 218.36,56.73 217.55,56.73 217.14,56.32 217.14,55.35 217.59,54.89 217.59,54.08 220.2,51.47 220.65,51.47 221.37,50.75 221.37,49.78 222.47,48.68 222.47,46.36 222.11,46 220.15,46 219.59,45.44 219.59,40.22 218.54,39.17 215.97,39.17 215.62,38.82 212.51,38.82 211.64,39.69 210.37,39.69 210.07,39.39 210.07,38.5 209.71,38.15 209.2,38.15 208.9,38.45 v1(208.89,38.45)
  BOTTOM w0.112: JEDP1.37 212,42.45 211.76,42.69 211.54,42.69 v2(210.97,42.12) 209.78,40.92 209.48,40.92 208.75,40.19 208.22,40.19 208.11,40.08 208.11,39.37 DX3.2 207.84,39.35 207.84,40.03 207.73,40.14 207.34,40.14 206.95,39.75 206.95,38.63 207.46,38.13 208.57,38.13 v1(208.89,38.45)
USB_EN#: length 249.3
  TOP w0.089: v1(40.37,81.31) 40.75,81.69 41.34,81.69 42.15,82.51 UE1.84 42.15,84.23 42.64,84.72 42.64,84.91 RE18.1 ; UU1.4 193.92,31.79 193.92,31.39 CU20.1 194.59,31.75 195.94,31.75 196.19,31.5 v1(196.19,31.34)
  IN1 w0.089: v1(38.19,59.39) 38.19,59.41 37.33,60.26 35.85,60.26 34.84,61.27 30.38,61.27 v1(28.23,59.11)
  IN2 w0.089: v1(196.19,31.34) 195.8,30.96 192.13,30.96 190.24,32.85 188.66,32.85 186.92,31.12 181.4,31.12 181.29,31.22 180.7,31.22 178.86,29.39 175.87,29.39 175.26,28.78 173.44,28.78 172.9,29.32 169.07,29.32 168.87,29.11 163.86,29.11 163.44,28.69 151.24,28.69 150.91,29.02 148.84,29.02 146.28,31.57 146.28,31.95 145.02,33.22 137.79,33.22 135.92,31.36 128.88,31.36 125.26,27.73 121.03,27.73 120.17,28.59 117.5,28.59 116.64,27.73 112.24,27.73 111.67,28.3 110.69,28.3 110.12,27.73 99.39,27.73 99.19,27.93 97.7,27.93 96.75,26.99 83.95,26.99 83.1,27.83 67.38,27.83 65.89,29.33 62.79,29.33 62.05,28.59 60.62,28.59 59.57,29.65 59.57,30.78 54.22,36.13 48.23,36.13 44.98,39.39 44.98,50.61 42.08,53.51 42.08,54.56 38.19,58.45 v1(38.19,59.39) 38.19,60.59 38.44,60.84 38.44,64.38 38.38,64.44 38.38,68.72 38.25,68.85 38.25,69.16 38.26,69.17 38.26,70.57 38.67,70.98 38.67,71.13 39.28,71.73 39.28,72.42 40.24,73.38 40.24,74.68 39.5,75.42 39.5,76.78 40,77.29 40,79.94 40.31,80.25 40.31,81.25 v1(40.37,81.31)
  BOTTOM w0.089: v1(28.23,59.11) 27.65,59.11 25.78,60.99 24.38,60.99 23.57,60.18 23.57,56.43 22.82,55.69 21.77,55.69 20.8,54.72 UI1.4 20.8,52.78 CU9.1
USB_OC0#: length 181
  TOP w0.089: 136.78,62.59 136.88,62.7 138.74,62.7 139.75,61.7 140.25,61.7 140.8,62.25 v3(140.8,62.61) 140.8,63.08 142.91,65.18 RC905.2
  TOP w0.099: v1(130.4,63.69) 130.77,63.32 131.65,63.32 132.62,62.35 132.95,62.35 133.25,62.04 136.22,62.04 136.78,62.59
  IN1 w0.089: v1(42.16,61.31) 42.06,61.2 35.17,61.2 34.92,61.45 29.93,61.45 v1(28.23,59.75)
  IN2 w0.089: v1(42.16,61.31) 42.64,61.31 43.92,60.03 43.92,59 44.82,58.1 45.63,58.1 50.62,53.11 50.62,48.84 56.27,43.19 56.27,41.17 60.91,36.53 63.78,36.53 65.23,35.08 78.58,35.08 79.03,34.62 80.25,34.62 81.17,33.71 96.58,33.71 97.57,34.7 100.16,34.7 100.38,34.92 103.1,34.92 104.09,33.94 104.5,33.94 104.71,34.14 106.92,34.14 107.68,33.38 110.12,33.38 110.17,33.34 114.87,33.34 115.34,33.8 116.25,33.8 116.92,34.47 117.59,34.47 118.34,35.22 120.57,35.22 120.92,35.57 124.59,35.57 129.72,40.7 129.78,40.7 131.2,42.12 131.38,42.12 132.46,43.2 133.12,43.2 134.54,44.62 134.54,46.82 132.65,48.71 132.65,50.02 131.81,50.86 131.12,50.86 130.18,51.8 130.18,54.37 129.31,55.24
  IN2 w0.099: v1(130.4,63.69) 130.02,63.31 129.24,63.31 129.06,63.13 129.06,60.35 129.31,60.11 129.31,55.24
  BOTTOM w0.089: v1(28.23,59.75) 27.28,59.75 25.85,61.17 24.3,61.17 23.3,60.17 23.3,59.08 21.5,57.27 CU10.1 20.8,57.26 UI1.3
  BOTTOM w0.1: v1(130.4,63.69) 130.83,64.12 UC1.AK10
USB_OC1#: length 97.8
  TOP w0.089: v1(186.63,36.61) 186.73,36.52 186.73,35.74 187.85,34.62 188.9,34.62 189,34.72 UU1.3 193.39,35.45 193.75,35.81 CU19.1 ; RC906.2 148.02,64.38 v3(147.02,65.38) 146.68,65.72 145.7,65.72 145.6,65.61 143.08,65.61 140.39,62.92 140.39,62.27 140.28,62.16 v1(140.18,62.16) 140.18,62.16 139.96,61.95 139.76,61.95 138.82,62.89 136.82,62.89 136.78,62.89 136.78,62.88
  TOP w0.099: v1(131.97,63.77) 132.43,63.31 132.43,62.82 132.7,62.55 133.03,62.55 133.25,62.32 136.22,62.32 136.78,62.88
  IN2 w0.089: v1(186.63,36.61) 186.56,36.61 186.56,36.61 186.44,36.61 185.97,36.13 182.62,36.13 181.82,36.93 177.61,36.93 176.71,36.03 174.67,36.03 173.79,35.15 173.79,34.82 173.3,34.34 170.96,34.34 169.54,35.76 163.51,35.76 162.31,36.95 154.07,36.95 153.92,37.1 153.59,37.1 151.55,39.14 150.38,39.14 143.05,46.47 143.05,56.96 140.18,59.82 v1(140.18,62.16)
  BOTTOM w0.1: UC1.AK9 131.63,64.11 v1(131.97,63.77)
USB_OC2#: length 235.7
  TOP w0.089: RC6121.2 144.04,64.7 142.69,64.7 141.13,63.15 141.13,62.28 140.37,61.51 139.67,61.51 139.5,61.68 139.11,61.68 138.95,61.84 136.78,61.84 ; UT8.3 38.08,131.06 38.44,130.7 38.44,128.93 38.08,128.57 38.08,126.37 39.11,125.34 39.11,123.04 40.61,121.54 40.61,116.25 40.87,116 44.83,116 45.25,115.57 45.25,112.41 v1(45.14,112.3)
  TOP w0.099: v1(130.42,62.94) 130.43,62.94 130.44,62.93 v3(131.28,62.93) 131.76,62.93 132.57,62.12 132.89,62.12 133.17,61.84 136.78,61.84
  IN2 w0.089: v1(45.14,112.3) 45.05,112.21 45.05,111.57 43.94,110.46 43.94,88.39 43.82,88.28 43.82,85.91 43.07,85.15 43.07,81.96 43.21,81.81 43.21,79.09 43.46,78.85 43.46,76.08 43.21,75.83 43.21,72.91 43.46,72.67 43.87,72.25 43.87,71.57 44.34,71.1 44.34,70.79 43.67,70.11 43.67,68.11 44.32,67.45 44.32,65.95 43.15,64.78 43.15,63.45 41.75,62.05 41.75,61.2 42.01,60.94 42.75,60.94 43.74,59.95 43.74,58.92 44.74,57.91 45.56,57.91 50.43,53.04 50.43,48.69 56.09,43.04 56.09,41.06 60.8,36.34 63.58,36.34 65.03,34.9 78.39,34.9 78.84,34.44 80.18,34.44 81.09,33.53 96.65,33.53 97.64,34.52 100.73,34.52 101.1,34.15 103.62,34.15 104.01,33.75 104.58,33.75 104.79,33.96 106.84,33.96 107.6,33.2 110.05,33.2 110.09,33.16 114.95,33.16 115.41,33.62 116.32,33.62 116.99,34.29 120.75,34.29 120.78,34.33 121.24,34.78 124.91,34.78 128.58,38.45 129.13,38.45 132.71,42.03 133.06,42.89 134.72,44.54 134.72,46.9 132.84,48.78 132.84,50.09 131.87,51.06 131.18,51.06 130.36,51.88 130.36,54.61 129.75,55.22
  IN2 w0.099: v1(130.42,62.94) 130.42,62.95 130.26,63.11 129.36,63.11 129.26,63.01 129.26,60.49 130.14,59.61 130.14,55.92 129.75,55.53 129.75,55.22
  BOTTOM w0.1: UC1.AL9 131.25,62.93 130.44,62.93 130.43,62.94 v1(130.42,62.94)
USBC_B2B_OVP: length 1.9
  TOP w0.254: PQS03.5 PQS03.6 55.8,132.77 PRS13.2
USBC_B2B_S1: length 17.4
  TOP w0.089: v3(43.89,121.72) 44.02,121.59 PDS04.1
  TOP w0.254: v1(60.59,125.73) 60.38,125.52 PRS42.1
  BOTTOM w0.254: v1(60.59,125.73) 59.11,125.73 57.37,123.98 53.82,123.98 52.33,125.47 50.92,125.47 48.47,123.02 v1(48.15,123.02)
USBC_B2B_S1_A: length 15.8
  TOP w0.089: v1(50.8,126.4) v3(51.16,126.76)
  TOP w0.254: PQS08.1 49.5,126.18 PRS12.2 50.78,126.39 v1(50.8,126.4) ; PQS03.3 58.76,130.87 PRS14.1 PCS11.1 58.48,132.1 56.57,132.1 54.2,129.73 54.2,129.55 PQS04.2 v1(52.93,129.22)
  IN2 w0.254: v1(50.8,126.4) 50.84,126.4 52.93,128.49 v1(52.93,129.22)
USBC_B2B_S2: length 8.6
  TOP w0.089: v3(55.08,128.13) 55.34,128.38 v1(55.74,128.38)
  TOP w0.254: PQS62.2 56.81,133.94 v1(57.27,133.49)
  IN2 w0.254: v1(57.27,133.49) 57.62,133.14 57.62,128.63 57.36,128.38 v1(55.74,128.38)
USBC_B2B_S2_G: length 20.3
  TOP w0.089: v3(61.35,127.9) 61.69,127.9 62.18,128.38 PQS06.1
  TOP w0.254: PQS06.1 61.48,129.54 61.22,129.79 61.22,130.7 PRS16.1 v1(62.24,131.72) ; v1(67.06,136.74) 66.71,137.09 66.71,138.95 PRS09.2 66.19,139.46 PCS10.2 65.2,139.61 PQS02.4
  IN2 w0.254: v1(62.24,131.72) 62.24,135.89 63.09,136.74 v1(67.06,136.74)
USBC_B2B_S3: length 2.3
  TOP w0.254: PRS18.1 61.53,126.22 PCS17.1 62.43,126.22 62.96,126.76 PQS07.2
USBC_SW_PROCHOT: length 8.9
  TOP w0.254: PCS20.1 62.66,118.52 62.66,119.16 62.51,119.31 62.51,120.7 62.18,121.04 v3(62.18,121.61) 62.3,121.61 62.86,122.17 62.86,122.88 62.32,123.42 PRS28.2 62.85,123.47 63.02,123.3 PQS10.6 63.37,124.06 PCS19.1
VBIOS_ID1: length 10.2
  TOP w0.099: RC711.2 129.78,46.79 129.78,48.29 129.32,48.75 RC712.1 129.32,49.13 129.82,49.63 129.82,50.5 129.28,51.04 128.92,51.04 v1(128.18,51.77) 128.18,52.25 128.53,52.6 v3(128.53,52.65)
  BOTTOM w0.089: v1(128.18,51.77) 128.39,51.98 128.39,53.85 UC1.BD13
VCIN0_PH: length 143.6
  TOP w0.089: v1(48.09,84.66) 47.29,84.66 46.96,85 PR52.1 ; v1(47.76,78.49) 47.49,78.22 47.49,77.64 45.79,75.94 40.86,75.94 39.9,76.91 36.66,76.91 36.56,77.01 UE1.109
  TOP w0.099: v1(120.75,49.84) 121.38,49.21 121.38,48.31 PH1.1
  IN2 w0.089: 61.02,41.97 61.02,41.31 62.36,39.97 64.43,39.97 66.51,37.89 79.58,37.89 80.24,37.23 87.38,37.23 87.85,37.7 89.43,37.7 90.17,36.97 93.62,36.97 95.55,38.9 105.58,38.9 106.18,39.5 108.42,39.5 110.82,37.1 111.46,36.65 112.47,36.29 113.87,36.29 115.12,36.88 116.99,38.75 116.99,40.65 118.42,42.08 120.53,42.08 121,42.55 121,48.32 121.13,48.45 121.13,49.46 v1(120.75,49.84) ; 58.79,44.64 53.64,49.79 53.64,54.54 50.14,58.05 50.14,66.25 48.75,67.63 48.75,69.47 49.13,69.86 49.13,70.8 48.65,71.28 48.65,73.13 49.05,73.53 49.05,77.37 47.93,78.49 v1(47.76,78.49) 48.11,78.84 48.11,84.56 48.09,84.57 v1(48.09,84.66)
  IN2 w0.102: 61.02,41.97 61.02,42.85 59.23,44.64 58.79,44.64
VCOUT0: length 2.5
  TOP w0.089: RE35.1 34.09,78.1 35,79.01 UE1.104
VCOUT0_PH#: length 16.8
  TOP w0.089: v3(31.64,77.65) v1(32.16,77.65) 32.18,77.65 32.63,78.1 RE35.2
  BOTTOM w0.254: v1(32.16,77.65) 32.07,77.65 31.64,78.08 31.64,81.93 31.63,81.94 31.63,83.1 32.29,83.76 32.29,86.74 31.44,87.59 30.87,87.59 29.43,89.02 28.22,89.02 PR507.1
VCOUT1_PH: length 2.3
  TOP w0.089: RE43.1 34.18,78.93 34.67,79.41 UE1.103
VGA_AC__BATT: length 140.7
  TOP w0.089: UV8.4 49.68,89.04 RV150.1 50.33,89.55 50.08,89.8 v1(49.93,89.8)
  TOP w0.102: v1(126.04,121.61) 125.48,122.18 125.48,126.45 v1(124.93,127)
  IN1 w0.102: v1(126.04,121.61) 127.25,121.61 131.34,117.52 v1(131.34,117.14)
  IN2 w0.089: v1(133.4,107.61) 133.2,107.81 128.73,107.81 128.2,107.28 126.08,107.28 125.66,106.86 118.76,106.86 118.5,106.6 105.98,106.6 101.14,111.44 95.61,111.44 94.95,112.11 91.03,112.11 89.86,113.28 84.18,113.28 84.15,113.31 81.17,113.31 80.42,112.55 77.21,112.55 76.13,113.63 73.76,113.63 72.84,112.7 64.36,112.7 63.43,113.63 60.45,113.63 60.26,113.44 51.77,113.44 50.57,112.23 49.49,112.23 48.09,110.84 48.09,105.88 48.71,105.25 48.71,90.41 49.33,89.8 v1(49.93,89.8)
  BOTTOM w0.089: v1(133.4,107.61) 133.07,107.94 133.07,109.76 133.28,109.98 133.28,113.65 RV260.2 130.72,116.51 v1(131.34,117.14)
  BOTTOM w0.102: v1(124.93,127) 124.53,127.4 UV1.T9
VGA_SMB_CK3: length 6.9
  TOP w0.112: RV6.2 123.4,120.59 QV1.1 123.66,120.89 123,121.55 v3(123,123.31) 123,124.2 122.82,124.38 122.82,125.38 v1(122.63,125.56)
  BOTTOM w0.102: UV1.U7 122.87,125.8 v1(122.63,125.56)
VGA_SMB_DA3: length 6.1
  TOP w0.112: v1(122.63,126.24) 123.06,125.82 123.06,124.48 123.34,124.19 124.45,124.19 RV5.2 124.96,123.68 QV1.4
  BOTTOM w0.102: v1(122.63,126.24) 122.79,126.24 UV1.U8
VGATE: length 233.7
  TOP w0.089: RC28.1 46.34,85.09 46.34,84.45 46.15,84.26 UE1.74 46.15,82.62 46.24,82.53 46.24,81.96 v1(46.59,81.61)
  TOP w0.203: PUZ01.20 151.39,85.53 151.19,85.33 v1(151.19,84.2)
  TOP w0.254: PRH19.1 166.11,48.89 165.26,48.04 165.26,47.26 v1(165.34,47.19)
  IN1 w0.089: v1(165.34,47.19) 165.34,41.13 164.69,40.49 156.73,40.49 156.01,41.21 154.6,41.21 154.1,41.71 154.1,42.73 153.68,43.15 152.07,43.15 151.29,43.93 151.29,48.61 153.11,50.43 153.11,68.74 153.31,68.93 153.31,76.52 151.5,78.33 151.5,81.83 151.19,82.14 v1(151.19,84.2)
  IN2 w0.089: v1(50.22,82.49) 49.44,83.27 49.44,88.06 48.53,88.97 48.53,105.18 47.91,105.8 47.91,110.91 49.41,112.42 50.49,112.42 51.7,113.63 59.39,113.63 60.49,114.73 63.34,114.73 65.18,112.88 72.76,112.88 73.38,113.5 73.38,113.5 73.69,113.81 76.21,113.81 77.28,112.74 80.34,112.74 81.09,113.49 84.23,113.49 84.26,113.46 89.94,113.46 91.11,112.29 95.02,112.29 95.64,111.67 101.35,111.67 106.05,106.97 117.56,106.97 117.64,107.04 125.59,107.04 126,107.46 128.12,107.46 128.71,108.04 133.49,108.04 133.89,107.65 133.89,106.71 135.42,105.18 139.16,105.18 141.7,102.65 141.7,99.38 146.39,94.69 146.39,90.75 149.13,88.01 149.22,88.01 150.65,86.57 150.65,84.74 v1(151.19,84.2)
  IN3 w0.089: v1(46.59,81.61) 46.7,81.61 47.67,82.58 50.13,82.58 v1(50.22,82.49)
  BOTTOM w0.089: v1(151.19,84.2) 151.47,84.2 v3(151.77,83.89)
  BOTTOM w0.203: PRZ24.2 150.8,83.81 v1(151.19,84.2)
VL: length 1.9
  TOP w0.089: v1(24.16,95.37) v3(23.62,95.37)
  TOP w0.508: v1(24.16,95.37) 24.34,95.55 PC515.1
  BOTTOM w0.254: PU501.15 24.41,95.37 v1(24.16,95.37)
VR_ON: length 174.6
  TOP w0.089: v1(49.39,72.59) 49.21,72.77 46.32,72.77 46.03,72.48 43.38,72.48 42.69,73.18 37.82,73.18 36.85,72.21 UE1.121
  TOP w0.254: PRZ19.1 v1(151.36,92.39)
  IN2 w0.089: v1(151.36,92.39) 149.88,92.39 148.58,93.69 147.7,93.69 141.91,99.48 141.91,102.7 139.24,105.37 135.57,105.37 134.08,106.86 134.08,107.72 133.57,108.23 128.63,108.23 128.05,107.64 125.93,107.64 125.51,107.23 117.56,107.23 117.49,107.15 106.12,107.15 101.42,111.85 95.72,111.85 95.1,112.47 91.19,112.47 90.01,113.65 86.13,113.65 86.1,113.67 81.02,113.67 80.26,112.92 77.36,112.92 76.29,113.99 73.61,113.99 72.87,113.26 65.07,113.26 63.42,114.91 60.42,114.91 59.32,113.81 51.62,113.81 50.41,112.6 49.33,112.6 47.72,110.99 47.72,105.72 48.35,105.1 48.35,88.9 49.26,87.98 49.26,83.89 48.66,83.28 48.66,80.16 49.6,79.22 49.6,72.8 v1(49.39,72.59)
  BOTTOM w0.089: v1(151.36,92.39) v3(151.9,92.39)
VSUM+_APU: length 14.5
  TOP w0.203: PCZ34.1 148.17,88.54 PCZ32.1 148.81,87.12 v1(148.99,87.12) 149.12,87.24 149.49,87.24 150.17,87.93 PUZ01.14
  TOP w0.254: PRZ27.1 149.47,81.56 v1(149.47,81.99)
  BOTTOM w0.254: PRZ33.1 PRZ32.1 148.84,87.27 v1(148.99,87.12) v3(148.99,83.5) 148.99,82.61 149.47,82.13 v1(149.47,81.99) 149.47,81.57 PRZ45.1
VSUM+_VGA: length 14.6
  TOP w0.203: PUV01.14 73.58,126.4 v1(73.45,126.27)
  TOP w0.254: PRV07.2 68.36,122.14 PCV30.1 69.58,122.99 PRV30.1 PCV28.1 70.96,122.97 v1(70.87,122.88) 70.96,122.79 70.96,122.09 PRV28.1 70.1,122.03 69.74,121.67 v3(69.74,121.45) 69.74,121.14 69.2,120.59 68.88,120.59 68.14,119.86 PRV24.2
  IN3 w0.254: v1(73.45,126.27) 73.45,125.37 70.96,122.88 v1(70.87,122.88)
VSUM-_APU: length 46.4
  TOP w0.203: PCZ34.2 148.57,90.09 149.07,89.59 149.36,89.59 PCZ27.2 PCZ28.2 149.39,88.37 149.08,88.07 PCZ32.2
  TOP w0.254: v1(149.54,80.6) 149.58,80.6 150.24,79.95 PRZ28.1 ; v1(148.36,89.4) 148.36,89.7 148.32,89.74 PCZ34.2
  IN1 w0.089: v1(149.54,80.6) 149.54,79.05 152.57,76.02 152.57,69.23 151.77,68.43 151.77,63.12 152.38,62.5 152.38,60.76 v1(152.04,60.42)
  IN3 w0.254: v1(148.36,89.4) 150.78,86.98 150.78,86.23 150.4,85.85 149.59,85.85 148.13,84.39 148.13,82.32 148.04,82.22 148.04,81.61 149.05,80.6 v1(149.54,80.6)
  BOTTOM w0.254: v1(152.04,60.42) 152.47,60.85 152.47,61.69 PHZ02.2 ; PRZ33.2 146.89,88.79 PRZ39.1 147.71,88.84 PRZ36.1 148.28,89.4 v1(148.36,89.4) 148.75,89.4 PCZ46.1 ; PRZ46.1 148.18,79.98 148.8,80.59 149.53,80.59 v1(149.54,80.6)
VSUM-_VGA: length 35.2
  TOP w0.254: v1(72.67,122.56) 72.36,122.56 72.17,122.75 PRV25.2 71.85,122.82 PRV35.1 ; PCV32.1 69.43,124.4 PRV30.2 PCV28.2 71.07,124.4 PRV35.1 ; PCV32.1 68.02,122.99 PCV30.2 67.09,122.99 PRV08.2 ; PCV32.1 68.87,124.53 PCV22.2 68.94,125.79 PCV23.2 ; PRV33.1 PRV35.1
  IN2 w0.254: v1(92.32,118.32) 91.97,118.67 88.58,118.67 87.31,119.95 77.66,119.95 75.94,121.66 73.74,121.66 72.84,122.56 v1(72.67,122.56)
  BOTTOM w0.254: PHV02.2 92.32,119.27 v1(92.32,118.32)
VSUMN_NB: length 13.3
  TOP w0.254: PRZ09.2 161.41,90.46 PCZ06.2 ; PCZ06.2 160.17,90.46 PRZ11.1 158.92,90.91 PRZ10.1 158.92,91.27 PCZ07.2 158.55,92.31 158.86,92.31 PRA04.1 v1(160.22,93.04) ; PCZ06.2 160.57,90.1 160.71,89.96 PCZ08.1
  IN1 w0.254: v1(156.37,92.82) 156.37,93.02 156.92,93.57 158.36,93.57 158.9,93.04 v1(160.22,93.04)
  BOTTOM w0.254: v1(156.37,92.82) 156.07,92.82 155.48,93.4 PHA01.2
VSUMP_NB: length 11.4
  TOP w0.089: v1(161.65,92.07) 161.65,92.63 v3(162.01,92.98)
  TOP w0.203: PUZ01.40 157.52,89.13 158.28,89.89 v1(158.28,90.51)
  TOP w0.254: PCZ07.1 159.92,92.29 PRA03.1 160.8,92.01 160.57,91.78 PCZ06.1 160.59,91.39 PRZ09.1 161.65,91.62 v1(161.65,92.07)
  BOTTOM w0.254: v1(158.28,90.51) 158.63,90.86 PRZ08.1 159.65,91.15 160.57,92.07 v1(161.65,92.07)
VTTREF_1.2V: length 2
  TOP w0.203: PUM01.4 36.45,30.82 36.41,30.85 36.41,31.82 PCM19.1
WAKEB: length 6.4
  BOTTOM w0.102: UV1.AJ27 113.83,141.49 113.67,141.49 113.36,141.19 113.36,140.94 112.92,140.49 111.41,140.49 v3(110.7,139.77) 110.31,139.39 RV163.1 RV162.2
WL_OFF#: length 208.8
  TOP w0.089: v1(81.8,116.45) 81.8,116.88 82.26,117.33 82.26,117.96 82.13,118.09 QW1.3
  TOP w0.099: RC46.2 125.76,44.23 125.8,44.27 125.8,44.65 125.86,44.7 v1(125.86,44.86) ; v1(124.24,50.37) 124.24,50.44 v3(123.61,51.07)
  IN2 w0.089: v1(81.8,116.45) 81.8,115.75 79.7,113.65 77.66,113.65 76.54,114.78 74.85,114.78 74.45,115.18 67.3,115.18 66.49,114.37 65.53,114.37 63.88,116.02 59.7,116.02 58.6,114.92 50.36,114.92 49.15,113.71 48.87,113.71 46.61,111.45 46.61,105.26 47.11,104.77 47.11,94.43 46.13,93.45 46.13,86.59 46.87,85.85 46.87,82.9 47.18,82.6 47.18,81.35 46.41,80.58 46.41,78.03 45.84,77.46 45.84,75.72 46.85,74.71 46.85,74.1 47.42,73.53 47.42,71.04 46.83,70.46 46.83,68.5 48.96,66.37 48.96,58.69 53.26,54.39 53.26,49.63 56.17,46.72 ; 59.1,42.35 61.92,39.53 64.28,39.53 66.47,37.34 79.52,37.34 80.02,36.84 81.96,36.84 82.26,36.54 93.96,36.54 94.67,37.25 96.98,37.25 97.23,37.49 98.56,37.49 99.37,38.3 105.88,38.3 106.31,38.73 107.15,38.73 107.62,38.26 108.62,38.26 110.35,36.54 111.11,36 112.27,35.55 113.7,35.55 115.36,36.34 117.72,38.71 117.72,39.94 118.57,40.78 119.99,40.78 120.33,41.12 121.82,41.12 124.99,44.3 125.67,44.3 125.86,44.49 v1(125.86,44.86) 125.86,45.43 125.37,45.91 125.37,46.91 125.4,46.94 125.4,47.79 124.37,48.83 124.37,50.24 v1(124.24,50.37)
  IN2 w0.102: 59.1,42.35 58.97,42.48 58.94,42.48 58.55,42.87 58.55,44.34 56.17,46.72
  BOTTOM w0.102: UC1.BB16 125.36,54.68 125.36,54.35 125.67,54.04 125.67,52.86 125.73,52.8 125.73,50.99 125.11,50.37 v1(124.24,50.37)
