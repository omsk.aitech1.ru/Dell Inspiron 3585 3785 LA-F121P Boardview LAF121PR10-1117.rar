# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_CS1#: length 56.9
  IN3 w0.102: 80.55,63.47 78.76,63.47 78.05,64.18 72.09,64.18 70.36,65.91 66.46,65.91 63.92,68.45 v1(63.85,68.45)
  IN3 w0.183: 80.55,63.47 92.47,63.47 93.67,62.27 104.26,62.27 105.02,63.03 105.48,63.03 105.56,63.11 106.9,63.11 106.97,63.18 107.03,63.18 v1(107.39,63.53)
  BOTTOM w0.099: UC1.AM31 113.33,62.81 113.03,62.5 108.41,62.5 v3(108.27,62.65) v1(107.39,63.53)
  BOTTOM w0.168: v1(63.85,68.45) 64.39,68.99 JDIMM2.157
DDR_B_DM0: length 83.7
  IN3 w0.102: v1(60.07,107.72) 60.07,107.51 59.87,107.31 59.05,107.31 58.95,107.21 58.95,106.9 59.05,106.8 63.15,106.8 63.53,107.18 65.02,107.18 65.4,106.8 66.76,106.8 66.91,106.66 70.22,106.66 71.76,105.12 72.45,105.12 72.99,104.58 79.46,104.58 79.71,104.33 80.55,104.33
  IN3 w0.107: v1(121.23,88.54) 121.01,88.77 120.72,88.77 120.63,88.68 120.63,88.15 120.93,87.85 121.66,87.85 121.86,88.05 121.86,90.53 121.13,91.26 121.13,94.08 119.37,95.83 111.06,95.83 104.34,102.56 82.32,102.56 80.55,104.33
  BOTTOM w0.099: v1(121.23,88.54) 121.23,88.02 120.86,87.65 120.86,87.47 120.85,87.46 120.85,87.05 120.93,86.97 120.93,86.48 121.16,86.25 121.16,85.88 UC1.C21
  BOTTOM w0.102: v1(60.07,107.72) 59.59,107.24 JDIMM2.12
DDR_B_DM1: length 69
  IN3 w0.102: 80.55,96.73 79.6,96.73 78,98.33 75.9,98.33 75.8,98.23 75.8,98 75.7,97.9 75.5,97.9 75.4,98 75.4,98.23 75.29,98.33 75.09,98.33 74.99,98.23 74.99,98 74.89,97.9 74.69,97.9 74.58,98 74.58,98.23 74.48,98.33 74.28,98.33 74.18,98.23 74.18,98 74.08,97.9 73.87,97.9 73.77,98 73.77,98.23 73.67,98.33 71.24,98.33 69.89,99.69 69.74,99.69 69.41,99.35 69.26,99.35 69.12,99.49 69.12,99.64 69.46,99.97 69.46,100.12 69.31,100.26 69.17,100.26 68.83,99.92 68.69,99.92 68.54,100.07 68.54,100.21 68.88,100.55 68.88,100.69 68.71,100.86 66.47,100.86 65.48,101.85 64.98,101.85 v1(64.59,101.46)
  IN3 w0.107: v1(115.37,91.48) 115.09,91.48 114.68,91.07 109.13,91.07 103.47,96.73 80.55,96.73
  BOTTOM w0.099: v1(115.37,91.48) 115.83,91.48 116.59,90.71 116.59,89.64 118.03,88.2 118.03,86.91 118.03,86.9 118.03,86.89 117.93,86.79 117.93,86.73 117.93,86.73 117.93,86.48 118.11,86.31 118.11,86.31 118.23,86.18 UC1.C25
  BOTTOM w0.102: JDIMM2.33 65.12,101.99 v1(64.59,101.46)
DDR_B_DM2: length 71.8
  IN3 w0.099: v1(110.24,85.26) 107,85.26 106.62,85.64 106.2,85.64
  IN3 w0.102: 80.54,91.07 78.39,91.07 77.78,90.47 75.57,90.47 74.85,91.19 71.67,91.19 69.84,93.03 69.8,93.03 ; 67.75,93.03 66.83,93.95 65.87,93.95 65.77,94.05 65.77,95.21 65.67,95.31 65.47,95.31 65.36,95.21 65.36,94.05 65.26,93.95 65.03,93.95 64.93,94.05 64.93,94.32 64.83,94.42 64.63,94.42 64.53,94.32 64.53,94.05 64.42,93.95 64.22,93.95 64.12,94.05 64.12,94.32 64.02,94.42 63.81,94.42 63.71,94.32 63.71,94.05 63.61,93.95 63.29,93.95 62.62,94.62 62.62,95.29 v1(62.74,95.41)
  IN3 w0.107: 106.2,85.64 105.08,86.77 103.87,86.77 103.22,87.42 103.22,87.57 103.61,87.95 103.61,88.11 103.46,88.26 103.31,88.26 102.92,87.87 102.77,87.87 102.62,88.02 102.62,88.17 103,88.56 103,88.71 102.85,88.86 102.7,88.86 102.32,88.47 102.17,88.47 102.02,88.63 102.02,88.78 102.4,89.16 102.4,89.31 102.25,89.46 102.1,89.46 101.71,89.08 101.56,89.08 101.41,89.23 101.41,89.38 101.8,89.76 101.8,89.92 101.65,90.07 101.5,90.07 101.11,89.68 100.96,89.68 100.18,90.46 84.65,90.46 84.04,91.07 80.54,91.07 ; 69.8,93.03 67.75,93.03
  BOTTOM w0.099: v1(110.24,85.26) 110.24,85.49 110.34,85.59 110.46,85.59 111.01,86.15 113.07,86.15 113.93,85.28 UC1.E32
  BOTTOM w0.102: v1(62.74,95.41) 62.17,95.98 60.58,95.98 59.82,96.74 JDIMM2.54
DDR_B_DM3: length 62.8
  IN3 w0.099: 106.24,81.69 106.24,81.68 112.21,81.68 v1(112.59,81.3)
  IN3 w0.102: v1(64.62,90.87) 64.7,90.79 64.7,90.59 65.14,90.15 65.29,90.15 65.48,90.34 65.62,90.34 65.77,90.19 65.77,90.05 65.58,89.86 65.58,89.72 65.72,89.57 65.95,89.57 66.05,89.48 66.15,89.37 66.15,89.14 66.31,88.98 68.91,88.98 69.3,88.6 70.79,88.6 72.06,87.33 72.7,87.33 72.81,87.43 72.81,87.82 72.91,87.92 73.11,87.92 73.21,87.82 73.21,87.43 73.31,87.33 74.34,87.33 74.41,87.27 78.67,87.27 79.11,87.71 80.55,87.71
  IN3 w0.107: 80.55,87.71 82.64,87.71 83.25,87.09 87.24,87.09 87.37,86.97 87.37,86.33 87.7,85.99 87.99,85.99 88.1,86.09 88.1,86.99 88.2,87.09 88.42,87.09 88.52,86.99 88.52,86.09 88.63,85.99 88.86,85.99 88.97,86.09 88.97,86.63 89.08,86.74 89.29,86.74 89.4,86.63 89.4,86.09 89.5,85.99 90.12,85.99 90.23,85.88 90.23,85.23 90.34,85.12 100.76,85.12 102.48,83.4 103.68,83.4 104.8,82.28 105.59,82.28 106.18,81.69 106.24,81.69
  BOTTOM w0.099: UC1.K30 114.52,81.51 114.47,81.51 114.46,81.51 114.21,81.51 114.1,81.61 113.46,81.61 113.28,81.78 113.07,81.78 v1(112.59,81.3)
  BOTTOM w0.102: v1(64.62,90.87) 65.24,91.49 JDIMM2.75
DDR_B_DM4: length 63.7
  IN3 w0.099: v1(111.89,60.05) 112.7,60.05 112.85,59.9 112.85,59.54 112.49,59.18 111.22,59.18
  IN3 w0.102: 78.94,59.65 78.02,60.58 70.64,60.58 ; v1(59.53,63.74) 59.58,63.74 60.12,63.19 63.17,63.19 63.51,63.53 65.61,63.53 67.07,62.07 69.15,62.07
  IN3 w0.107: 78.94,59.65 87.9,59.65 89.1,58.46 105.84,58.46 106.57,59.18 109.58,59.18 109.68,59.29 109.68,59.52 109.79,59.62 110,59.62 110.11,59.52 110.11,59.29 110.22,59.18 110.43,59.18 110.54,59.29 110.54,59.52 110.64,59.62 110.86,59.62 110.96,59.52 110.96,59.29 111.07,59.18 111.22,59.18 ; 70.64,60.58 69.15,62.07
  BOTTOM w0.099: UC1.AP30 114.68,60.25 114.34,60.25 114.09,60.01 113.81,60.01 113.69,60.13 113.19,60.13 112.83,60.49 111.99,60.49 111.89,60.39 v1(111.89,60.05)
  BOTTOM w0.102: v1(59.53,63.74) JDIMM2.178
DDR_B_DM5: length 59.3
  IN3 w0.102: 69.49,56.07 68.08,56.07 66.49,57.66 63.28,57.66 63.07,57.86 63.07,58.49 63.18,58.59 64.63,58.59 v1(64.9,58.33) ; 79.05,55.56 70.46,55.56 69.89,56.12 69.54,56.12
  IN3 w0.107: v1(112.29,55.14) 111.9,54.75 111.44,54.75 111.33,54.64 111.33,54.52 111.22,54.42 111.01,54.42 110.9,54.52 110.9,54.64 110.8,54.75 110.58,54.75 110.48,54.64 110.48,54.52 110.37,54.42 110.15,54.42 110.05,54.52 110.05,54.64 109.94,54.75 109.65,54.75 108.68,53.78 86.66,53.78 85.43,55.01 79.6,55.01 79.05,55.56 ; 69.49,56.07 69.54,56.12
  BOTTOM w0.099: v1(112.29,55.14) 112.29,55.19 113.8,56.7 114.22,56.7 UC1.AW31
  BOTTOM w0.102: JDIMM2.199 65.06,58.49 v1(64.9,58.33)
DDR_B_DM6: length 70.6
  IN3 w0.102: 78.74,50.39 68.24,50.39 68.18,50.45 65.86,50.45 65.13,51.18 64.98,51.18 64.74,50.94 64.6,50.94 64.45,51.08 64.45,51.23 64.7,51.47 64.7,51.62 63.97,52.34 62.87,52.34 61.98,53.24 61.71,53.24 61.61,53.14 61.61,52.14 61.5,52.04 61.3,52.04 61.2,52.14 61.2,53.14 61.1,53.24 60.89,53.24 60.79,53.14 60.79,52.14 60.69,52.04 60.49,52.04 60.39,52.14 60.39,53.14 60.28,53.24 v1(59.53,53.24)
  IN3 w0.107: 78.74,50.39 78.75,50.37 83.5,50.37 84.74,49.14 85.36,48.51 106.65,48.51 107.78,49.64 108.75,49.64 109.32,50.22 109.69,50.22 109.8,50.33 109.8,50.68 v1(109.88,50.76)
  BOTTOM w0.099: v1(109.88,50.76) 109.88,51.47 109.98,51.57 116.2,51.57 116.86,52.22 116.86,53.15 116.85,53.15 116.85,53.46 116.86,53.46 116.86,54.11 117.03,54.28 117.03,54.28 117.23,54.48 UC1.BB26
  BOTTOM w0.102: JDIMM2.220 58.25,53.24 v1(59.53,53.24)
DDR_B_DM7: length 76.1
  IN3 w0.102: 69.06,44.42 69.09,44.42 69.43,44.07 69.85,44.07 ; 69.86,44.06 70.01,44.06
  IN3 w0.107: 69.85,44.07 69.86,44.06 ; 69.06,44.42 69.05,44.43 68.75,44.43 68.65,44.32 68.65,43.86 68.54,43.75 68.33,43.75 68.22,43.86 68.22,44.32 68.11,44.43 67.9,44.43 67.79,44.32 67.79,43.86 67.69,43.75 67.47,43.75 67.37,43.86 67.37,44.32 67.26,44.43 67.05,44.43 66.94,44.32 66.94,43.86 66.83,43.75 66.62,43.75 66.51,43.86 66.51,44.32 66.41,44.43 66.26,44.43 65.51,45.18 65.09,45.18 63.93,46.33 63.68,46.33 v1(63.47,46.54) ; 70.01,44.06 70.09,43.98 70.6,43.98 70.7,43.88 70.7,43.35 70.81,43.24 71.03,43.24 71.13,43.35 71.13,43.88 71.24,43.98 71.63,43.98 71.73,43.88 71.73,43.79 71.84,43.68 72.05,43.68 72.16,43.79 72.16,43.88 72.27,43.98 72.48,43.98 72.59,43.88 72.59,43.79 72.69,43.68 72.91,43.68 73.01,43.79 73.01,43.88 73.12,43.98 73.71,43.98 73.82,44.09 73.82,44.28 73.92,44.38 74.14,44.38 74.24,44.28 74.24,44.09 74.35,43.98 74.56,43.98 74.67,44.09 74.67,44.28 74.78,44.38 74.99,44.38 75.1,44.28 75.1,44.09 75.2,43.98 75.42,43.98 75.52,44.09 75.52,44.28 75.63,44.38 75.84,44.38 75.95,44.28 75.95,44.09 76.06,43.98 76.27,43.98 76.38,44.09 76.38,44.28 76.48,44.38 76.7,44.38 76.8,44.28 76.8,44.09 76.91,43.98 79.48,43.98 80.62,42.84 97.91,42.84 98.89,43.83 108.53,43.83 110.87,46.17 v1(111.23,46.17)
  BOTTOM w0.099: v1(111.23,46.17) 111.51,45.88 115.44,45.88 119.35,49.8 119.35,51.66 120.23,52.54 UC1.BD22
  BOTTOM w0.102: v1(63.47,46.54) 63.63,46.54 64.52,47.43 64.96,47.43 65.52,47.99 JDIMM2.241
DDR_B_DQ0: length 83.8
  IN3 w0.102: 80.55,105.19 79.4,105.19 79.3,105.3 79.3,105.57 79.2,105.67 78.99,105.67 78.89,105.57 78.89,105.3 78.79,105.19 78.59,105.19 78.48,105.3 78.48,105.71 78.38,105.81 78.24,105.81 78.08,105.65 78.08,105.3 77.98,105.19 73.68,105.19 71.96,106.92 71.47,106.92 70.56,107.83 65.75,107.83 65.62,107.69 63.83,107.69 63.76,107.77 v1(62.49,107.77)
  IN3 w0.107: v1(123.03,89.78) 122.68,90.13 122.68,90.87 121.95,91.6 121.95,94.42 119.71,96.66 111.4,96.66 104.68,103.38 82.66,103.38 82.36,103.68 82.36,103.83 82.89,104.37 82.89,104.52 82.74,104.67 82.59,104.67 82.06,104.14 81.91,104.14 81.76,104.29 81.76,104.44 82.29,104.97 82.29,105.12 82.14,105.27 81.99,105.27 81.45,104.74 81.3,104.74 80.85,105.19 80.55,105.19
  BOTTOM w0.099: UC1.B21 121.73,86.21 121.73,86.89 121.83,86.99 121.83,87.17 121.83,87.17 121.83,88.05 121.85,88.07 121.85,88.7 122.94,89.78 v1(123.03,89.78)
  BOTTOM w0.102: v1(62.49,107.77) 62.01,108.24 JDIMM2.8
DDR_B_DQ1: length 81.3
  IN3 w0.102: 80.55,106.33 75.6,106.33 75.5,106.43 75.5,107.02 75.4,107.12 75.19,107.12 75.09,107.02 75.09,106.43 74.99,106.33 74.7,106.33 74.59,106.43 74.59,107.02 74.49,107.12 74.29,107.12 74.19,107.02 74.19,106.43 74.09,106.33 73.88,106.33 73.78,106.43 73.78,107.02 73.68,107.12 73.48,107.12 73.38,107.02 73.38,106.43 73.27,106.33 72.97,106.33 72.02,107.29 71.62,107.29 70.67,108.24 69.8,108.24 69.79,108.24 67.22,108.24 66.9,108.57 64.53,108.57 v1(64.03,109.06)
  IN3 w0.107: 80.55,106.33 81.66,106.33 84.2,103.79 104.85,103.79 111.57,97.07 119.88,97.07 122.36,94.59 122.36,91.77 123.09,91.04 123.09,90.49 v1(123.09,90.48)
  BOTTOM w0.099: UC1.D21 121.73,85.78 121.43,86.08 121.43,86.33 121.43,86.33 121.43,86.38 121.53,86.47 121.53,86.48 121.53,86.48 121.53,86.98 121.63,87.07 121.63,88.13 121.65,88.15 121.65,89.05 v1(123.09,90.48)
  BOTTOM w0.102: JDIMM2.7 65.35,108.49 65.27,108.57 64.53,108.57 v1(64.03,109.06)
DDR_B_DQ2: length 85.2
  IN3 w0.102: 80.04,101.29 79.28,102.04 79.02,102.04 78.91,102.14 78.91,103.14 78.81,103.25 78.61,103.25 78.51,103.14 78.51,102.14 78.41,102.04 78.18,102.04 78.08,102.14 78.08,102.76 77.97,102.87 77.77,102.87 77.67,102.76 77.67,102.14 77.57,102.04 77.34,102.04 77.24,102.14 77.24,102.71 77.14,102.81 76.88,102.81 76.78,102.71 76.78,102.14 76.68,102.04 76.48,102.04 76.37,102.14 76.37,102.71 76.27,102.81 76,102.81 75.9,102.71 75.9,102.14 75.8,102.04 75.6,102.04 75.5,102.14 75.5,102.71 75.39,102.81 75.19,102.81 75.09,102.71 75.09,102.14 74.99,102.04 74.78,102.04 74.68,102.14 74.68,102.71 74.58,102.81 74.38,102.81 74.28,102.71 74.28,102.14 74.17,102.04 73.97,102.04 73.87,102.14 73.87,102.71 73.77,102.81 72.09,102.81 69.67,105.24 66.76,105.24 66.76,105.23 63.08,105.23 v1(62.49,105.83)
  IN3 w0.107: v1(119.04,91.09) 119.86,91.91 119.86,93.55 118.84,94.56 110.53,94.56 104.65,100.45 96.62,100.45 95.79,101.29 80.04,101.29
  BOTTOM w0.099: UC1.B23 119.73,86.89 119.83,86.99 119.83,87.72 119.36,88.19 119.36,88.34 119.35,88.34 119.35,89.18 119.27,89.26 119.27,89.27 118.29,90.26 118.29,90.99 118.38,91.09 v1(119.04,91.09)
  BOTTOM w0.102: v1(62.49,105.83) 61.9,105.24 JDIMM2.20
DDR_B_DQ3: length 81.8
  IN3 w0.102: v1(64.37,104.1) 64.39,104.1 64.8,104.52 66.47,104.52 66.57,104.42 69.22,104.42 72.05,101.59 78.67,101.59 80.55,99.7
  IN3 w0.107: v1(118.62,93.53) 118.41,93.74 118.17,93.74 118.06,93.63 118.06,92.21 117.94,92.09 117.79,92.09 117.63,92.24 117.63,93.63 117.53,93.74 117.29,93.74 117.19,93.63 117.19,92.75 117.05,92.61 116.9,92.61 116.76,92.75 116.76,93.63 116.65,93.74 110.19,93.74 104.31,99.62 90.24,99.62 90.14,99.73 90.14,100.04 90.03,100.15 89.82,100.15 89.71,100.04 89.71,99.73 89.6,99.62 89.37,99.62 89.26,99.73 89.26,100.36 89.16,100.46 88.94,100.46 88.84,100.36 88.84,99.73 88.73,99.62 88.52,99.62 88.41,99.73 88.41,100.36 88.3,100.46 88.09,100.46 87.98,100.36 87.98,99.73 87.88,99.62 87.66,99.62 87.56,99.73 87.56,100.36 87.45,100.46 87.24,100.46 87.13,100.36 87.13,99.73 87.02,99.62 86.81,99.62 86.7,99.73 86.7,100.36 86.6,100.46 82,100.46 81.16,99.62 80.63,99.62 80.55,99.7
  BOTTOM w0.099: UC1.D23 119.73,85.78 119.61,85.91 119.61,85.91 119.43,86.08 119.43,86.08 119.43,86.38 119.53,86.48 119.53,86.97 119.57,87.01 119.57,87.01 119.63,87.07 119.63,87.52 119.08,88.07 119.08,89.19 118.09,90.17 118.09,92.69 118.7,93.3 118.7,93.44 v1(118.62,93.53)
  BOTTOM w0.112: JDIMM2.21 65.26,104.99 v1(64.37,104.1)
DDR_B_DQ4: length 83.7
  IN3 w0.102: 80.55,106.74 77.18,106.74 75.6,108.33 71.4,108.33 70.94,108.78 65.52,108.78 64.86,109.44 62.79,109.44 v1(62.35,109)
  IN3 w0.107: v1(122.65,88.01) 123.16,88.01 123.48,88.32 123.48,90.1 123.51,90.13 123.51,91.21 122.78,91.94 122.78,94.76 120.06,97.48 111.74,97.48 104.82,104.4 87.18,104.4 87.08,104.51 87.08,104.97 86.97,105.08 86.76,105.08 86.65,104.97 86.65,104.51 86.54,104.4 86.33,104.4 86.22,104.51 86.22,104.97 86.12,105.08 85.9,105.08 85.8,104.97 85.8,104.51 85.69,104.4 85.48,104.4 85.37,104.51 85.37,104.97 85.26,105.08 85.05,105.08 84.94,104.97 84.94,104.51 84.84,104.4 84.48,104.4 82.13,106.74 80.55,106.74
  BOTTOM w0.099: v1(122.65,88.01) 122.42,87.77 122.42,86.79 UC1.A20
  BOTTOM w0.102: JDIMM2.4 60.19,109.24 60.42,109.47 61.88,109.47 v1(62.35,109)
DDR_B_DQ5: length 82.2
  IN3 w0.102: 80.55,104.74 79.78,104.74 79.53,104.99 73.6,104.99 72.19,106.4 71.17,106.4 70.49,107.07 66.16,107.07 65.85,107.39 63.17,107.39 63.03,107.25 61.75,107.25 v1(61.26,107.74)
  IN3 w0.107: v1(122.65,88.64) 122.27,89.02 122.27,90.7 121.54,91.43 121.54,94.25 119.54,96.25 111.23,96.25 104.51,102.97 82.49,102.97 80.72,104.74 80.55,104.74
  BOTTOM w0.099: UC1.C20 122.23,86.18 121.93,86.48 121.93,86.73 122.17,86.97 122.17,88.17 v1(122.65,88.64)
  BOTTOM w0.112: JDIMM2.3 63.81,109.49 63.53,109.22 63.53,108.2 62.65,107.31 61.69,107.31 v1(61.26,107.74)
DDR_B_DQ6: length 84.5
  IN3 w0.102: v1(61.28,105.83) 60.59,105.83 60.49,105.72 60.49,104.96 60.63,104.82 66.92,104.82 66.93,104.82 69.42,104.82 72.41,101.84 79.14,101.84 80.53,100.45 80.93,100.45
  IN3 w0.107: v1(119.04,91.79) 119.45,92.2 119.45,93.38 118.67,94.15 110.36,94.15 104.48,100.04 96.07,100.04 95.97,100.14 95.97,100.52 95.86,100.63 95.65,100.63 95.54,100.52 95.54,100.14 95.43,100.04 95.2,100.04 95.09,100.14 95.09,100.77 94.99,100.87 94.77,100.87 94.67,100.77 94.67,100.14 94.56,100.04 94.33,100.04 94.22,100.14 94.22,100.76 94.11,100.87 93.9,100.87 93.79,100.76 93.79,100.14 93.69,100.04 93.47,100.04 93.37,100.14 93.37,100.76 93.26,100.87 93.05,100.87 92.94,100.76 92.94,100.14 92.83,100.04 92.6,100.04 92.49,100.14 92.49,100.77 92.38,100.87 92.17,100.87 92.06,100.77 92.06,100.14 91.96,100.04 91.65,100.04 91.55,100.14 91.55,100.77 91.44,100.87 91.23,100.87 91.12,100.77 91.12,100.14 91.01,100.04 90.72,100.04 89.89,100.87 81.35,100.87 80.93,100.45
  BOTTOM w0.099: v1(119.04,91.79) 119.23,91.79 119.51,91.51 119.51,90.41 119.76,90.16 119.76,88.5 120.23,88.03 120.23,88.02 120.23,88.02 UC1.A22
  BOTTOM w0.102: v1(61.28,105.83) 60.87,106.24 JDIMM2.16
DDR_B_DQ7: length 81.8
  IN3 w0.102: v1(63.13,104.06) 63.47,103.72 66.28,103.72 66.37,103.81 69.18,103.81 71.6,101.38 77.96,101.38 79.37,99.98 79.51,99.98 79.68,100.14 79.82,100.14 79.97,100 79.97,99.86 79.8,99.69 79.8,99.54 80.13,99.21
  IN3 w0.107: 80.13,99.21 81.89,99.21 82,99.32 82,99.62 82.11,99.72 82.32,99.72 82.43,99.62 82.43,99.32 82.53,99.21 82.79,99.21 82.9,99.32 82.9,99.94 83.01,100.05 83.22,100.05 83.33,99.94 83.33,99.32 83.43,99.21 83.65,99.21 83.75,99.32 83.75,99.94 83.86,100.05 84.07,100.05 84.18,99.94 84.18,99.32 84.29,99.21 84.5,99.21 84.61,99.32 84.61,99.94 84.71,100.05 84.93,100.05 85.03,99.94 85.03,99.32 85.14,99.21 85.35,99.21 85.46,99.32 85.46,99.94 85.57,100.05 85.78,100.05 85.89,99.94 85.89,99.32 85.99,99.21 104,99.21 109.89,93.33 116.14,93.33 116.24,93.22 116.24,91 116.76,90.48 117,90.48 117.1,90.59 117.1,90.82 117.21,90.93 117.42,90.93 117.53,90.82 117.53,90.59 117.64,90.48 117.85,90.48 117.96,90.59 117.96,91.33 118.06,91.44 118.28,91.44 118.38,91.33 118.38,90.59 118.49,90.48 v1(119,90.48)
  BOTTOM w0.099: UC1.C22 120.23,86.18 120.11,86.31 120.11,86.31 119.93,86.48 119.93,86.81 120.03,86.91 120.03,87.95 119.55,88.43 119.55,89.6 119.29,89.86 119.29,90.34 119.15,90.48 v1(119,90.48)
  BOTTOM w0.102: JDIMM2.17 65.7,105.99 65.11,105.41 64.35,105.41 63.13,104.19 v1(63.13,104.06)
DDR_B_DQ8: length 71.5
  IN3 w0.102: v1(61.39,103.77) 61.36,103.77 61.01,103.42 61.01,103.24 61.29,102.95 66.42,102.95 67.21,102.16 69.32,102.16 71.71,99.77 78.35,99.77 80.08,98.04 80.55,98.04
  IN3 w0.107: 80.55,98.04 103.9,98.04 109.52,92.43 114.23,92.43 v1(114.23,92.43)
  BOTTOM w0.099: v1(114.23,92.43) 114.61,92.05 115.88,92.05 117.05,90.88 117.05,89.89 118.43,88.51 118.43,86.91 118.53,86.81 118.53,86.48 118.43,86.38 118.43,86.08 118.61,85.91 118.61,85.91 118.73,85.78 UC1.D24
  BOTTOM w0.102: JDIMM2.28 60.86,103.24 v1(61.39,103.77)
DDR_B_DQ9: length 68.9
  IN3 w0.102: 80.2,97.22 79.75,97.22 78.42,98.55 71.76,98.55 68.97,101.34 66.7,101.34 65.68,102.36 64.26,102.36 64.16,102.26 64.16,102.07 64.06,101.96 63.86,101.96 63.76,102.07 63.76,102.26 63.65,102.36 63.17,102.36 63.06,102.26 63.06,101.63 v1(63.18,101.51)
  IN3 w0.107: 80.2,97.22 103.56,97.22 109.3,91.48 114.51,91.48 v1(114.58,91.55)
  BOTTOM w0.099: v1(114.58,91.55) 114.88,91.86 115.8,91.86 116.86,90.8 116.86,89.65 118.23,88.28 118.23,88.27 118.23,88.27 UC1.A25
  BOTTOM w0.102: JDIMM2.29 65.63,102.99 65.22,102.58 64.26,102.58 v1(63.18,101.51)
DDR_B_DQ10: length 68.9
  IN3 w0.102: v1(61.72,99.04) 62.54,99.86 64.21,99.86 65.14,98.93 67.31,98.93 69.12,97.12 70.86,97.12 71.36,96.62 72.34,96.62 72.97,96 76.56,96 77.03,95.53 77.66,95.53 78.3,94.89 80.39,94.89 80.39,94.89 80.55,94.89
  IN3 w0.107: 80.55,94.89 97.15,94.89 97.76,94.28 103.53,94.28 108.95,88.87 v1(115.53,88.87)
  BOTTOM w0.099: v1(115.53,88.87) 115.53,88.83 115.57,88.83 115.57,87.93 116.43,87.07 116.43,86.08 116.73,85.78 UC1.D27
  BOTTOM w0.112: v1(61.72,99.04) 61.72,98.9 62.58,98.04 64.04,98.04 65.06,99.06 65.06,99.31 65.74,99.99 JDIMM2.41
DDR_B_DQ11: length 71.2
  IN3 w0.102: 67.76,99.05 69.24,97.57 70.7,97.57 71.45,96.82 72.43,96.82 72.85,96.4 76.45,96.4 77.11,95.73 78.19,95.73 78.29,95.63 78.29,95.4 78.39,95.3 80.22,95.3 80.22,95.3 80.55,95.3
  IN3 w0.107: v1(60.39,99.11) 59.88,99.61 59.88,100.14 60.12,100.37 60.35,100.37 60.46,100.27 60.46,99.73 60.56,99.63 60.78,99.63 60.88,99.73 60.88,100.27 60.99,100.37 61.2,100.37 61.31,100.27 61.31,99.73 61.42,99.63 61.63,99.63 61.74,99.73 61.74,100.27 61.84,100.37 64.46,100.37 65.5,99.33 67.48,99.33 67.76,99.05 ; v1(114.42,89.62) 114.28,89.76 113.3,89.76 113.2,89.65 113.2,89.47 113.09,89.36 112.88,89.36 112.77,89.47 112.77,89.65 112.66,89.76 112.45,89.76 112.34,89.65 112.34,89.47 112.24,89.36 112.02,89.36 111.92,89.47 111.92,89.65 111.81,89.76 108.64,89.76 103.7,94.69 97.93,94.69 97.32,95.3 80.55,95.3
  BOTTOM w0.099: UC1.C27 116.23,86.99 114.55,88.66 114.55,89.49 v1(114.42,89.62)
  BOTTOM w0.102: v1(60.39,99.11) 60.39,99.34 59.99,99.74 JDIMM2.42
DDR_B_DQ12: length 71.3
  IN3 w0.102: 80.55,97.63 80.08,97.63 78.41,99.31 71.58,99.31 69.15,101.74 66.86,101.74 66.05,102.56 61.4,102.56 v1(60.21,103.74)
  IN3 w0.107: 80.55,97.63 103.73,97.63 109.47,91.89 114.28,91.89 114.46,92.07 115.24,92.07 v1(115.83,92.66)
  BOTTOM w0.099: v1(115.83,92.66) 117.5,90.99 117.5,90.36 118.83,89.04 118.83,87.07 118.93,86.97 118.93,86.73 118.93,86.73 118.93,86.48 118.93,86.48 118.93,86.43 119.03,86.33 119.03,86.33 119.23,86.13 UC1.C23
  BOTTOM w0.102: JDIMM2.24 59.72,104.24 v1(60.21,103.74)
DDR_B_DQ13: length 69.4
  IN3 w0.102: v1(62.62,103.74) 63.21,103.15 66.99,103.15 67.15,102.99 69.3,102.99 71.68,100.62 78.3,100.62 80.2,98.73 80.55,98.73
  IN3 w0.107: v1(114.95,92.56) 114.67,92.84 109.69,92.84 103.8,98.73 80.55,98.73
  BOTTOM w0.099: UC1.B24 118.73,86.89 118.63,86.99 118.63,88.7 117.28,90.05 117.28,90.93 115.96,92.25 115.26,92.25 v1(114.95,92.56)
  BOTTOM w0.102: JDIMM2.25 65.61,103.99 65.12,103.5 62.86,103.5 v1(62.62,103.74)
DDR_B_DQ14: length 71.2
  IN3 w0.099: v1(116.77,87.66) 116.67,87.75 109.22,87.75 109.13,87.66
  IN3 w0.102: 67.09,97.9 63.9,97.9 63.88,97.92 63.73,97.92 63.71,97.9 61.29,97.9 61.18,98 61.18,98.51 61.29,98.61 63.09,98.61 63.53,99.05 v1(63.53,99.12) ; 67.17,97.9 68.78,96.3 70.23,96.3 71.62,94.9 77.02,94.9 77.11,94.99 77.51,94.99 78.22,94.28 80.01,94.28 80.22,94.07 80.55,94.07
  IN3 w0.107: 80.55,94.07 96.8,94.07 97.42,93.46 103.19,93.46 108.99,87.66 109.13,87.66 ; 67.09,97.9 67.17,97.9
  BOTTOM w0.099: UC1.C26 117.23,86.13 117.03,86.33 117.03,86.33 116.93,86.43 116.93,86.48 116.93,86.48 116.93,86.73 116.93,86.73 116.93,86.97 116.83,87.07 116.83,87.3 116.77,87.36 v1(116.77,87.66)
  BOTTOM w0.102: v1(63.53,99.12) 63.11,99.54 61.09,99.54 59.89,100.74
  BOTTOM w0.112: JDIMM2.38 59.89,100.74
DDR_B_DQ15: length 67.9
  IN3 w0.102: v1(62.36,99.06) 62.95,99.65 63.94,99.65 65.07,98.52 67.13,98.52 68.42,97.23 68.42,97.23 68.95,96.71 70.7,96.71 71,96.41 71,96.26 70.85,96.11 70.85,95.97 70.99,95.82 71.14,95.82 71.29,95.97 71.43,95.97 71.61,95.79 76.39,95.79 76.97,95.21 77.58,95.21 78.3,94.48 80.39,94.48 80.39,94.48 80.55,94.48
  IN3 w0.107: 80.55,94.48 96.98,94.48 97.59,93.87 103.36,93.87 109.16,88.07 115.16,88.07 115.18,88.05 115.84,88.05 115.95,88.16 v1(115.95,88.46)
  BOTTOM w0.099: v1(115.95,88.46) 115.95,87.83 116.63,87.15 116.63,86.99 116.73,86.89 UC1.B27
  BOTTOM w0.112: v1(62.36,99.06) 62.87,98.55 63.66,98.55 64.61,99.5 64.61,100.13 65.47,100.99 JDIMM2.37
DDR_B_DQ16: length 72.2
  IN3 w0.102: v1(61.49,97.06) 61.49,96.62 61.39,96.52 59.97,96.52 59.87,96.41 59.87,96.07 59.97,95.97 61.46,95.97 61.64,95.79 62.33,95.79 62.43,95.89 62.43,96.54 62.54,96.64 62.74,96.64 62.84,96.54 62.84,95.89 62.94,95.79 63.91,95.79 64.3,96.18 66.47,96.18 68.3,94.35 70.53,94.35 71.74,93.14 74.41,93.14 74.48,93.06 77.8,93.06 78.5,92.35 80.22,92.35 80.22,92.35 80.55,92.35
  IN3 w0.107: v1(106.32,87.91) 105.77,87.91 105.57,88.11 105.41,88.11 104.71,88.8 104.71,88.95 104.91,89.15 104.91,89.3 104.76,89.45 104.61,89.45 104.41,89.26 104.26,89.26 104.11,89.41 104.11,89.56 104.31,89.76 104.31,89.91 104.16,90.06 104,90.06 103.81,89.86 103.66,89.86 103.49,90.02 103.49,90.18 103.69,90.37 103.69,90.52 103.54,90.68 103.39,90.68 103.19,90.48 103.04,90.48 102.89,90.63 102.89,90.78 103.08,90.98 103.08,91.13 102.93,91.28 102.78,91.28 102.58,91.08 102.43,91.08 101.78,91.74 85.36,91.74 84.75,92.35 80.55,92.35
  BOTTOM w0.099: v1(106.32,87.91) 107.45,89.03 111.91,89.03 112.76,88.19 113.77,88.19 115.33,86.63 115.33,86.21 UC1.C30
  BOTTOM w0.102: JDIMM2.50 59.78,97.74 60.05,97.47 61.09,97.47 v1(61.49,97.06)
DDR_B_DQ17: length 70.5
  IN3 w0.099: v1(108,86.25) 108.29,86.55 108.29,86.82
  IN3 w0.102: 80.55,93.58 80.22,93.58 80.22,93.57 78.29,93.57 77.92,93.94 75.59,93.94 74.91,94.62 71.41,94.62 70.22,95.81 68.58,95.81 66.69,97.7 60.95,97.7 v1(60.31,97.06)
  IN3 w0.107: 108.29,86.82 108.29,87.67 102.99,92.97 97.21,92.97 96.6,93.58 80.55,93.58
  BOTTOM w0.099: v1(108,86.25) 108,86.54 108.79,87.34 112.97,87.34 114.26,86.05 114.26,85.25 114.68,84.84 114.86,84.84 114.89,84.81 UC1.E29
  BOTTOM w0.112: JDIMM2.49 65.51,97.99 65.2,97.68 65.2,96.92 64.89,96.62 60.76,96.62 v1(60.31,97.06)
DDR_B_DQ18: length 71.6
  IN3 w0.099: v1(112.25,83.91) 112.25,83.3 112.42,83.13 113.43,83.13 113.53,83.23 113.53,83.86 113.63,83.96 113.83,83.96 113.93,83.86 113.93,83.23 114.02,83.13 114.77,83.13 114.87,83.23 114.87,84.35 114.77,84.45 109.96,84.45 109.55,84.86 106.82,84.86 106.53,85.15
  IN3 w0.102: v1(61.47,95.41) 61.47,95.15 61.73,94.89 61.99,94.89 63.13,93.75 66.45,93.75 67.58,92.62 69.96,92.62 71.59,90.99 74.54,90.99 75.43,90.1 77.94,90.1 78.5,90.66 80.55,90.66
  IN3 w0.107: 80.55,90.66 83.87,90.66 84.48,90.05 100.01,90.05 103.7,86.36 104.9,86.36 106.03,85.23 106.45,85.23 106.53,85.15 106.53,85.15
  BOTTOM w0.099: UC1.H29 114.76,82.81 114.63,82.93 114.63,82.93 114.46,83.11 114.21,83.11 114.21,83.11 114.16,83.11 114.06,83.01 113.81,83.01 113.63,83.18 113.63,83.19 113.35,83.47 112.42,83.47 112.25,83.64 v1(112.25,83.91)
  BOTTOM w0.102: JDIMM2.62 60.8,94.74 v1(61.47,95.41)
DDR_B_DQ19: length 68.2
  IN3 w0.099: v1(111.03,83.89) 111.03,83.71 110.57,83.26 107.07,83.26 106.33,84 106.24,84
  IN3 w0.102: v1(64.33,92.55) 64.4,92.63 64.85,92.63 66.1,91.38 66.24,91.38 66.57,91.7 66.71,91.7 66.86,91.56 66.86,91.42 66.53,91.09 66.53,90.95 66.69,90.79 69.93,90.79 70.6,90.12 74.24,90.12 75.37,89 78.75,89 79.18,89.43 80.55,89.43
  IN3 w0.107: 106.24,84 105.52,84 104.39,85.12 103.19,85.12 101.47,86.84 99.89,86.84 99.78,86.95 99.78,87.65 99.67,87.75 99.46,87.75 99.35,87.65 99.35,86.95 99.25,86.84 99.01,86.84 98.91,86.95 98.91,87.9 98.8,88.01 98.59,88.01 98.48,87.9 98.48,86.95 98.37,86.84 98.14,86.84 97.97,87.01 97.97,88.16 97.86,88.26 97.65,88.26 97.54,88.16 97.54,86.95 97.44,86.84 97.29,86.84 97.12,87.01 97.12,88.16 97.01,88.26 96.8,88.26 96.69,88.16 96.69,86.95 96.58,86.84 94.63,86.84 93.24,88.22 93.22,88.22 92.62,88.82 83.97,88.82 83.36,89.43 80.55,89.43
  BOTTOM w0.099: UC1.H31 114.14,82.81 114.14,82.81 113.72,82.81 113.26,83.27 111.66,83.27 v1(111.03,83.89)
  BOTTOM w0.102: v1(64.33,92.55) 64.33,93.02 65.79,94.49 JDIMM2.63
DDR_B_DQ20: length 72.5
  IN3 w0.102: v1(62.74,97.07) 62.74,96.93 63.03,96.64 63.32,96.64 63.42,96.54 63.42,96.16 63.53,96.05 63.73,96.05 63.83,96.16 63.83,96.48 63.93,96.59 66.65,96.59 68.47,94.76 68.89,94.76 69,94.87 69,94.88 69.1,94.99 69.32,94.99 69.42,94.88 69.42,94.87 69.53,94.76 70.4,94.76 71.82,93.34 72.07,93.34 72.17,93.44 72.17,93.55 72.27,93.65 72.47,93.65 72.57,93.55 72.57,93.44 72.67,93.34 72.88,93.34 72.98,93.44 72.98,93.55 73.08,93.65 73.28,93.65 73.39,93.55 73.39,93.44 73.49,93.34 73.69,93.34 73.79,93.44 73.79,93.55 73.89,93.65 74.1,93.65 74.2,93.55 74.2,93.44 74.3,93.34 74.53,93.34 74.63,93.44 74.63,93.55 74.73,93.65 74.94,93.65 75.04,93.55 75.04,93.44 75.14,93.34 77.94,93.34 78.52,92.76 80.39,92.76 80.39,92.76 80.55,92.76
  IN3 w0.107: 80.55,92.76 84.92,92.76 85.53,92.15 85.76,92.15 85.87,92.25 85.87,92.65 85.98,92.76 86.19,92.76 86.3,92.65 86.3,92.25 86.4,92.15 86.62,92.15 86.72,92.25 86.72,92.65 86.83,92.76 87.04,92.76 87.15,92.65 87.15,92.25 87.26,92.15 87.47,92.15 87.58,92.25 87.58,92.65 87.68,92.76 87.9,92.76 88,92.65 88,92.25 88.11,92.15 88.32,92.15 88.43,92.25 88.43,92.65 88.54,92.76 88.75,92.76 88.86,92.65 88.86,92.25 88.96,92.15 89.18,92.15 89.28,92.25 89.28,92.65 89.39,92.76 89.6,92.76 89.71,92.65 89.71,92.25 89.82,92.15 90.03,92.15 90.14,92.25 90.14,92.65 90.24,92.76 90.46,92.76 90.56,92.65 90.56,92.25 90.67,92.15 102.65,92.15 105.7,89.09 105.7,88.94 v1(105.47,88.71)
  BOTTOM w0.099: UC1.A28 113.89,88.45 113,88.45 111.71,89.74 106.51,89.74 v1(105.47,88.71)
  BOTTOM w0.102: v1(62.74,97.07) 61.85,97.96 60.64,97.96 59.86,98.74
  BOTTOM w0.112: JDIMM2.46 59.86,98.74
DDR_B_DQ21: length 69.5
  IN3 w0.102: 80.55,93.17 80.39,93.17 80.39,93.17 78.4,93.17 78.03,93.54 75.59,93.54 75.27,93.86 71.88,93.86 70.34,95.4 68.41,95.4 66.8,97 65.23,97 65.02,96.79 64.29,96.79 v1(64.01,97.07)
  IN3 w0.107: 80.55,93.17 91.18,93.17 91.29,93.06 91.29,92.67 91.4,92.56 91.61,92.56 91.72,92.67 91.72,93.06 91.82,93.17 92.04,93.17 92.14,93.06 92.14,92.67 92.25,92.56 92.46,92.56 92.57,92.67 92.57,93.06 92.68,93.17 92.89,93.17 93,93.06 93,92.67 93.1,92.56 93.32,92.56 93.42,92.67 93.42,93.06 93.53,93.17 93.74,93.17 93.85,93.06 93.85,92.67 93.96,92.56 94.17,92.56 94.28,92.67 94.28,93.06 94.38,93.17 94.6,93.17 94.7,93.06 94.7,92.67 94.81,92.56 95.02,92.56 95.13,92.67 95.13,93.06 95.24,93.17 95.45,93.17 95.56,93.06 95.56,92.67 95.66,92.56 95.88,92.56 95.98,92.67 95.98,93.06 96.09,93.17 96.43,93.17 97.04,92.56 102.82,92.56 106.73,88.65 106.73,88.49 106.6,88.36 106.6,88.21 106.75,88.06 106.9,88.06 107.03,88.19 107.18,88.19 107.84,87.54 107.84,87.39 107.54,87.08 v1(107.15,87.08)
  BOTTOM w0.099: UC1.D28 115.61,85.29 114.75,85.29 114.47,85.56 114.47,86.12 112.33,88.26 108.32,88.26 v1(107.15,87.08)
  BOTTOM w0.102: v1(64.01,97.07) 64.01,97.52 65.47,98.99 JDIMM2.45
DDR_B_DQ22: length 71.5
  IN3 w0.099: v1(108.55,83.85) 108.52,83.82 108.14,83.82 108.04,83.91 108.04,84.56 107.94,84.66 107.75,84.66 107.65,84.56 107.65,83.91 107.55,83.82 107.32,83.82 106.47,84.66 106.44,84.66 106.29,84.82
  IN3 w0.102: 80.55,90.25 78.61,90.25 78.15,89.8 75.14,89.8 74.41,90.53 70.89,90.53 70.73,90.69 70.73,90.83 71.02,91.13 71.02,91.27 70.88,91.41 70.73,91.41 70.44,91.12 70.3,91.12 69.82,91.6 68.7,91.6 68.59,91.71 68.59,92.1 68.49,92.21 68.27,92.21 68.17,92.11 68.17,91.71 68.06,91.6 67.68,91.6 67.09,92.2 67.09,92.34 66.08,93.34 62.33,93.34 62.22,93.44 62.22,94.19 62.12,94.29 61.79,94.29 61.69,94.19 61.69,93.23 61.59,93.13 61.03,93.13 60.86,93.29 60.86,94.77 60.7,94.93 60.5,94.93 60.4,94.83 60.4,93.89 60.3,93.78 59.97,93.78 59.87,93.89 59.87,95 v1(60.25,95.38)
  IN3 w0.107: 106.29,84.82 106.28,84.82 105.86,84.82 104.73,85.95 103.53,85.95 99.84,89.64 84.31,89.64 83.7,90.25 80.55,90.25
  BOTTOM w0.099: v1(108.55,83.85) 108.55,84.32 108.72,84.49 113.26,84.49 113.78,83.97 114.17,83.97 UC1.F31
  BOTTOM w0.102: JDIMM2.58 59.9,95.74 v1(60.25,95.38)
DDR_B_DQ23: length 68.6
  IN3 w0.099: v1(109.82,83.85) 109.82,83.68 109.6,83.45 107.4,83.45 106.45,84.41 106.24,84.41
  IN3 w0.102: v1(63.1,92.55) 63.51,92.96 65.75,92.96 67.51,91.19 69.94,91.19 70.81,90.32 74.33,90.32 75.21,89.44 78.6,89.44 79,89.85 80.43,89.85 80.43,89.84 80.6,89.84
  IN3 w0.107: 106.24,84.41 105.69,84.41 104.56,85.54 103.36,85.54 99.67,89.23 98.59,89.23 98.48,89.12 98.48,88.79 98.37,88.68 98.16,88.68 98.05,88.79 98.05,89.12 97.95,89.23 97.73,89.23 97.63,89.12 97.63,88.79 97.52,88.68 97.31,88.68 97.2,88.79 97.2,89.12 97.09,89.23 96.88,89.23 96.77,89.12 96.77,88.79 96.67,88.68 96.45,88.68 96.35,88.79 96.35,89.12 96.24,89.23 96.09,89.23 95.98,89.12 95.98,88.37 95.88,88.26 95.66,88.26 95.56,88.37 95.56,89.06 95.45,89.17 95.3,89.17 95.19,89.06 95.19,88.05 95.02,87.88 94.87,87.88 94.77,87.98 94.77,89 94.53,89.23 84.14,89.23 83.53,89.84 80.6,89.84
  BOTTOM w0.099: v1(109.82,83.85) 110.26,84.29 113.18,84.29 113.7,83.77 113.94,83.77 114.21,83.51 114.21,83.51 114.41,83.31 UC1.G30
  BOTTOM w0.102: v1(63.1,92.55) 63.1,93.48 63.79,94.17 64.42,94.17 64.84,94.59 64.84,94.78 65.54,95.49 65.74,95.49
  BOTTOM w0.112: JDIMM2.59 65.74,95.49
DDR_B_DQ24: length 65.4
  IN3 w0.099: v1(113,82.44) 113,82.42 112.46,81.88 110.56,81.88 110.4,82.04 107.56,82.04 107.46,82.14 107.46,82.56 107.36,82.66 107.16,82.66 107.06,82.56 107.06,82.14 106.96,82.04 106.68,82.04 106.24,82.48
  IN3 w0.102: 80.55,88.12 79.2,88.12 78.7,87.61 74.38,87.61 73.87,88.12 71.59,88.12 70.7,89 69.47,89 69.08,89.39 66.86,89.39 64.88,91.37 61.54,91.37 60.96,91.96 59.72,91.96 59.53,92.14 59.53,92.53 59.73,92.72 59.81,92.72 v1(60.23,93.15)
  IN3 w0.107: 80.55,88.12 82.81,88.12 83.43,87.51 90.29,87.51 92.27,85.53 100.93,85.53 102.65,83.81 103.85,83.81 104.97,82.69 105.76,82.69 105.97,82.48 106.24,82.48
  BOTTOM w0.099: v1(113,82.44) 113.03,82.44 113.03,82.47 113.09,82.41 113.28,82.41 113.69,82 114.05,82 114.06,82.01 114.16,82.11 114.21,82.11 114.21,82.11 114.46,82.11 114.46,82.11 114.51,82.11 114.81,81.81 UC1.J29
  BOTTOM w0.102: v1(60.23,93.15) 60.11,93.15 59.69,92.74 JDIMM2.70
DDR_B_DQ25: length 62.6
  IN3 w0.099: 106.24,81.2 111.22,81.2 v1(111.32,81.3)
  IN3 w0.102: 80.55,87.3 80.02,87.3 79.59,86.86 78.11,86.86 78.01,86.76 78.01,86.58 77.91,86.48 77.71,86.48 77.61,86.58 77.61,86.76 77.5,86.86 77.3,86.86 77.2,86.76 77.2,86.54 77.1,86.44 76.89,86.44 76.79,86.54 76.79,86.76 76.69,86.86 76.49,86.86 76.39,86.76 76.39,86.54 76.28,86.44 76.08,86.44 75.98,86.54 75.98,86.76 75.88,86.86 74.35,86.86 74.09,87.13 71.97,87.13 70.91,88.19 69.13,88.19 68.74,88.57 66.43,88.57 65.02,89.99 63.34,89.99 63.22,90.11 63.22,90.7 v1(63.39,90.87)
  IN3 w0.107: 80.55,87.3 81.03,87.3 81.13,87.19 81.13,86.88 81.24,86.78 81.45,86.78 81.56,86.88 81.56,87.19 81.67,87.3 82.47,87.3 83.08,86.68 86.43,86.68 87.58,85.53 88.6,85.53 89.43,84.71 100.59,84.71 102.3,82.99 103.51,82.99 104.63,81.86 105.42,81.86 106.09,81.2 106.24,81.2
  BOTTOM w0.099: UC1.J31 113.54,81.81 113.37,81.98 112,81.98 v1(111.32,81.3)
  BOTTOM w0.102: JDIMM2.71 65.31,92.49 64.55,91.73 64.24,91.73 v1(63.39,90.87)
DDR_B_DQ26: length 63.1
  IN3 w0.102: 80.55,85.09 72.68,85.09 72.66,85.12 71.76,85.12 70.3,86.58 66.19,86.58 66.09,86.68 66.09,87.57 65.99,87.67 65.78,87.67 65.68,87.57 65.68,86.68 65.58,86.58 65.32,86.58 64.98,86.91 64.98,87.06 65.26,87.34 65.26,87.48 65.12,87.63 64.98,87.63 64.7,87.34 64.55,87.34 63.98,87.92 63.98,88.13 v1(64.32,88.46)
  IN3 w0.107: v1(105.73,80.22) 104.91,81.04 100.87,81.04 98.89,83.02 85.24,83.02 85.13,83.13 85.13,83.42 85.03,83.52 84.81,83.52 84.71,83.42 84.71,83.13 84.6,83.02 84.37,83.02 84.26,83.13 84.26,83.74 84.15,83.85 83.94,83.85 83.83,83.74 83.83,83.13 83.73,83.02 83.49,83.02 81.42,85.09 80.55,85.09
  BOTTOM w0.099: v1(105.73,80.22) 106.16,79.79 112.6,79.79 112.81,80.01 114.06,80.01 114.16,80.11 114.46,80.11 114.63,79.93 114.63,79.93 114.76,79.81 UC1.L29
  BOTTOM w0.102: JDIMM2.83 65.34,89.49 v1(64.32,88.46)
DDR_B_DQ27: length 66.2
  IN3 w0.102: 80.78,83.56 79.1,83.56 78.17,84.49 72.87,84.49 72.55,84.17 71.53,84.17 69.93,85.76 64.18,85.76 64.08,85.87 64.08,86.7 63.98,86.8 63.77,86.8 63.67,86.7 63.67,85.93 63.51,85.76 63.36,85.76 63.26,85.86 63.26,86.78 63.16,86.88 62.96,86.88 62.86,86.78 62.86,85.92 62.7,85.76 62.45,85.76 60.45,87.76 v1(60.45,89.85)
  IN3 w0.107: v1(103.98,80.22) 100.53,80.22 98.55,82.2 82.76,82.2 81.4,83.56 80.78,83.56
  BOTTOM w0.099: v1(103.98,80.22) 104.6,79.59 112.68,79.59 112.9,79.81 UC1.L31
  BOTTOM w0.102: JDIMM2.84 60.26,89.24 60.45,89.43 v1(60.45,89.85)
DDR_B_DQ28: length 66.1
  IN3 w0.099: 106.24,83.04 106.42,82.86 110.26,82.86 v1(110.64,82.48)
  IN3 w0.102: 80.55,88.53 79.05,88.53 78.34,87.82 74.53,87.82 74.02,88.32 73.42,88.32 73.32,88.43 73.32,88.86 73.22,88.96 73.01,88.96 72.91,88.86 72.91,88.43 72.81,88.32 71.87,88.32 70.77,89.42 69.63,89.42 69.25,89.8 66.82,89.8 65.05,91.58 61.62,91.58 60.79,92.41 v1(60.79,92.58)
  IN3 w0.107: 106.24,83.04 106.18,83.1 105.15,83.1 104.02,84.22 102.82,84.22 101.1,85.94 92.45,85.94 92.34,86.05 92.33,86.05 92.17,86.21 92.17,86.36 92.41,86.6 92.41,86.8 92.3,86.91 92.11,86.91 91.87,86.67 91.72,86.67 91.55,86.83 91.55,86.98 91.8,87.23 91.8,87.43 91.69,87.53 91.5,87.53 91.25,87.28 91.1,87.28 90.46,87.92 83.6,87.92 82.98,88.53 80.55,88.53
  BOTTOM w0.099: v1(110.64,82.48) 110.64,82.97 110.74,83.07 113.18,83.07 113.64,82.61 114.06,82.61 114.06,82.61 114.1,82.61 114.41,82.31 UC1.H30
  BOTTOM w0.102: JDIMM2.66 60.69,93.74 60.79,93.64 v1(60.79,92.58)
DDR_B_DQ29: length 63.6
  IN3 w0.099: v1(111.83,82.48) 111.26,83.06 106.74,83.06 106.29,83.51 106.24,83.51
  IN3 w0.102: 80.55,88.94 79.18,88.94 78.32,88.08 74.81,88.08 73.73,89.16 71.64,89.16 70.97,89.83 69.8,89.83 69.42,90.21 66.98,90.21 65.12,92.07 62.39,92.07 61.98,92.48 v1(61.98,92.58)
  IN3 w0.107: 106.24,83.51 105.32,83.51 104.19,84.64 102.99,84.64 101.27,86.35 93.45,86.35 92.36,87.44 92.36,87.45 92.22,87.58 91.48,88.33 83.77,88.33 83.15,88.94 80.55,88.94
  BOTTOM w0.099: UC1.H32 113.66,82.31 113.1,82.87 111.96,82.87 111.86,82.77 111.86,82.48 v1(111.83,82.48)
  BOTTOM w0.102: v1(61.98,92.58) 61.98,92.57 61.98,91.85 62.08,91.75 63.6,91.75 63.95,92.1 64.62,92.1 65.06,92.54 65.06,92.84
  BOTTOM w0.112: JDIMM2.67 65.71,93.49 65.06,92.84
DDR_B_DQ30: length 63.4
  IN3 w0.102: v1(63.05,88.46) 63.03,88.45 62.11,88.45 62.01,88.35 62.01,87.43 62.18,87.26 64.25,87.26 65.34,86.17 69.99,86.17 71.81,84.36 72.47,84.36 72.79,84.68 80.51,84.68
  IN3 w0.107: v1(105.15,80.22) 104.74,80.63 100.7,80.63 98.72,82.61 83.32,82.61 81.25,84.68 80.51,84.68
  BOTTOM w0.099: v1(105.15,80.22) 105.87,80.95 110.52,80.95 110.97,80.5 113.6,80.5 113.71,80.61 114.02,80.61 114.06,80.61 114.22,80.45 114.59,80.45 UC1.L30
  BOTTOM w0.102: v1(63.05,88.46) 63.05,89.29 64.24,90.49 JDIMM2.79
DDR_B_DQ31: length 66.4
  IN3 w0.099: v1(106.95,80.17) 107,80.22 107.53,80.22 107.62,80.31 107.62,80.65 107.5,80.77 106.24,80.77
  IN3 w0.102: v1(61.56,89.57) 61.36,89.37 61.36,89.04 61.47,88.93 65.23,88.93 66.79,87.37 68.24,87.37 68.63,86.98 70.44,86.98 72.1,85.32 72.74,85.32 72.77,85.3 73.29,85.3 73.5,85.51 80.54,85.51
  IN3 w0.107: 80.54,85.51 81.59,85.51 82.84,84.26 84.87,84.26 85.7,83.43 85.94,83.43 86.04,83.54 86.04,84.09 86.15,84.2 86.36,84.2 86.47,84.09 86.47,83.54 86.58,83.43 86.79,83.43 86.9,83.54 86.9,84.09 87,84.2 87.22,84.2 87.32,84.09 87.32,83.54 87.43,83.43 87.64,83.43 87.75,83.54 87.75,84.09 87.86,84.2 88.07,84.2 88.18,84.09 88.18,83.54 88.28,83.43 99.06,83.43 101.04,81.45 105.25,81.45 105.94,80.77 106.24,80.77
  BOTTOM w0.099: UC1.L32 113.83,80.2 112.73,80.2 112.58,80.06 107.07,80.06 v1(106.95,80.17)
  BOTTOM w0.102: JDIMM2.80 59.73,90.24 59.79,90.29 61.31,90.29 61.56,90.05 v1(61.56,89.57)
DDR_B_DQ32: length 63.8
  IN3 w0.102: 72,60.78 78.11,60.78 78.82,60.07 ; 70.3,62.48 66.95,62.48 65.69,63.74 62.76,63.74 62.76,63.73 62.61,63.73 62.61,63.74 62.4,63.74 62.3,63.64 62.3,63.5 62.2,63.39 62,63.39 61.9,63.5 61.9,63.64 61.79,63.74 61.59,63.74 61.49,63.64 61.49,63.5 61.39,63.39 61.18,63.39 61.08,63.5 61.08,63.64 60.98,63.74 60.75,63.74 60.19,64.3 v1(60.19,64.57)
  IN3 w0.107: v1(109.4,60.05) 109.4,60.02 108.97,59.6 106.4,59.6 105.67,58.87 89.27,58.87 88.07,60.07 78.82,60.07 ; 72,60.78 71.48,61.3 71.33,61.3 70.97,60.93 70.82,60.93 70.67,61.09 70.67,61.24 71.03,61.6 71.03,61.75 70.88,61.9 70.73,61.9 70.52,61.69 70.37,61.69 70.22,61.84 70.22,61.99 70.43,62.2 70.43,62.35 70.3,62.48
  BOTTOM w0.099: UC1.AP29 114.76,60.81 114.63,60.68 114.63,60.68 114.46,60.51 114.16,60.51 114.06,60.61 113.64,60.61 113.37,60.88 111.09,60.88 110.68,60.47 109.54,60.47 109.4,60.32 v1(109.4,60.05)
  BOTTOM w0.102: v1(60.19,64.57) 59.8,64.96 59.21,64.96 58.99,64.74 JDIMM2.174
DDR_B_DQ33: length 60.7
  IN3 w0.102: v1(63.97,64.66) 64.28,64.36 65.93,64.36 66.6,63.7 70,63.7 71.41,62.29 73.38,62.29 74.04,62.95 77.41,62.95 78.3,62.05 78.3,61.81 78.82,61.3 80.55,61.3
  IN3 w0.107: v1(110.67,60.06) 111.63,61.02 112.26,61.02 112.37,61.13 112.37,61.48 112.26,61.59 111.39,61.59 110.74,60.94 106.45,60.94 106.37,60.86 105.92,60.86 105.16,60.1 91.99,60.1 90.8,61.3 80.55,61.3
  BOTTOM w0.099: UC1.AP32 113.83,60.41 113.45,60.41 113.17,60.69 111.18,60.69 110.67,60.18 v1(110.67,60.06)
  BOTTOM w0.102: v1(63.97,64.66) 63.97,64.87 64.25,65.15 65.31,65.15 65.47,64.99 JDIMM2.173
DDR_B_DQ34: length 62
  IN3 w0.102: 80.7,57.56 72.25,57.56 71.14,58.67 69.18,58.67 68.05,59.79 65.42,59.79 64.55,60.66 62.6,60.66 v1(61.64,61.62)
  IN3 w0.107: v1(110.98,58.29) 109.78,57.1 108.22,57.1 107.47,56.36 87.94,56.36 86.74,57.56 80.7,57.56
  BOTTOM w0.099: v1(110.98,58.29) 111.3,58.62 112.57,58.62 112.68,58.51 113.63,58.51 113.66,58.54 113.66,58.54 113.73,58.61 113.81,58.61 113.81,58.61 114.06,58.61 114.19,58.48 114.42,58.48 114.45,58.51 114.46,58.51 114.63,58.68 114.63,58.68 114.76,58.81 UC1.AT29
  BOTTOM w0.102: JDIMM2.187 65.66,61.49 65.32,61.15 62.11,61.15 v1(61.64,61.62)
DDR_B_DQ35: length 64.3
  IN3 w0.102: 80.55,57.15 79.91,57.15 79.73,57.33 79.46,57.33 79.46,57.32 72.2,57.32 71.27,58.25 69,58.25 67.88,59.38 65.54,59.38 64.46,60.46 58.5,60.46 58.27,60.69 58.27,61.82 58.37,61.92 60.05,61.92 v1(60.36,61.61)
  IN3 w0.107: 80.55,57.15 86.45,57.15 87.65,55.95 107.64,55.95 108.29,56.59 110.6,56.59 112.21,58.2 v1(112.21,58.24)
  BOTTOM w0.099: UC1.AU32 112.98,58.31 112.97,58.31 112.86,58.31 112.8,58.24 v1(112.21,58.24)
  BOTTOM w0.102: v1(60.36,61.61) 60.05,61.92 59.35,61.92 59.17,61.74 JDIMM2.186
DDR_B_DQ36: length 65
  IN3 w0.102: v1(61.46,64.65) 61.35,64.65 61.25,64.55 61.25,64.04 61.35,63.94 61.58,63.94 61.68,64.04 61.68,64.16 61.78,64.26 61.98,64.26 62.08,64.16 62.08,64.04 62.19,63.94 65.78,63.94 66.83,62.89 70.2,62.89 70.33,62.76 ; 78.7,60.48 78.19,60.99 77.38,60.99 77.18,61.19 76.98,61.19 76.77,60.99 76.57,60.99 76.37,61.19 76.16,61.19 75.96,60.99 75.76,60.99 75.56,61.19 75.35,61.19 75.15,60.99 74.94,60.99 74.74,61.19 74.54,61.19 74.34,60.99 74.13,60.99 73.93,61.19 73.73,61.19 73.52,60.99 73.32,60.99 73.12,61.19 72.91,61.19 72.71,60.99 72.1,60.99
  IN3 w0.107: v1(107,60.04) 106.26,60.04 105.5,59.28 91.08,59.28 90.97,59.39 90.97,59.9 90.86,60 90.65,60 90.54,59.9 90.54,59.39 90.44,59.28 90.22,59.28 90.12,59.39 90.12,59.96 90.01,60.07 89.8,60.07 89.69,59.96 89.69,59.4 89.58,59.29 89.43,59.29 88.24,60.48 78.7,60.48 ; 72.1,60.99 70.33,62.76
  BOTTOM w0.099: UC1.AN30 114.36,61.31 114.06,61.01 113.81,61.01 113.41,61.4 111.05,61.4 110.51,60.86 109.37,60.86 109.09,60.58 107.54,60.58 v1(107,60.04)
  BOTTOM w0.102: JDIMM2.170 60.37,65.74 v1(61.46,64.65)
DDR_B_DQ37: length 61.4
  IN3 w0.102: v1(62.73,64.66) 62.68,64.61 62.56,64.61 62.45,64.51 62.45,64.26 62.56,64.16 65.85,64.16 66.71,63.29 70.09,63.29 71.34,62.03 77.8,62.03 78.15,61.68 78.15,61.31 78.58,60.89 80.55,60.89
  IN3 w0.107: v1(108.23,60.04) 108.23,60.43 108.12,60.53 106.62,60.53 106.54,60.45 106.09,60.45 105.33,59.69 91.82,59.69 90.62,60.89 90.1,60.89 90,60.78 90,60.58 89.89,60.48 89.68,60.48 89.57,60.58 89.57,60.78 89.46,60.89 89.25,60.89 89.14,60.78 89.14,60.58 89.04,60.48 88.82,60.48 88.72,60.58 88.72,60.78 88.61,60.89 80.55,60.89
  BOTTOM w0.099: v1(108.23,60.04) 108.23,60.11 108.5,60.38 109.18,60.38 109.46,60.66 110.59,60.66 111.01,61.08 113.45,61.08 113.73,60.81 UC1.AP31
  BOTTOM w0.102: v1(62.73,64.66) 64.05,65.99 JDIMM2.169
DDR_B_DQ38: length 61.1
  IN3 w0.102: 80.55,58.38 80.34,58.17 79.42,58.17 79.31,58.28 79.31,58.6 79.21,58.7 79.01,58.7 78.91,58.6 78.91,58.28 78.81,58.17 78.58,58.17 78.37,58.39 78.37,58.53 78.71,58.87 78.71,59.02 78.57,59.16 78.42,59.16 78.08,58.82 77.94,58.82 77.4,59.36 77.38,59.36 77.28,59.46 77.28,59.71 77.18,59.81 76.98,59.81 76.87,59.71 76.87,59.46 76.77,59.36 71.71,59.36 71.61,59.46 71.61,59.88 71.51,59.98 71.3,59.98 71.2,59.88 71.2,59.46 71.1,59.36 70.9,59.36 70.8,59.46 70.8,59.88 70.69,59.98 70.49,59.98 70.39,59.88 70.39,59.46 70.29,59.36 69.91,59.36 68.65,60.61 65.17,60.61 64.64,61.15 64.42,61.15 64.16,61.41 v1(64.16,61.61)
  IN3 w0.107: v1(108.54,58.36) 108.11,57.92 107.87,57.92 107.13,57.18 88.28,57.18 87.08,58.38 80.55,58.38
  BOTTOM w0.099: v1(108.54,58.36) 108.54,58.65 108.9,59.02 112.83,59.02 112.91,58.93 113.49,58.93 113.57,59.01 113.81,59.01 114.06,59.01 114.06,59.01 114.11,59.01 114.21,59.11 114.21,59.11 114.34,59.24 114.66,59.24 UC1.AR30
  BOTTOM w0.102: v1(64.16,61.61) 64.71,62.16 64.72,62.16 64.96,62.4 64.96,62.41 65.03,62.49 JDIMM2.183
DDR_B_DQ39: length 64.8
  IN3 w0.102: v1(62.94,61.57) 63.64,60.87 64.63,60.87 65.3,60.2 68.48,60.2 69.52,59.16 69.63,59.16 69.64,59.15 72.19,59.15 72.3,59.05 72.3,58.83 72.4,58.73 72.6,58.73 72.7,58.83 72.7,59.05 72.8,59.15 73.09,59.15 73.19,59.05 73.19,58.69 73.3,58.59 73.5,58.59 73.6,58.69 73.6,59.05 73.7,59.15 73.91,59.15 74.01,59.05 74.01,58.69 74.11,58.59 74.31,58.59 74.41,58.69 74.41,59.05 74.52,59.15 74.79,59.15 74.89,59.05 74.89,58.67 74.99,58.57 75.19,58.57 75.29,58.67 75.29,59.05 75.4,59.15 75.6,59.15 75.7,59.05 75.7,58.67 75.8,58.57 76,58.57 76.11,58.67 76.11,59.05 76.21,59.15 76.41,59.15 76.51,59.05 76.51,58.67 76.61,58.57 76.82,58.57 76.92,58.67 76.92,59.05 77.02,59.15 77.31,59.15 78.49,57.97 80.55,57.97
  IN3 w0.107: v1(109.8,58.36) 108.95,57.51 108.04,57.51 107.3,56.77 88.11,56.77 86.91,57.97 80.55,57.97
  BOTTOM w0.099: v1(109.8,58.36) 109.8,58.58 110.03,58.82 112.75,58.82 112.83,58.73 113.58,58.73 113.65,58.81 UC1.AT31
  BOTTOM w0.102: v1(62.94,61.57) 61.77,62.74 JDIMM2.182
DDR_B_DQ40: length 59.9
  IN3 w0.102: 79.52,56.92 72.02,56.92 71.59,57.35 ; 68.63,57.35 67.5,58.49 65.86,58.49 65.09,59.25 64.24,59.25 v1(63.69,59.8)
  IN3 w0.107: 68.63,57.35 69.95,57.35 70.06,57.25 70.06,57.03 70.17,56.92 70.38,56.92 70.49,57.03 70.49,57.25 70.59,57.35 70.81,57.35 70.91,57.25 70.91,57.03 71.02,56.92 71.23,56.92 71.34,57.03 71.34,57.25 71.44,57.35 71.59,57.35 ; 79.52,56.92 80.19,56.25 85.94,56.25 87.17,55.01 107.98,55.01 108.66,55.69 109.68,55.69 109.95,55.42 v1(109.95,55.2)
  BOTTOM w0.099: UC1.AU29 114.77,57.81 114.48,57.51 114.47,57.51 114.46,57.5 114.16,57.5 114.06,57.61 113.81,57.61 113.81,57.61 113.16,57.61 112.37,56.82 111.07,56.82 109.95,55.7 v1(109.95,55.2)
  BOTTOM w0.102: v1(63.69,59.8) 64.06,60.17 64.96,60.17 65.64,59.49 JDIMM2.195
DDR_B_DQ41: length 62.4
  IN3 w0.102: 71.46,57.77 72.11,57.12 79.49,57.12 79.49,57.12 79.64,57.12 80.11,56.66 80.26,56.66 ; 68.8,57.77 67.67,58.9 65.74,58.9 64.38,60.26 61.77,60.26 v1(61.26,59.75)
  IN3 w0.107: 80.26,56.66 86.11,56.66 87.31,55.46 107.85,55.46 108.49,56.1 110.8,56.1 111.17,56.47 111.32,56.47 111.45,56.34 111.45,55.45 111.16,55.16 v1(111.12,55.16) ; 68.8,57.77 71.46,57.77
  BOTTOM w0.099: v1(111.12,55.16) 111.12,55.62 112.12,56.62 113.44,56.62 113.83,57.01 114.1,57.01 114.21,57.11 114.21,57.11 114.41,57.31 UC1.AV30
  BOTTOM w0.102: JDIMM2.194 59.3,59.74 59.76,59.28 60.79,59.28 v1(61.26,59.75)
DDR_B_DQ42: length 59.4
  IN3 w0.102: v1(64.63,56.1) 64.59,56.1 64.49,56 64.49,54.53 64.59,54.43 65.47,54.43 65.57,54.53 65.57,55.07 65.67,55.17 65.87,55.17 65.97,55.07 65.97,54.53 66.08,54.43 66.87,54.43 67.21,54.09 71.08,54.09 71.5,54.5 76.14,54.5 76.24,54.4 76.24,54.19 76.34,54.08 76.55,54.08 76.65,54.19 76.65,54.4 76.75,54.5 76.95,54.5 77.05,54.4 77.05,54.19 77.16,54.08 77.36,54.08 77.46,54.19 77.46,54.4 77.56,54.5 78.44,54.5 79.61,53.33 80.26,53.33
  IN3 w0.107: 80.26,53.33 84.73,53.33 85.96,52.1 111.84,52.1 112.48,52.73 112.92,52.73 113.38,53.2 v1(113.38,53.21)
  BOTTOM w0.099: v1(113.38,53.21) 113.73,53.21 114.45,53.93 114.45,54.25 114.83,54.64 UC1.BB30
  BOTTOM w0.102: JDIMM2.207 65.33,56.49 65.27,56.55 64.91,56.55 64.63,56.27 v1(64.63,56.1)
DDR_B_DQ43: length 62.6
  IN3 w0.099: v1(115.66,53.36) 115.66,53 115.35,52.7
  IN3 w0.102: v1(59.77,56.09) 61.31,54.55 61.53,54.55 62.06,54.02 64.94,54.02 65.91,53.06 79.12,53.06 79.67,52.51 80.55,52.51
  IN3 w0.107: 115.35,52.7 113.93,51.27 85.62,51.27 84.39,52.51 80.55,52.51
  BOTTOM w0.099: UC1.BA28 115.73,54.64 115.44,54.34 115.44,54.14 115.43,54.13 115.43,53.88 115.44,53.87 115.44,53.58 v1(115.66,53.36)
  BOTTOM w0.112: v1(59.77,56.09) 59.38,56.09 59.23,56.24 JDIMM2.208
DDR_B_DQ44: length 60.6
  IN3 w0.102: v1(62.45,59.74) 63.13,59.05 65.01,59.05 65.99,58.07 67.23,58.07 68.36,56.94 69.72,56.94 69.95,56.71 79.37,56.71 80.25,55.84
  IN3 w0.107: 80.25,55.84 85.77,55.84 87,54.6 107.7,54.6 v1(107.7,54.61)
  BOTTOM w0.099: UC1.AU30 114.65,58.22 114.3,58.22 114.09,58.01 114.07,58.01 114.06,58.01 113.81,58.01 113.7,58.11 112.94,58.11 112.07,57.23 109.94,57.23 v3(108.24,55.53) 107.7,54.99 v1(107.7,54.61)
  BOTTOM w0.102: JDIMM2.191 65.22,60.49 65.13,60.57 63.29,60.57 v1(62.45,59.74)
DDR_B_DQ45: length 63.7
  IN3 w0.102: 64.95,58.82 59.11,58.82 59.01,58.92 59.01,59.63 59.17,59.79 v1(60.01,59.79) ; 66.86,57.86 68.19,56.53 69.72,56.53 69.74,56.51 78.46,56.51 79.54,55.43
  IN3 w0.107: 64.95,58.82 65.91,57.86 66.86,57.86 ; 79.54,55.43 85.6,55.43 86.83,54.19 108.46,54.19 108.78,54.52 108.78,55.2 v1(108.77,55.21)
  BOTTOM w0.099: UC1.AU31 113.02,57.81 112.23,57.02 110,57.02 108.76,55.78 108.76,55.22 v1(108.77,55.21)
  BOTTOM w0.102: JDIMM2.190 59.5,60.74 60.01,60.23 v1(60.01,59.79)
DDR_B_DQ46: length 60.8
  IN3 w0.102: 70.94,54.71 78.53,54.71 79.49,53.74 ; 70.73,54.5 67.94,54.5 66.31,56.12 65.75,56.12 65.38,56.5 63.26,56.5 v1(62.86,56.1)
  IN3 w0.107: 79.49,53.74 84.9,53.74 86.13,52.51 111.67,52.51 112.22,53.05 v1(112.22,53.14) ; 70.73,54.5 70.94,54.71
  BOTTOM w0.099: UC1.AY32 113.93,55.42 114.3,55.05 114.3,54.39 114.25,54.34 114.25,54.01 113.83,53.59 112.31,53.59 112.22,53.49 v1(112.22,53.14)
  BOTTOM w0.102: v1(62.86,56.1) 62.86,56.72 63.55,57.41 65.52,57.41 65.59,57.49 JDIMM2.203
DDR_B_DQ47: length 62.8
  IN3 w0.102: v1(61.53,56.1) 63.41,54.22 65.03,54.22 65.57,53.68 71.22,53.68 71.84,54.3 75.43,54.3 75.84,53.88 78.61,53.88 79.57,52.92 80.87,52.92
  IN3 w0.107: v1(114.55,52.93) 114.52,52.93 113.81,52.22 112.55,52.22 112.01,51.68 85.79,51.68 84.56,52.92 80.87,52.92
  BOTTOM w0.099: v1(114.55,52.93) 114.55,52.96 115.2,53.62 115.2,55.22 115.13,55.3 UC1.AY29
  BOTTOM w0.102: v1(61.53,56.1) 60.4,57.24 JDIMM2.204
DDR_B_DQ48: length 70.8
  IN3 w0.102: v1(60.33,53.88) 60.71,53.5 62,53.5 62.96,52.55 64.05,52.55 65.25,51.35 65.78,51.35 65.88,51.25 65.88,50.93 65.98,50.83 66.19,50.83 66.29,50.93 66.29,51.25 66.39,51.35 66.65,51.35 66.76,51.25 66.76,50.93 66.86,50.83 67.06,50.83 67.16,50.93 67.16,51.25 67.26,51.35 68.82,51.35 68.92,51.25 68.92,50.96 69.02,50.86 69.22,50.86 69.32,50.96 69.32,51.23 69.45,51.35 69.65,51.35 69.76,51.25 69.76,50.85 69.86,50.74 70.06,50.74 70.16,50.85 70.16,51.25 70.26,51.35 70.47,51.35 70.57,51.25 70.57,50.85 70.67,50.74 70.87,50.74 70.98,50.85 70.98,51.25 71.08,51.35 71.6,51.35 72.09,50.86 74.04,50.86 74.14,50.96 74.14,51.39 74.24,51.49 74.44,51.49 74.54,51.39 74.54,50.96 74.65,50.86 79.52,50.86 79.6,50.79
  IN3 w0.107: 79.6,50.79 83.67,50.79 85.53,48.92 106.48,48.92 107.74,50.19 v1(107.98,50.19)
  BOTTOM w0.099: v1(107.98,50.19) 107.98,51.26 108.68,51.96 116.04,51.96 116.43,52.36 116.43,54.53 116.61,54.71 116.61,54.71 116.73,54.83 UC1.BA27
  BOTTOM w0.102: JDIMM2.216 59.23,54.24 59.35,54.36 59.85,54.36 v1(60.33,53.88)
DDR_B_DQ49: length 67.8
  IN3 w0.102: 80.55,52.02 79.87,52.02 79.31,52.57 65.14,52.57 v1(64.28,53.44)
  IN3 w0.107: 80.55,52.02 84.19,52.02 85.42,50.79 86.21,50.79 86.31,50.68 86.31,50.26 86.42,50.16 86.63,50.16 86.74,50.26 86.74,50.68 86.85,50.79 87.06,50.79 87.17,50.68 87.17,50.26 87.27,50.16 87.49,50.16 87.59,50.26 87.59,50.68 87.7,50.79 87.91,50.79 88.02,50.68 88.02,50.26 88.13,50.16 88.34,50.16 88.45,50.26 88.45,50.68 88.55,50.79 88.77,50.79 88.87,50.68 88.87,50.26 88.98,50.16 89.19,50.16 89.3,50.26 89.3,50.68 89.41,50.79 89.62,50.79 89.73,50.68 89.73,50.26 89.83,50.16 90.05,50.16 90.16,50.26 90.16,50.68 90.26,50.79 90.48,50.79 90.58,50.68 90.58,50.26 90.69,50.16 90.9,50.16 91.01,50.26 91.01,50.68 91.12,50.79 91.33,50.79 91.44,50.68 91.44,50.26 91.54,50.16 91.76,50.16 91.86,50.26 91.86,50.68 91.97,50.79 92.18,50.79 92.29,50.68 92.29,50.26 92.4,50.16 92.61,50.16 92.72,50.26 92.72,50.68 92.82,50.79 108.71,50.79 v1(108.72,50.78)
  BOTTOM w0.099: UC1.BC27 116.73,54.26 116.66,54.19 116.66,52.3 116.12,51.77 108.82,51.77 108.72,51.67 v1(108.72,50.78)
  BOTTOM w0.102: v1(64.28,53.44) 64.28,54.11 64.65,54.49 JDIMM2.215
