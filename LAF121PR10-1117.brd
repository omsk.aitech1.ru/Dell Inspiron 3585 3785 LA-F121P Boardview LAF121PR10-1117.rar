# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WL_OFF#_R: length 36.7
  TOP w0.089: v1(81.41,116) 81.43,116.02 81.43,116.75 80.56,117.61 RW8.2 80.76,118.55 82.9,118.55 83.09,118.74 QW1.1 83.66,118.35 v3(84.18,117.83)
  IN2 w0.089: v1(74.97,115.54) 74.97,115.4 75.22,115.15 76.43,115.15 77.74,113.83 79.18,113.83 81.35,116 v1(81.41,116)
  BOTTOM w0.089: JWLAN1.56 72.15,134.4 72.82,133.74 72.82,132.3 73.39,131.73 73.39,126.86 73.83,126.43 73.83,121.02 74.59,120.25 74.59,119.55 73.94,118.9 73.94,116.27 74.67,115.54 v1(74.97,115.54)
WLAN_EN: length 79.5
  TOP w0.089: UE1.73 46.55,82.4 46.61,82.34 v1(46.61,82.2)
  TOP w0.254: UW1.4 67.77,139.69 RW14.2 67.06,138.98 67.06,137.52 v1(67.17,137.41)
  IN2 w0.089: v1(64.79,117.08) 64.79,117.04 64.14,116.39 58.49,116.39 57.38,115.28 50.21,115.28 49,114.08 48.72,114.08 46.25,111.6 46.25,105.11 46.65,104.71 46.65,94.67 45.76,93.79 45.76,86.44 46.51,85.69 46.51,82.31 v1(46.61,82.2)
  BOTTOM w0.089: v1(64.79,117.08) 64.79,117.13 64.75,117.17 64.75,118.51 66.18,119.94 66.18,122.68 65.59,123.26 65.59,125.16 67.56,127.13 67.56,127.92 67.3,128.19 67.3,129.48 68.95,131.13 68.95,132.22 67.44,133.73 67.44,136.9 67.17,137.17 v1(67.17,137.41)
WLAN_WAKE#: length 83.9
  TOP w0.089: v1(40.15,84.67) 40.15,84.65 ; 40.15,84.65 39.75,84.25 UE1.90 ; 40.15,84.65 39.79,85.02 RE19.2 ; v1(77.33,134.65) 77.43,134.65 77.66,134.42 79.05,134.42 RW15.2
  IN2 w0.089: v1(40.15,84.67) 40.15,84.65 40.72,85.23 41.51,85.23 42.64,86.35 42.64,88.57 43.39,89.32 43.39,110.69 43.84,111.14 43.84,112.14 47.06,115.37 48.48,115.37 49.87,116.76 54.49,116.76 55.13,117.39 56.82,117.39 57.03,117.19 57.32,117.19 57.63,117.5 57.63,118.12 v1(57.06,118.69)
  IN3 w0.089: v1(57.06,118.69) 59.44,121.08 62.14,121.08 62.86,121.8 62.86,125.15 64.02,126.31 64.55,126.31 65.64,127.4 65.64,127.93 66.38,128.67 66.38,130.69 66.9,131.21 68.66,131.21 69.51,132.06 71.12,132.06 71.96,132.9 75.27,132.9 77.03,134.65 v1(77.33,134.65)
  BOTTOM w0.112: v1(77.33,134.65) 77.43,134.65 77.93,134.15 JWLAN1.55
WOL_EN: length 18.1
  TOP w0.089: v1(30.39,88.87) 29.76,89.5 UL2.4 29.23,89.91 28.91,90.23 RL16.1 RL2.2 RL17.1 ; v3(31.72,82.34) 31.92,82.14 33.92,82.14 34.42,81.64 v1(34.42,81.41) UE1.98
  BOTTOM w0.089: v1(30.39,88.87) 31.38,87.88 31.52,87.88 34.69,84.71 34.69,83.83 34.42,83.55 v1(34.42,81.41)
XTALIN: length 6.2
  BOTTOM w0.102: UV1.AM28 112.62,142.92 112.45,142.92
  BOTTOM w0.112: YV1.1 109.48,145.16 CV17.1 109.7,144.94 RV24.1 110.08,143.65 111.31,143.65 112.04,142.92 112.45,142.92
XTALOUT: length 9.4
  BOTTOM w0.102: UV1.AK28 113.54,142.6 113.1,142.15 112.45,142.15
  BOTTOM w0.112: RV24.2 110.93,143.11 111.89,142.15 112.45,142.15 ; RV24.2 109.68,143.09 CV18.1 ; RV24.2 109.7,143.18 108.88,144 107.69,144 YV1.3
XTLI: length 8
  TOP w0.089: UL1.28 21.08,83.13 20.76,83.45 20.02,83.45 19.91,83.56 19.43,83.56 v3(18.79,84.2) 18.39,84.2 CL11.1 17.6,84.83 17.15,84.39 15.73,84.39 YL1.1
XTLO: length 5.7
  TOP w0.089: YL1.3 16.98,83.84 CL12.1 18.89,83.84 19.47,83.26 v3(19.78,83.26) 20.59,83.26 21.12,82.73 UL1.29
N16741477: length 1.3
  TOP w0.102: v1(119,126.39) 118.56,125.94 T49.1
  BOTTOM w0.102: v1(119,126.39) 119.33,126.39 UV1.AB8
N16741489: length 1.4
  TOP w0.102: v1(118.14,125.4) 118.14,124.74 T56.1
  BOTTOM w0.102: UV1.AD7 v1(118.14,125.4)
N16741505: length 4.4
  BOTTOM w0.102: T60.1 117.12,120.61 117.12,120.62 118.84,122.35 118.84,123 119.34,123.49 UV1.AB4
N16741517: length 1.4
  TOP w0.102: v1(117.37,127.81) 117.01,128.17 117.01,128.18 T55.1
  BOTTOM w0.102: UV1.AD9 117.37,127.77 v1(117.37,127.81)
N16741525: length 2.1
  TOP w0.102: T62.1 121.89,125.33 121.89,125.62 121.67,125.85 121.61,125.85 v1(121.34,126.11)
  BOTTOM w0.102: v1(121.34,126.11) 120.86,126.6 UV1.Y8
N16741803: length 2
  TOP w0.102: v1(118.23,138.19) v3(118.23,137.62)
  TOP w0.508: RV29.2 118.12,138.29 v1(118.23,138.19)
  BOTTOM w0.254: UV1.AC22 118.23,137.91 v1(118.23,138.19)
N16741825: length 1.5
  TOP w0.508: RV59.2 119.18,138.56 v1(119,138.38)
  BOTTOM w0.305: UV1.AB22 119,138.13 v1(119,138.38)
N16751828: length 1.2
  TOP w0.102: v1(118.12,127.01) 118.55,127.44 T48.1
  BOTTOM w0.102: UV1.AC8 v1(118.12,127.01)
N16751830: length 1.1
  TOP w0.102: T54.1 116.94,125.85 v1(117.29,126.2)
  BOTTOM w0.102: UV1.AE8 116.94,126.55 v1(117.29,126.2)
N16751834: length 1.2
  TOP w0.102: v1(116.54,127.02) 116.98,127.02 T52.1
  BOTTOM w0.102: v1(116.54,127.02) 116.93,127.4 UV1.AE9
N16751836: length 1.4
  TOP w0.102: T50.1 125.7,127.63 v1(126.19,127.63)
  BOTTOM w0.102: v1(126.19,127.63) 126.51,127.63 UV1.N9
N16751838: length 3.4
  BOTTOM w0.102: T61.1 117.92,120.74 117.92,121.14 119.05,122.27 119.05,122.71 119.12,122.78 UV1.AB2
N16751842: length 1.5
  TOP w0.102: v1(119,127.18) 119.6,126.58 T58.1
  BOTTOM w0.102: UV1.AB9 119.22,127.4 v1(119,127.18)
N16751844: length 1.4
  TOP w0.102: v1(118.99,127.9) 119.01,127.87 T47.1
  BOTTOM w0.102: v1(118.99,127.9) 118.84,127.9 UV1.AC10
N16751848: length 1.3
  TOP w0.102: T51.1 126.97,127.29 127.07,127.19 v1(127.35,127.19)
  BOTTOM w0.102: UV1.L9 127.78,127.24 127.39,127.24 v1(127.35,127.19)
N16751852: length 1.4
  TOP w0.102: v1(120.07,125.51) 119.9,125.51 T59.1
  BOTTOM w0.102: v1(120.07,125.51) 119.83,125.51 UV1.AB7
N16751854: length 3.1
  TOP w0.102: v1(118.88,125.39) 118.61,125.12 118.61,125.06 118.59,125.04 118.59,123.21 T57.1
  BOTTOM w0.102: v1(118.88,125.39) 118.54,125.73 UV1.AC7
N16751856: length 1.4
  TOP w0.102: v1(121.34,128.18) 121.12,127.96 T53.1
  BOTTOM w0.102: v1(121.34,128.18) 121.34,128.18 UV1.Y11
N16751858: length 1.9
  TOP w0.102: T63.1 120.79,125.17 120.53,124.91 v1(120.53,124.64)
  BOTTOM w0.102: UV1.Y7 120.74,125.54 120.53,125.33 v1(120.53,124.64)
N16808781: length 3.7
  BOTTOM w0.102: RV157.1 111.13,128.33 111.34,128.54 113.51,128.54 113.96,129 UV1.AJ11
N16808782: length 4.4
  BOTTOM w0.089: RV155.1 110.21,130.62 v3(110.21,131.06)
  BOTTOM w0.102: UV1.AK12 113.36,130.18 111.21,130.18 111.13,130.1 RV155.1
N16808783: length 2.8
  BOTTOM w0.102: UV1.AL11 113.11,129.23 RV156.1
N16813004: length 2.7
  BOTTOM w0.089: RV84.2 108.15,127.13 RV87.2 107.36,128.01 RV71.2 107.31,128.06 107.31,128.9 v3(107.26,128.95)
N17072999: length 3.1
  TOP w0.089: v3(44.8,98.67) 44.18,98.05 C28.1 43.73,97.87 U4.12
N17205184: length 6.8
  TOP w0.089: RS9.2 179.45,29.1 180.39,29.1 v3(180.95,29.65) 181.73,30.44 183.57,30.44 184.13,30.99 US1.7
N17205187: length 2.8
  TOP w0.089: RS12.2 RS13.2 184.4,37.26 184.95,36.71 184.95,36.33 184.63,36.01 US1.18
N17205206: length 7
  TOP w0.089: US1.10 185.63,31.18 186.25,30.56 v3(186.66,30.56) 187.4,30.56 187.8,30.96 189.42,30.96 189.55,31.1 189.94,31.1 190.07,30.96 190.88,30.96 RS5.2
N17213597: length 2.8
  TOP w0.254: v1(36.09,127.14) 36.42,126.81 CT8.1
  BOTTOM w0.254: v1(36.09,127.14) 35.39,127.14 35.14,126.89 UT1.33
N17389450: length 6.7
  BOTTOM w0.089: v3(29.55,91.65) 28.86,90.97 PD501.2
  BOTTOM w0.254: PR503.2 27.34,92.2 PC516.1 PR508.1 27.49,90.41 PR506.2 PR502.2 28.05,89.6 PD501.2
N17847259: length 3
  BOTTOM w0.102: UV1.AL9 112.85,127.4 111.51,126.06 T68.1
N17877344: length 2.5
  BOTTOM w0.102: UV1.R1 124.94,122.29 124.94,121.61 T66.1
N17877347: length 4.6
  BOTTOM w0.102: T67.1 122.93,120.55 124.45,122.07 124.45,122.57 124.88,122.99 124.88,123.33 UV1.R3
N19609367: length 3.3
  TOP w0.089: v4(22.26,113.6) 22.82,113.04 RI15.1 23.96,113.6 QI2.2
N20141258: length 2.8
  TOP w0.203: PUZ01.1 156.37,90.3 v3(157.01,90.94) PRZ13.2
N20141272: length 30.2
  TOP w0.254: v1(149.72,91.85) 149.81,91.76 PRZ25.2 149.81,90.83 PRZ26.1
  IN1 w0.254: v1(149.72,91.85) 149.72,91.65 150.88,90.48 155.33,90.48 157.06,88.76 157.06,84.91 161.55,80.41 v1(161.55,72.21)
  BOTTOM w0.254: PHZ01.2 160.68,72.27 160.74,72.21 v1(161.55,72.21)
N20141325: length 1.8
  BOTTOM w0.089: v3(160.24,90.38) PRZ07.1
  BOTTOM w0.254: PCZ03.2 161.17,91.09 PRZ07.1
N20141337: length 7.3
  TOP w0.203: PCZ04.1 159.37,88.3 v1(158.56,88.3) 158.56,88.28 v3(158.2,87.93) PUZ01.37
  BOTTOM w0.254: v1(158.56,88.3) 159.1,88.84 PRZ04.1 159.86,89.46 PRZ07.2 ; PRZ07.2 161.95,89.46 PRZ03.2 ; PRZ07.2 161.12,89.41 PRZ01.2
N20141361: length 11.6
  TOP w0.089: v1(162.23,92.2) v3(162.59,91.84)
  TOP w0.203: v1(158.02,88.6) 157.75,88.33 PUZ01.38
  IN1 w0.254: v1(158.02,88.6) 158.77,89.35 160.45,89.35 162.23,91.13 v1(162.23,92.2)
  BOTTOM w0.254: v1(162.23,92.2) 162.23,91.87 161.97,91.62 PCZ03.1 161.97,90.4 PRZ03.1 162.83,90.38 PCZ05.2 162.86,90.43 PRZ06.2
N20141372: length 11.4
  TOP w0.203: PUZ01.15 151.51,87.53
  TOP w0.254: v1(148.05,91.26) 147.97,91.26 147.14,90.43 v3(147.14,89.34) 147.34,89.14 147.34,87.46 147.6,87.21 148.16,87.21 148.76,86.61 149.13,86.61 149.43,86.91 149.64,86.91 150.26,87.53 151.51,87.53
  BOTTOM w0.254: PRZ36.2 147.74,89.78 PCZ47.2 148.05,90.93 v1(148.05,91.26)
N20141380: length 2.8
  TOP w0.089: v3(161.28,88.2) 160.65,88.2 159.77,89.07 PCZ09.1
  TOP w0.254: PRZ11.2 159.77,89.93 PCZ09.1
N20141402: length 1.8
  BOTTOM w0.089: PCZ47.1 v3(145.93,90.62)
  BOTTOM w0.254: PCZ47.1 146.82,89.77 PRZ39.2
N20141406: length 6.9
  TOP w0.089: PCZ22.1 153.36,80.62 v3(154.54,79.43)
  TOP w0.203: PUZ01.25 154.37,84.11 154.49,83.99 154.49,82.57 154.01,82.09 PRZ17.1
  TOP w0.254: PCZ22.1 153.83,81.39 PRZ17.1
N20141448: length 7
  TOP w0.089: v3(162.26,87.36) 161.23,87.36 159.95,88.64 159.34,88.64 158.86,89.12 PCZ09.2
  TOP w0.203: PCZ09.2 157.96,89.15 157.54,88.73 PUZ01.39
  TOP w0.254: PRZ10.2 158.86,89.94 PCZ09.2
N20141457: length 10.2
  TOP w0.254: PRA03.2 v1(159.95,93.68)
  BOTTOM w0.254: PLA01.2 154.6,97.73 154.34,97.47 154.34,95.63 154.91,95.05 156.38,95.05 157.84,93.59 v3(159.06,93.59) 159.86,93.59 v1(159.95,93.68)
N20141459: length 11
  TOP w0.254: v1(157.91,93.04) PRA04.2
  BOTTOM w0.254: v1(157.91,93.04) 156.33,94.61 154.66,94.61 153.77,95.5 153.77,97.4 153.45,97.73 PLA01.3
N20141467: length 33.4
  TOP w0.254: v1(147.53,80.98) 147.49,80.94 147.49,79.59 147.93,79.15 149.3,79.15 150.54,77.92 150.54,75.62 150.39,75.47 150.39,74.31 150.23,74.16 150.23,73.14 149.73,72.64 149.73,71.48 149.57,71.32 149.57,65.2 v3(150.02,64.75) 150.7,64.07 151.43,64.07 152.3,63.21 152.3,62.65 152.8,62.14 152.8,60.54 153.85,59.49 156.1,59.49 156.55,59.95 156.55,60.99 v1(156.83,61.26)
  BOTTOM w0.254: v1(147.53,80.98) 147.68,80.84 PRZ46.2 ; PLZ03.3 156.51,60.94 v1(156.83,61.26)
N20141469: length 30.2
  TOP w0.254: v1(150.26,79) 150.88,78.37 150.88,75.39 150.74,75.24 150.74,74.17 150.58,74.01 150.58,73 150.11,72.53 v3(150.11,71.99) 150.11,71.37 149.92,71.17 149.92,65.39 150.89,64.42 151.58,64.42 152.64,63.35 152.64,62.79 153.15,62.28 153.15,60.68 154,59.84 155.95,59.84 156.21,60.09 156.21,61.28 156.76,61.84 v1(156.79,61.84)
  BOTTOM w0.254: PLZ03.2 156.51,62.12 v1(156.79,61.84) ; v1(150.26,79) 150.26,79.04 150.25,79.04 PRZ42.1 149.24,79.95 PRZ45.2
N20141477: length 1.2
  TOP w0.089: PCA08.1 v3(155.94,102.92)
N20141501: length 2.5
  TOP w0.203: PRZ26.2 151.14,90.41 152.08,89.46 PUZ01.11
N20141511: length 9.7
  TOP w0.203: PUZ01.16 150.34,87.13 v1(149.63,86.42)
  TOP w0.254: v1(146.41,85.35) 146.84,84.92 146.97,84.92 PCZ29.1 PRZ31.1 PCZ31.1 PRZ38.1
  IN3 w0.254: v1(146.41,85.35) 146.74,85.35 147.81,86.42 v1(149.63,86.42)
N20141517: length 4.9
  TOP w0.203: v1(150.28,86.42) 150.28,86.43 150.48,86.63 151.28,86.63 151.38,86.73 PUZ01.17
  BOTTOM w0.254: v1(150.28,86.42) 150.34,86.48 v3(150.34,87.26) 150.34,87.68 ; 150.34,87.68 150.28,87.74 PRZ40.1 ; 150.34,87.68 151.33,87.68 PCZ49.1
N20141713: length 5.3
  TOP w0.089: PCZ04.2 160.36,87.31 v3(160.51,87.16)
  TOP w0.203: PUZ01.36 158.6,87.53 v1(158.63,87.56) 159.19,87.56 PCZ04.2
  BOTTOM w0.254: PRZ05.1 158.23,87.97 v1(158.63,87.56) 159.06,87.99 PCZ02.2
N20141719: length 1.5
  TOP w0.089: PRZ44.2 v3(158.14,59.6)
N20141862: length 3.2
  BOTTOM w0.089: PCZ02.1 161.32,86.84 v3(162.07,86.84)
  BOTTOM w0.254: PCZ02.1 160.16,88 PRZ04.2
N20141864: length 1.8
  BOTTOM w0.089: PCZ01.2 161.23,87.82 v3(161.11,87.7)
  BOTTOM w0.254: PRZ01.1 162.02,88.67 PCZ01.2
N20141906: length 8.3
  TOP w0.089: v3(146.02,88.68) 146.33,88.68 147.08,87.93 147.08,87.35 147.8,86.62 PRZ29.2
  TOP w0.203: PUZ01.18 150.91,86.33 150.39,85.81 PCZ30.1 PRZ35.1 PRZ34.1 PRZ31.2 PRZ29.2
N20141912: length 1.9
  TOP w0.089: PRZ29.1 146.69,86.88 v3(146.69,87.57)
  TOP w0.254: PRZ29.1 147,86.57 PCZ29.2
N20141916: length 2.9
  TOP w0.254: PRZ35.2 v1(149.49,84.26)
  BOTTOM w0.254: v1(149.49,84.26) 149.49,84.49 v3(149.78,84.78) 150.72,85.72 PCZ42.1
N20141920: length 5.9
  TOP w0.203: PUZ01.19 151.36,85.93 150.35,84.92 PCZ30.2 150.4,84.84 v1(150.4,84.26) 150.36,84.26 v3(149.8,83.69) 149.25,83.14 PCZ33.2
  BOTTOM w0.203: PRZ30.1 150.67,84.84 150.4,84.58 v1(150.4,84.26)
N20141926: length 3.1
  TOP w0.089: PCZ33.1 148.78,84.01 148.32,83.55 148.32,82.44 v3(148.03,82.15)
  TOP w0.254: PRZ34.2 148.67,84.16 PCZ33.1
N20142021: length 3.9
  BOTTOM w0.089: PRZ08.2 159.46,92.06 v3(159.62,91.91)
  BOTTOM w0.254: PRZ08.2 157.79,92.06 PHA01.1
N20142108: length 33.2
  IN1 w0.089: v1(152.01,61.15) 152.2,61.34 152.2,62.43 151.59,63.04 151.59,68.5 152.39,69.31 152.39,75.92 149.27,79.04 149.27,80.2 148.05,81.42 148.05,85.21 v1(146.28,86.98)
  BOTTOM w0.089: v1(146.28,86.98) 146.28,86.79 146.73,86.34 v3(147.25,86.34)
  BOTTOM w0.254: v1(152.01,61.15) 151.64,61.52 151.64,62.13 152.28,62.77 PHZ02.1 ; v1(146.28,86.98) 146.28,87.02 146.54,87.27 PRZ32.2
N20142189: length 5.9
  TOP w0.254: v1(157.44,91.28) 157.44,91.64 157.6,91.8 157.6,92.65 PRZ13.1 157.01,93.92 v3(157.63,94.55) v1(158.4,94.55)
  BOTTOM w0.254: v1(158.4,94.55) PHA02.2 ; PRZ12.2 v1(157.44,91.28)
N21022260: length 1.1
  BOTTOM w0.089: PRA01.2 v3(161.96,85.23)
N21022300: length 0.6
  TOP w0.089: 151.34,81.03 v3(151.34,80.44)
N21379353: length 1
  TOP w0.089: PC508.1 v3(24.75,96.69)
  vias: v1(23.08,96.83)
N21513882: length 2
  TOP w0.254: PD10.3 91.12,150.31 PR14.2 90.95,150.49 PR16.1
N21533617: length 8.2
  TOP w0.254: PUS03.4 55.07,124.74 55.18,124.63 v1(55.51,124.63) ; PQS05.5 v1(59.44,129.03)
  BOTTOM w0.254: v1(59.44,129.03) 59.44,128.43 55.65,124.63 v1(55.51,124.63)
N21533620: length 2.6
  TOP w0.254: PRS10.2 PRS15.1 65.67,128.57 PQS06.2
N21537645: length 1.3
  BOTTOM w0.254: PQ17.1 90.56,148.12 PR48.2
N21556764: length 1.9
  TOP w0.254: PRS29.1 64.09,124.26 PCS19.2 64.02,124.21 PQS10.5
N21558641: length 5.3
  TOP w0.089: PCS20.2 64.77,117.85 65.2,117.42 v3(65.2,116.78)
  TOP w0.254: PRS30.1 64.18,117.79 PCS20.2 64.25,119.09 63.41,119.92 PQS11.2
N21562486: length 2.5
  TOP w0.254: PDS06.2 50.26,120.07 50.66,120.47 50.66,121.12 51.24,121.71 PRS23.2
N21562772: length 3.6
  TOP w0.089: v3(167.95,33.43) 168.11,33.28 169.1,33.28 169.58,32.8 PRB44.2
  TOP w0.254: PDB05.2 169.4,33.51 169.73,33.18 PRB44.2
N21562775: length 8.7
  TOP w0.254: PUB02.1 165.63,34.32 165.88,34.58 v1(165.88,34.78) ; v1(167.43,37.84) 167.6,37.68 PDB04.1 167.6,36.58 168,36.18 v3(168.07,36.18) 168.61,36.18 169.09,36.66 PDB05.1
  BOTTOM w0.254: v1(165.88,34.78) 165.9,34.76 166.37,34.76 167.43,35.82 v1(167.43,37.84)
N21563532: length 1.7
  TOP w0.254: PDS05.2 50.87,122.72 PRS33.2
N21563639: length 2.8
  TOP w0.089: PRS32.2 44.79,117.44 v3(45.39,116.85)
  TOP w0.254: PDS04.2 45.25,118.37 44.79,117.91 PRS32.2
N21741311: length 2.9
  TOP w0.254: PQS12.1 50.65,130.74 v3(50.9,131) PRS37.2
N21741314: length 7
  TOP w0.089: v3(49.61,131.01) 49.61,131.38 50.75,132.51 PQS13.2
  TOP w0.254: PRS37.1 52.26,131.55 PQS13.2 53.93,132.51 PRS36.2
N21741394: length 4.5
  TOP w0.089: PQS12.2 53.2,128.57 v3(53.62,128.15)
  TOP w0.254: PRS38.2 49.47,128.57 PQS12.2
N21741482: length 0.6
  TOP w0.089: v1(43.7,139.06) v4(43.7,139.67)
  vias: v1(43.11,139.06) v1(43.11,138.48) v1(43.11,137.89) v1(43.11,137.31) v1(43.7,138.48) v1(43.7,137.89) v1(43.7,137.31) v1(47.39,134.32) v1(47.39,133.74) v1(47.98,134.32) v1(47.98,133.74) v1(51.7,138.77) v1(51.7,138.18) v1(51.7,137.6) v1(51.7,137.02) v1(52.28,138.77) v1(52.28,138.18) v1(52.28,137.6) v1(52.28,137.02)
N21741739: length 8.9
  TOP w0.089: PRS08.2 49.27,135.86 v3(49.23,135.9)
  TOP w0.254: PRS08.2 50.22,135.1 50.17,135.05 PQS13.1 v1(50.17,132.61)
  BOTTOM w0.254: v1(50.17,132.61) 51.14,132.61 v1(53.74,135.21)
N22643329: length 4.8
  TOP w0.089: UL1.27 21.09,83.53 20.99,83.63 20.63,83.63 19.35,84.91 T43.1
N22643331: length 1.3
  TOP w0.089: T44.1 20.67,84.33 UL1.25
N22643429: length 2.5
  TOP w0.254: 20.81,81.93 20.32,81.93 v3(19.92,81.52) RL8.2
N22643935: length 13.5
  TOP w0.089: v3(20.61,87.28) v1(20.61,86.61) 20.23,86.61 19.78,86.16 19.78,84.77 20.62,83.93 UL1.26 ; RL17.2 RL6.2 27.77,87.7 26.68,86.61 v1(26.59,86.61)
  IN1 w0.089: v1(26.59,86.61) v1(20.61,86.61)
N22649665: length 3.1
  BOTTOM w0.089: RE4.2 57.79,34.9 v3(58.52,34.9) 59.48,34.9 59.75,34.63 JKB1.30
N22657623: length 7.6
  TOP w0.089: v3(35.3,14.88) 34.96,15.22 v1(34.96,15.28)
  TOP w0.203: v1(31.71,14.86) 31.5,14.86 31.46,14.82 30.9,14.27 UA1.9
  TOP w0.254: v1(34.96,15.28) 34.51,15.73 RA56.1 ; CA17.1 32.3,15.06 31.97,15.06 31.87,14.97 31.81,14.97 v1(31.71,14.86)
  IN2 w0.254: v1(34.96,15.28) 34.51,15.73 33.65,15.73 32.94,15.02 32.06,15.02 31.91,14.86 v1(31.71,14.86)
N22661096: length 4.2
  TOP w0.203: UA1.27 22.46,14.67 v3(22.42,14.7) 21.9,14.7 CA19.2 21.13,15.48 RA13.1
N22661869: length 4
  TOP w0.203: UA1.39 25.88,9.9 25.78,9.8 25.78,9.31 25.08,8.61 v3(24.48,8.61) 24.2,8.61 23.78,8.19 CA20.2
N22662054: length 5.9
  TOP w0.203: UA1.7 31.78,13.47 v1(31.8,13.45) ; CA21.2 v1(35.37,13.52)
  IN2 w0.203: v1(31.8,13.45) 31.87,13.52 v1(35.37,13.52)
N22663765: length 3
  TOP w0.203: CA23.1 21.73,14.32 23.74,14.32 23.8,14.27 UA1.28
N22664360: length 3.5
  TOP w0.203: CA24.2 23.74,9.38 23.74,9.82 24.64,10.73 24.93,10.73 25.08,10.58 UA1.37
N22664751: length 3
  TOP w0.203: CA24.1 22.65,10.27 22.65,10.45 v3(22.83,10.63) 23.67,11.47 UA1.35
N22664968: length 6.2
  TOP w0.203: UA1.34 v3(23.14,11.87) 22.83,11.87 21.5,10.54 21.5,10.22
  TOP w0.254: 21.5,10.22 19.91,8.63 CA54.2
N22673637: length 4.4
  TOP w0.089: RA58.1 RA53.2 QA1.3 36.28,17.48 35.51,18.26 v3(35.25,18.26)
N22675171: length 1.3
  TOP w0.102: CA31.1 33.57,13.27 RA44.2
N22737223: length 2.3
  TOP w0.089: UL2.3 32.16,90.97 RL1.2 32.52,91.33 v3(33.21,91.33)
N23465138: length 5.8
  TOP w0.089: v3(46.83,91.44) RV164.2 RV165.1 47.34,90.61 46.9,90.17 CV25.1 47.8,88.58 47.98,88.58 48.07,88.67 UV8.5
N23821471: length 3.4
  TOP w0.089: U6.12 39.98,50.88 C38.1 40.19,51.05 41.16,52.01 v3(41.55,52.01)
N23827049: length 3.3
  BOTTOM w0.089: R21.1 R20.2 ; R21.1 v3(83.89,35.61) ; R21.1 82.95,35.59 JKB1.1
N24106209: length 13.5
  TOP w0.089: R15.2 113.58,27.82 113.65,27.88 113.92,27.88 114.16,28.12 Q2.3 114.16,29.31 113.45,30.02 112.78,30.02 112.51,30.29 110.33,30.29 109.12,29.08 108,29.08 107.73,29.35 C22.1 106.21,29.4 105.83,29.78 104.62,29.78 v3(104.36,29.52)
N24106231: length 3.3
  TOP w0.089: Q4.1 108.75,31.8 v3(109.08,32.14) 109.24,32.3 109.97,32.3 R16.1
N24142380: length 5.3
  TOP w0.089: v3(178.91,72.39) 179.52,71.78 DF1.1 179.62,71.05 RF3.1 180.87,70.28 180.87,70.66 v1(180.83,70.7)
  BOTTOM w0.089: JFAN1.3 181.04,70.7 v1(180.83,70.7)
N24551788: length 2.9
  TOP w0.089: v3(40.74,48.73) 40.15,49.31 C41.2 39.72,49.72 39.36,50.08 U6.10
N24554309: length 3.1
  BOTTOM w0.089: U3.10 119.79,113.7 C27.1 v3(119.74,112.7)
N24718506: length 2.6
  TOP w0.089: UA1.11 30.62,15.07 30.93,15.38 30.93,15.54 31.45,16.06 RA14.2
N24718549: length 2.9
  TOP w0.089: CA47.2 31.84,16.95 v3(31.48,16.58) 30.76,15.86 30.76,15.6 30.62,15.47 UA1.12
N24988789: length 2.4
  BOTTOM w0.089: UT10.6 30.2,131.17 RT119.1 v3(31.28,131.05)
N25136253: length 5.7
  TOP w0.089: RX7.2 222.75,43.75 220.15,43.75 219.75,44.15 U2.3
  TOP w0.102: v3(224,44.05) RX7.2
N26502042: length 8.3
  TOP w0.099: v1(130.69,56.29) 130.78,56.2 v3(130.78,54.99) 130.27,54.48 130.27,48.9 RC17.1
  BOTTOM w0.1: UC1.AW11 130.37,56.61 v1(130.69,56.29)
N26503230: length 1.4
  TOP w0.099: T2.1 127.73,84.79 127.69,84.75 v1(127.69,84.35)
  BOTTOM w0.089: v1(127.69,84.35) 127.35,84.01 UC1.F14
N26503233: length 3
  TOP w0.099: T3.1 130.91,85.66 130.02,85.66 129.71,85.35 v1(129.71,84.38)
  BOTTOM w0.089: v1(129.71,84.38) 129.33,84.01 UC1.F12
N26503236: length 1.3
  TOP w0.099: v1(131.72,84.34) 131.83,84.45 T4.1
  BOTTOM w0.089: UC1.F10 131.39,84.01 v1(131.72,84.34)
N26513758: length 10.3
  BOTTOM w0.089: 126.43,47.05 126.41,47.03 v3(126.41,46.86) RC449.2
  BOTTOM w0.1: 126.43,47.05 126.75,47.37 126.75,51.62 127.1,51.97 127.1,52.33 126.71,52.72 126.71,53.54 126.91,53.75 126.91,54.11 127.03,54.23 127.03,54.53 126.73,54.83 UC1.BA15
N26545373: length 12.6
  TOP w0.089: U58.12 220.56,58.8 220.81,59.05 221.34,59.05 v3(221.42,58.97)
  TOP w0.203: U58.28 215.68,51.81 216.06,52.19 216.06,55.11 217.27,56.32 217.27,57.84 218.22,58.8 U58.12
N26545412: length 4.4
  TOP w0.089: v3(221.66,61.88) 221.48,61.7 R65.1
  TOP w0.203: R65.1 221.42,60.98 221.42,60.48 221,60.07 U58.14
N26926732: length 16.8
  TOP w0.089: v1(118.36,34.72) v3(117.51,34.72) 115.62,34.72 115.16,35.18 112.38,35.18 110.5,36 109.67,36.83 107.58,36.83 v1(106.57,35.83)
  BOTTOM w0.089: RX30.2 106.96,35.68 106.81,35.83 v1(106.57,35.83) 106.42,35.67 106.04,35.67 105.91,35.8 UX1.21 ; v1(118.36,34.72) 118.76,34.33 119.75,34.33 RX2.2
N26926735: length 17.2
  TOP w0.089: v1(107.13,37.36) 107.48,37.02 109.74,37.02 110.6,36.15 112.42,35.36 114.76,35.36 117.11,37.71 v3(118.4,37.71) v1(119.26,37.71)
  BOTTOM w0.089: UX1.19 106.35,36.8 106.92,37.36 v1(107.13,37.36) 107.13,37.96 RX33.2 ; RX4.2 119.41,37.87 v1(119.26,37.71)
N26926835: length 3.9
  BOTTOM w0.089: v3(107.12,39.96) RX3.2 RX31.2 107.12,38.54 106.78,38.21 106.78,37.98 106.1,37.3 UX1.18
N26926873: length 4.9
  BOTTOM w0.089: UX1.27 103.53,33.1 103.95,32.68 RX35.2 103.95,31.38 104.15,31.17 RX6.2 v3(105.48,32.15)
N26928013: length 4.2
  TOP w0.089: QS1.6 QS1.5 203.55,34.67 203.5,34.62 RS29.2 203.23,35.34 204.28,36.38 v3(204.69,36.38)
N26936819: length 2.3
  BOTTOM w0.089: v3(27.26,128.01) 28.05,128.01 ; UT10.10 28.16,128.46
  BOTTOM w0.102: 28.05,128.01 RT130.1 28.16,128.02 28.16,128.46
N27108733: length 3.2
  BOTTOM w0.089: CT45.2 RT101.2 20.4,117.95 20.3,118.05 v3(20.3,118.52) 20.3,118.73 20.2,118.83
  BOTTOM w0.102: UT9.24 19.76,119.27 20.2,118.83
N27108736: length 4.1
  BOTTOM w0.089: 19.84,118.83 19.95,118.72 19.95,118.25 19.71,118.01 19.03,118.01 CT47.2 RT35.2
  BOTTOM w0.102: UT9.25 19.36,119.31 19.84,118.83
N27221272: length 3.9
  TOP w0.089: v3(38.67,12.92) 36.74,12.92 36.41,12.59 CA49.1 RA19.2
N27367990: length 3.1
  BOTTOM w0.089: RC680.2 C636.1 120.7,36.28 120.25,35.83 v3(118.73,35.83)
N27535100: length 2.1
  TOP w0.089: UE1.111 33.69,76.21 RE12.2
N27535635: length 0.8
  TOP w0.089: RE14.2 CE12.1
N27633672:
  vias: v3(26.7,117.66)
N27633678: length 20.2
  TOP w0.089: RT112.2 26.72,113.2 26.55,113.37 26.55,115.55 28.94,117.94 UT4.4 30.34,117.94 31.71,119.31 CT53.1 32.66,119.01 32.66,116.31 32.55,116.2 QT4.1 v3(32.55,113.53) 32.44,113.43 31.73,113.43 UT4.3
N27633690: length 4.5
  TOP w0.089: v3(35.58,114.55) 35.58,115.73 34.96,116.35 RT113.1 CT54.1 34.79,117.43 QT4.2
N27634822: length 4.7
  BOTTOM w0.089: RT33.2 30.83,113.06 v3(31.67,112.23)
  BOTTOM w0.254: RT33.2 32.28,113.6 32.37,113.51 QT3.1
N27636003: length 25
  TOP w0.089: UT8.4 34.21,131.06 34.36,131.21 RT62.1 37.22,132.18 38.62,130.78 38.62,128.85 38.27,128.49 38.27,126.55 39.41,125.4 v3(39.41,125.12) 39.3,125.01 39.3,123.11 40.81,121.59 40.81,116.93 v1(40.98,116.76)
  BOTTOM w0.089: QT5.3 40.34,115.65 40.98,116.29 v1(40.98,116.76)
N27700832: length 31
  TOP w0.254: v1(24.35,99.45) 24.35,99.53 23.69,100.19 QI1.1 ; RI28.2 RI22.2 v1(22.46,94.42) ; v1(20.09,95.47) 19.86,95.25 RI23.2 ; v1(20.15,91.42) 20.04,91.31 RI26.2 ; v1(22.58,97.43) 22.23,97.09 RI21.2 ; v1(20.16,88.36) 19.73,88.36 19.48,88.62 RI25.2 ; RI27.2 22.35,90.67 v1(22.54,90.48) ; v1(20.3,92.48) 20.25,92.53 19.53,92.53 RI24.2
  IN2 w0.254: v1(24.35,99.45) 24.35,98.78 23.28,97.7 22.84,97.7 v1(22.58,97.43) 20.62,95.47 v1(20.09,95.47) 19.47,94.85 19.47,92.91 19.9,92.48 v1(20.3,92.48) 20.3,91.58 v1(20.15,91.42) 19.59,90.86 19.59,88.76 19.99,88.36 v1(20.16,88.36) 20.29,88.36 20.62,88.69 20.62,89.1 22,90.48 v1(22.54,90.48) 22.04,90.98 22.04,94 v1(22.46,94.42)
  BOTTOM w0.089: v1(22.46,94.42) 22.03,94.42 v3(21.85,94.24)
N27708054: length 2.1
  BOTTOM w0.089: U3.12 120.82,114.5 v3(120.71,114.61) C24.1
N27906658: length 1.3
  TOP w0.089: RH22.2 224.24,60.7 T120.1
N27906903: length 1.4
  TOP w0.089: T121.1 224.72,61.53 RH23.2
N27907005: length 1.4
  TOP w0.089: RH24.2 224.51,63.23 T122.1
N27917496: length 3
  TOP w0.099: T112.1 133.13,53.37 v1(132.66,52.9)
  BOTTOM w0.102: v1(132.66,52.9) 132.76,52.9 133.73,53.87 UC1.BC6
N28062813: length 4.2
  TOP w0.203: UA1.16 28.28,16.71 28.82,17.25 v3(28.82,18.72) 28.82,19.05 28.46,19.41 CA57.1
N28203970: length 19.7
  IN3 w0.089: v1(3.21,130.55) 3.21,128.39 4.19,127.41 9.4,127.41 12.54,130.55 15.66,130.55 15.78,130.68 v1(15.78,130.93)
  BOTTOM w0.089: R68.1 15.58,131.14 v1(15.78,130.93) 15.78,130.92 v3(16.23,130.48) ; v1(3.21,130.55) 2.55,131.21 LED1.4
N28203972: length 19.1
  IN3 w0.089: v1(3.25,131.19) 3.64,130.79 3.64,128.53 4.54,127.63 9.24,127.63 12.42,130.81 15.02,130.81 v1(15.15,130.93)
  BOTTOM w0.089: LED1.2 v1(3.25,131.19) ; R69.1 15.27,132.39 15.15,132.27 v1(15.15,130.93) v3(14.63,130.93)
N28205898: length 1.2
  TOP w0.089: US5.3 189.16,35.49 188.77,35.11 RS60.1
N28206848: length 2
  TOP w0.089: v3(72.17,140.58) RW13.2 71.18,139.64 UW1.3
N28207892: length 5.5
  TOP w0.089: R300.1 208.8,33.88 v3(208.8,32.98) 208.82,32.98 209.85,31.95 211.12,31.95 211.36,32.19 211.36,32.96 211.48,33.08 U5.3
N28296708: length 19.7
  TOP w0.089: 134.97,44.06 133.18,42.27 133.18,42.02 132.27,41.11 131,41.11 130.16,41.95 v1(130.16,42.01) ; 136.78,44.79 v3(137.77,44.79) 139.65,44.79 140.08,44.36 v1(140.99,44.36)
  TOP w0.099: 134.97,44.06 135.7,44.79 136.78,44.79
  BOTTOM w0.089: UC9.2 143.21,44.38 CC95.1 141.32,44.62 141.05,44.36 v1(140.99,44.36) ; v1(130.16,42.01) 130.16,42.12 129.82,42.46 129.82,43.27 129.87,43.32 129.87,43.61 RC618.1
N28502853: length 1.1
  TOP w0.254: PRS40.2 51.54,120.66 PDS03.2
N28502856: length 3.5
  TOP w0.254: PDS03.3 51.91,118.65 52.73,119.46 52.73,120.43 52.95,120.66 PRS41.2
N28577025: length 2.7
  BOTTOM w0.089: UX1.3 99.25,35.3 RX28.2 v3(98.65,35.01)
N28577921: length 4
  BOTTOM w0.089: UX1.15 104.03,38.93 103.79,39.16 103.79,40.01 103.98,40.2 v3(103.98,40.29) 103.84,40.43 102.1,40.43 RX32.2
N28579184: length 1.7
  BOTTOM w0.089: T116.1 102.53,32.1 UX1.29
N28580789: length 50.1
  TOP w0.089: v3(45.72,125.71) 44.81,125.71 v1(44.8,125.72)
  TOP w0.254: v1(44.8,125.72) 44.29,125.21 42.71,125.21 42.57,125.07 PR63.1 ; PD11.1 82.63,138.78 82.08,139.34 79.76,139.34 78.7,138.27 78.7,137.49 78.4,137.19 77.45,137.19 v1(77.34,137.3)
  IN1 w0.254: v1(77.34,137.3) 77.25,137.21 75.3,137.21 74.28,136.19 72.46,136.19 70.28,134.01 61.6,134.01 61.22,134.39 55.44,134.39 49.33,128.28 49.33,126.74 48.21,125.62 44.89,125.62 v1(44.8,125.72)
N28580920: length 53.9
  TOP w0.089: PU1.4 85.67,142.47 v3(85.85,142.29)
  TOP w0.254: v1(47.77,123.73) PR62.1 47.76,124.81 PR61.2 46.53,124.81 46.21,125.13 45.64,125.13 45.27,124.76 PQS30.3 ; PU1.4 84.07,142.47 v1(83.63,142.91)
  IN1 w0.254: v1(83.63,142.91) 83.09,142.91 81.43,141.24 80.09,141.24 78.93,140.08 78.93,137.14 78.63,136.84 75.55,136.84 73.79,135.09 71.85,135.09 70.42,133.66 61.46,133.66 61.07,134.04 55.65,134.04 49.68,128.07 49.68,126.45 47.77,124.54 v1(47.77,123.73)
N28582416: length 10.9
  TOP w0.254: v1(53.7,122.87) 53.59,122.98 PRS43.2 PRS44.1 ; PRS02.1 v1(46.5,119.39)
  BOTTOM w0.254: v1(46.5,119.39) 46.87,119.39 50.35,122.87 v1(53.7,122.87)
N28583343: length 18.7
  TOP w0.089: v1(51.33,124.82) 51.05,124.82 50.55,125.32 v3(50.55,125.59)
  TOP w0.254: v1(59.86,125.24) 59.72,125.24 59.47,124.99 PRS42.2 ; v1(53.22,120.2) 53.43,119.99 PDS03.1 ; PUS03.2 51.58,125.39 51.33,125.14 v1(51.33,124.82)
  IN1 w0.254: v1(59.86,125.24) 59.72,125.1 51.6,125.1 v1(51.33,124.82)
  IN3 w0.254: v1(53.22,120.2) 52,121.42 52,124.15 v1(51.33,124.82)
N28583360: length 20.4
  TOP w0.089: PQS14.1 69,135.61 v3(68.32,136.28)
  TOP w0.254: PQS14.1 69.1,135.54 v1(69.72,135.54) 69.72,135.35 70.01,135.06 70.39,135.06 PRS45.2 ; PRS18.2 61.48,125.36 PRS34.2 62.27,125.36 63.03,126.12 63.69,126.12 64.2,126.64 64.2,127.14 v1(64.08,127.26)
  IN2 w0.254: v1(64.08,127.26) 63.61,127.73 63.61,132.95 66.2,135.54 v1(69.72,135.54)
N28583366: length 7.5
  TOP w0.203: PQS14.2 68.35,132.49 v3(68.11,132.25) 67.6,132.25 66.43,131.08 66.43,127.17 PRS35.1
N28592761: length 1.7
  TOP w0.254: PRH08.2 168.81,45.15 PRH10.2 168.87,44.33 PRH13.1
N28593397: length 4.9
  TOP w0.089: v3(164.54,47.18) 164.09,46.73 PRH15.1
  TOP w0.254: PCH19.2 163.29,44.18 PQH01.2 164.12,44.75 PCH18.2 164.12,46.11 PRH15.1
N28593401: length 6.9
  TOP w0.254: PRH13.2 168.94,42.98 168.26,42.3 166.67,42.3 v3(166.24,42.73) 165.66,42.73 165.45,42.94 PQH01.1 165.45,44.87 PCH18.1
N28593455: length 10.4
  TOP w0.089: v3(168.55,53.59) 168.55,52.75 PRH17.1
  TOP w0.254: PRH17.1 PRH16.2 168.37,51.53 168.37,49.19 168.12,48.94 PQH02.3 167.63,48.65 167.33,48.36 166.07,48.36 165.62,47.9 165.62,47.56 165.87,47.3 165.87,46.73 165.27,46.13 PRH15.2
N28618638: length 18.1
  TOP w0.254: PQS63.1 45.2,137.59 46.94,135.85 PRS62.2 47.25,135.86 PCS61.2 48.79,136.56 49.58,136.56 49.87,136.85 49.87,139.35 50.12,139.61 PQS61.4 51.27,139.61 51.67,140.01 v3(52.5,140.01) 54.72,140.01 54.96,139.77 54.96,136.5 PRS61.1
N28618644: length 4.3
  TOP w0.089: PRS66.1 v3(41.3,133.01)
  TOP w0.508: PRS66.1 43.21,133.57 43.21,133.57 PRS63.2 43.21,134.23 43.87,134.89 PQS63.2
N28618652: length 1.9
  TOP w0.089: v3(38.93,126.59) 39.26,126.92 PRS64.2
  TOP w0.254: PRS64.2 40.69,126.92 PRS65.2
N28618683: length 2.1
  TOP w0.508: PQS64.1 40.65,131.01 v3(41.35,131.71) PRS66.2
N28618685: length 3
  TOP w0.089: v3(55.46,134.15) PRS61.2
  TOP w0.254: PRS61.2 55.67,135.09 56.43,135.84 PQS62.1
N28618689: length 3
  TOP w0.089: PRS64.1 39.05,127.83 v3(38.9,127.99)
  TOP w0.254: PCS62.1 39.92,127.77 PRS64.1 39.85,128.32 40,128.46 PQS64.2
N28639206: length 3.7
  TOP w0.089: PRB41.2 163.77,33.27 165.08,31.95 v3(165.35,31.95)
  TOP w0.254: PUB02.2 163.8,33.67 PRB41.2
N28737012: length 1.9
  TOP w0.254: PQH02.2 166.86,49.59 PRH19.2 PCH20.1
N28737022: length 3.5
  TOP w0.089: v3(171.03,50.88) 170.56,50.41 PRH18.2
  TOP w0.254: PQH02.5 170.21,49.59 PRH18.2 170.25,50.24 PQH02.6
N29197780: length 6.4
  BOTTOM w0.089: UC20.3 131.88,25.06 132.11,24.82 133.13,24.82 133.32,25.01 133.32,26.35 133.7,26.73 134.64,26.73 RC6127.1 v3(135.1,25.33)
N30021424: length 91.3
  TOP w0.089: v1(38.46,90.67) 39.55,89.58 v3(41.52,89.58) RS62.1
  IN2 w0.089: v1(29.33,27.76) 29.33,29.24 30.49,30.4 30.49,31.52 30.67,31.69 31.29,31.69 31.96,32.37 31.96,34.16 34.51,36.7 34.74,36.7 35.34,37.31 35.34,38.81 35.53,39 36.86,39 37.14,39.28 37.14,39.86 36.97,40.03 36.97,42.25 36.59,42.63 36.59,44.82 37.19,45.42 37.19,45.64 36.83,46 36.83,46.8 38.71,48.67 38.71,51.95 38.25,52.41 38.25,53.51 33.05,58.71 33.05,62.06 32.79,62.33 32.79,70.09 33.45,70.75 33.45,71.64 36.39,74.58 36.39,78.12 37.73,79.47 37.73,80.92 37.36,81.3 37.36,86.66 37.71,87.02 37.71,89.93 v1(38.46,90.67)
  IN3 w0.089: v1(29.23,24.83) 29.23,26.19 29.33,26.29 v1(29.33,27.76)
  BOTTOM w0.089: v1(29.23,24.83) 31.89,24.83 32.25,25.19 36.83,25.19 37.13,25.49 JSSD1.10
N30021591: length 3.7
  TOP w0.089: Q26.5 39.43,91.4 R82.2 ; v3(38.08,91.24) 38.79,91.24 39,91.04 R82.2 ; R82.2 39.37,90.75 Q26.6
N30684242: length 3.8
  BOTTOM w0.089: RT132.1 20.7,115.5 v2(20.04,115.5) 19.67,115.5 19.49,115.32 19.09,115.32 18.95,115.46 18.95,115.87 19.16,116.09 19.16,116.34 CT45.1
N30684245: length 4.1
  BOTTOM w0.089: CT47.1 18.97,116.35 18.97,116.17 18.76,115.95 v2(18.76,115.69) 18.76,115.38 19.01,115.13 19.57,115.13 19.75,115.31 20.68,115.31 RT133.1
N32433695: length 4
  TOP w0.102: UV14.J13 155.1,120.11 154.73,119.74 154.73,118.55 153.71,117.53 RV120.1
N32433703: length 3.1
  TOP w0.102: UV14.J1 155.34,129.94 155.49,130.09 155.49,132.06 RV116.1
N32433714: length 10
  TOP w0.102: RV118.1 163.82,123.62 v1(163.63,123.43) ; v1(155.49,123.05) 155.11,122.67 UV14.J10
  BOTTOM w0.102: v1(155.49,123.05) 156.3,123.87 162.3,123.87 162.74,123.43 v3(163.12,123.43) v1(163.63,123.43)
N32434049: length 4.4
  BOTTOM w0.102: RV121.1 152.82,117 v3(153.38,117.56) 154.71,118.89 154.71,119.71 UV15.J13
N32434050: length 3.3
  BOTTOM w0.102: RV117.1 155.82,131.73 v3(155.82,131.52) 155.82,130.87 155.11,130.16 UV15.J1
N32434053: length 11.2
  BOTTOM w0.102: UV15.J10 155.11,122.8 155.04,122.86 155.04,123.31 156.53,124.79 163.07,124.79 v3(163.11,124.75) 163.11,124.65 163.78,123.99 163.88,123.99 RV119.1
N32437553: length 6.7
  TOP w0.089: v3(153.4,151.57) 153.4,149.55 153.83,149.12 RV123.1 153.83,148.57 154.92,147.48 154.92,147.42
  TOP w0.102: 154.92,147.42 154.92,147.35 155.53,146.74 155.53,146.34 155.12,145.93 UV12.J13
N32437559: length 5.5
  BOTTOM w0.089: 155.17,147.42 155.98,148.23 156.47,148.23 RV132.1 157.27,149.84 v3(157.13,149.98)
  BOTTOM w0.102: UV13.J13 155.43,146.25 155.43,146.84 155.14,147.14 155.14,147.39 155.17,147.42
N32437560: length 2.9
  BOTTOM w0.102: RV131.1 v3(155.09,134.55) 155.09,136.31 UV13.J1
N32437563: length 9.8
  BOTTOM w0.102: RV133.1 163.68,142.85 v3(163.09,142.85) 161.93,142.85 161.65,142.58 155.52,142.58 155.11,142.99 UV13.J10
N37640332: length 1.4
  TOP w0.381: v1(126.12,128.33) 125.59,128.33 RV2.2
  BOTTOM w0.381: UV1.N10 126.58,128.36 126.22,128.36 126.19,128.33 v1(126.12,128.33)
N37640410: length 1.4
  TOP w0.508: RV3.1 120.17,138.55 v1(120.12,138.49)
  BOTTOM w0.381: v1(120.12,138.49) 120.12,138.02 UV1.AA22
N37828209: length 1.4
  TOP w0.508: RV1.1 121.25,138.62 v1(121.36,138.51)
  BOTTOM w0.381: v1(121.36,138.51) 121.36,138.51 121.36,137.82 UV1.Y22
N38038746: length 2.6
  BOTTOM w0.089: CV96.1 v3(150.94,114.81)
  BOTTOM w0.102: RV37.2 RV36.2 150.88,115.66 CV96.1
N38038992: length 6.4
  TOP w0.102: v1(129.28,126.17) 129.42,126.17 129.87,125.72 v3(130.33,125.72) 130.4,125.66 130.4,124.01 130.04,123.66 129.77,123.66 129.52,123.41 129.52,122.39 129.71,122.2 CV98.2
  BOTTOM w0.102: v1(129.28,126.17) 128.94,126.51 UV1.K8
N38038994: length 4.8
  TOP w0.102: CV99.2 128.34,122.33 129.01,122.99 129.01,124.36 128.97,124.39 128.97,125.26 128.65,125.58 v1(128.47,125.58)
  BOTTOM w0.102: v1(128.47,125.58) 128.16,125.58 UV1.L7
N38038995: length 0.9
  TOP w0.102: RV40.2 CV98.1
N38038996: length 4.3
  TOP w0.102: CV99.1 127.09,121.27 v3(126.78,120.96) 126.66,120.84 126.66,119.29 126.76,119.18 RV41.2
N38349725: length 10.4
  TOP w0.254: RV39.2 122.74,145.53 v3(123.92,145.53) 125.33,145.53 125.64,145.22 125.64,144.46 125.95,144.14 127.3,144.14 127.61,143.82 127.61,143.56 128.58,142.6 v1(128.58,140.56)
  BOTTOM w0.3: v1(128.58,140.56) UV1.K25
N38996077: length 3.2
  TOP w0.102: RV134.1 155.09,133.43 155.47,133.81 v3(155.47,134.36) 155.47,135.96 UV12.J1
N38996080: length 11.5
  TOP w0.102: v1(154.85,142.55) 155.11,142.8 UV12.J10 ; RV135.1 v1(163.98,141.79)
  BOTTOM w0.102: v1(163.98,141.79) 163.76,141.56 v3(163.47,141.56) 155.84,141.56 v1(154.85,142.55)
N40598435: length 0.6
  BOTTOM w0.089: 23.8,40.27 v3(24.42,40.27)
N40598500: length 2.2
  TOP w0.508: v1(22.75,101.89) 21.87,101 PC507.1
N40598503: length 2.8
  BOTTOM w0.089: v3(21.34,49.41) 21.88,48.88 21.88,48.28 21.52,47.93 PR306.1
  BOTTOM w0.254: PR306.1 21.51,47.85 PC315.2
N40598539: length 1.8
  BOTTOM w0.089: PR509.1 v3(23.94,92.12)
  BOTTOM w0.254: PC517.2 PR509.1
N40598619: length 2.4
  BOTTOM w0.089: v3(27.59,86.57) PR507.2
  BOTTOM w0.254: PD501.1 28.34,87.49 PR507.2
N42785906: length 4.9
  TOP w0.089: PCB35.1 v3(203.37,41.92)
  TOP w0.254: v1(205.07,42.59) 204.92,42.59 204.31,41.98 PCB35.1
  BOTTOM w0.203: PRB21.1 204.31,41.48 205.01,42.18 205.01,42.52 205.08,42.59 v1(205.08,42.59) 205.08,42.69 205.04,42.73 205.04,43.29 205.17,43.42 PUB01.3
N42785908:
  vias: v3(204.54,57.92)
N42785925: length 24.4
  IN1 w0.254: v1(184.06,58.68) 184.95,57.78 192.88,57.78 197.34,53.32 197.34,49.53 197.9,48.97 197.9,47.37 v1(198.6,46.67)
  BOTTOM w0.203: v1(198.6,46.67) 198.77,46.67 PRB03.1
  BOTTOM w0.254: v1(184.06,58.68) 184.17,58.56 PRB01.3
N42785929: length 1.8
  BOTTOM w0.203: PUB01.29 207.76,45.69 208.24,45.22 PRB28.1
N42785931: length 2.6
  BOTTOM w0.254: PCB40.1 210.02,44.31 PRB34.1 209.99,44.35 209.99,45.19 ; 209.99,45.19 PRB28.2 ; 209.99,45.19 PRB35.1
N42785953: length 3.6
  TOP w0.254: v1(207.63,44.98) 207.63,44.6 v3(207.75,44.48) 208.24,43.99 PRB33.1
  BOTTOM w0.203: PRB31.1 208.05,44.56 v1(207.63,44.98) 207.63,45.09 207.42,45.29 PUB01.30
N42785972: length 4.9
  TOP w0.089: PDB04.3 166.01,36.47 166.33,36.79 v3(166.33,38.95)
  TOP w0.254: PDB04.3 165.5,36.28 PRB38.2 165.51,35.39 PRB37.1
N42786037: length 32.2
  IN2 w0.254: v1(202.42,39.56) 202.01,39.97 199.97,39.97 199.69,40.25 196.4,40.25 195.42,41.23 193.07,41.23 192.35,40.52 189.46,40.52 188.85,41.13 183.41,41.13 183,41.54 178.4,41.54 177.54,42.4 v1(177.48,42.4)
  BOTTOM w0.254: PRB12.3 177.68,42.6 v1(177.48,42.4) ; v1(202.42,39.56) v3(202.9,39.08) 203.08,39.08 203.72,38.43 204.95,38.43 205.07,38.55 205.27,38.55 PRB36.2
N42786187: length 3
  TOP w0.089: v3(166.22,30.74) 166.21,30.74 166.21,31.33 167,32.11 PRB42.1
  TOP w0.254: PUB02.4 167.18,32.58 PRB42.1
N42786230: length 6.5
  TOP w0.254: v1(209.6,42.06) 210.16,42.06 210.42,42.31 210.42,43.47 209.43,44.46 ZTB03.1
  BOTTOM w0.254: v1(209.6,42.06) 209.47,42.19 209.47,42.9 209.46,42.91 209.46,43.9 208.99,44.36 PRB31.2
N42786400: length 30.6
  IN2 w0.254: v1(202.99,39.69) 202.97,39.69 202.35,40.31 200.11,40.31 199.83,40.6 196.54,40.6 195.56,41.58 192.92,41.58 192.21,40.86 189.61,40.86 189,41.47 183.56,41.47 183.14,41.89 178.74,41.89 v1(178.35,42.27)
  BOTTOM w0.254: PRB12.2 177.68,41.96 178,42.27 v1(178.35,42.27) ; v1(202.99,39.69) 202.99,39.67 203.84,38.82 v3(204.33,38.82) 204.65,38.82 205.21,39.37 PRB32.2
N42787418: length 2.1
  TOP w0.089: v3(164.6,38.79) PRB40.2
  TOP w0.254: PDB04.2 165.14,37.77 165.05,37.87 PRB40.2
N42787433: length 4.7
  TOP w0.089: PRB27.2 209.15,48.33 208.64,48.84 v3(208.06,48.84)
  TOP w0.254: PRB27.2 209.12,47.86 208.29,47.03 PRB29.2 207.48,47.03 v1(207.4,47.11)
  BOTTOM w0.203: PUB01.26 207.18,46.89 v1(207.4,47.11)
N42787440: length 2
  BOTTOM w0.089: PCB42.1 210.04,47.31 v3(210.62,47.89)
  BOTTOM w0.254: PCB42.1 210.04,47.04 PRB30.2
N42787460: length 1
  BOTTOM w0.089: v3(198.41,46.07) 198.48,46.14 PRB06.2
N42787464: length 1
  TOP w0.254: ZTB01.1 210.04,47.04 209.7,47.04 209.69,47.03 PRB29.1
N42787500: length 1.2
  BOTTOM w0.089: v3(201.46,39.45) 201.69,39.68 201.69,39.73 201.83,39.88 PRB15.1
N42787538: length 23.7
  IN1 w0.254: v1(184.76,58.68) 185.3,58.14 193.02,58.14 197.7,53.46 197.7,49.68 198.28,49.09 198.28,47.68 v1(198.6,47.36)
  BOTTOM w0.203: PRB02.1 v1(198.6,47.36)
  BOTTOM w0.254: v1(184.76,58.68) 184.17,59.26 PRB01.2
N42787589: length 1.9
  BOTTOM w0.203: PRB14.2 205.27,49.52 205.27,48.85 204.77,48.35 PUB01.21
N42787591: length 2
  BOTTOM w0.203: PRB16.2 205.77,49.46 205.77,48.94 205.42,48.58 205.17,48.33 PUB01.22
N42787599: length 2.7
  TOP w0.254: ZTB02.1 206.28,49.55 v1(206.28,49.02)
  BOTTOM w0.203: PUB01.23 205.57,48.31 205.79,48.54 205.8,48.54 v1(206.28,49.02)
  BOTTOM w0.254: v1(206.28,49.02) 206.78,49.52 PRB19.2
N45824609: length 7.3
  TOP w0.254: PRS05.1 49.12,117.1 PRS01.1 50.02,117.09 PCS03.1 51.02,117.33 PRS03.2 51.14,115.17 50.57,114.61 PUS01.3
N45824635: length 7
  TOP w0.254: PRS39.1 47.5,115.91 PUS01.1 49.85,115.91 49.92,115.98 49.92,116.34 49.79,116.47 48.84,116.47 PRS01.2 48.22,117.89 PCS04.1 48.23,117.93 PRS02.2
N45824651: length 5.5
  TOP w0.254: PUS01.2 47.59,115.26 PCS02.1 PRS06.1 46.58,116.03 v3(46.47,116.14) 46.49,116.16 46.49,116.86 PRS04.2
N45824918: length 3.2
  TOP w0.254: PQS04.1 54.52,133.97 54.39,134.09 PRS11.2
N45824978: length 2.1
  TOP w0.254: PRS15.2 65.31,127.3 PQS07.1
N45824994: length 1.4
  TOP w0.254: PRS16.2 60.54,130.11 PQS05.6
N47697054: length 1.4
  BOTTOM w0.254: PUH01.7 166.05,46.73 166.16,46.85 167.14,46.85 PRH05.2
N47701287: length 2.9
  TOP w0.089: v3(166.1,44.46) 166.32,44.68 v1(166.56,44.68)
  TOP w0.254: PCH11.1 166.94,44.31 v1(166.56,44.68)
  BOTTOM w0.254: PUH01.11 166.31,44.93 v1(166.56,44.68) 166.95,44.3 PRH11.1
N47701297: length 1.4
  BOTTOM w0.254: PCH10.1 167.01,45.83 PUH01.9
N47703049: length 2.6
  TOP w0.089: PCH14.2 168.91,46.39 169.59,47.07 v3(169.93,47.07)
  TOP w0.254: PRH12.1 168.89,45.97 PCH14.2
N47710281: length 4.1
  TOP w0.089: PCF04.1 81.22,109.88 v3(81.44,109.66)
  TOP w0.254: PUF01.4 80.95,112.7 81.51,112.13 81.51,111.77 PRF04.2 81.21,110.63 PCF04.1
N47727861: length 3.3
  TOP w0.089: v3(144.88,111.25) 144.42,111.25 v1(143.99,110.82)
  TOP w0.254: v1(143.99,110.82) 144.44,110.36 PRW11.1
  BOTTOM w0.254: PCW11.1 144.29,111.12 v1(143.99,110.82) 143.8,110.63 PUW01.11
N47727869: length 1.6
  BOTTOM w0.254: PCW10.1 142.9,111.16 PUW01.9
N47735962: length 2
  BOTTOM w0.254: PUW01.7 142,110.39 141.52,110.87 141.34,110.87 PRW05.2
N47737171: length 2.1
  BOTTOM w0.089: PCW14.2 v3(148.13,114.44)
  BOTTOM w0.254: PRW12.1 147.09,114.36 PCW14.2
N48536383: length 46.4
  TOP w0.254: v1(164.43,58.85) 164.77,59.19 168.41,59.19 170.52,61.3 170.52,76.57 v3(168.45,78.64) 154.69,78.64 153.39,79.94 151.27,79.94 150.35,80.86 PRZ28.2
  BOTTOM w0.254: PLZ02.3 v1(164.43,58.85)
N48536385: length 46.7
  TOP w0.254: v1(164.42,59.52) 164.44,59.54 168.25,59.54 170.16,61.45 170.16,76.35 v3(169.66,76.85) 168.22,78.29 154.55,78.29 153.38,79.45 149.64,79.45 PRZ27.2 148.18,79.9 PRZ22.1
  BOTTOM w0.254: PLZ02.2 164.43,60.01 164.42,60 v1(164.42,59.52)
N48536391: length 1.1
  TOP w0.089: PCZ26.1 v3(161.02,59.51)
N48536437: length 1.6
  TOP w0.089: v3(158.42,80.31) 157.45,81.28 157.45,81.33 PRZ21.2
N48542989: length 5.7
  TOP w0.089: PR2504.2 70.89,115.43 70.67,115.21 69.12,115.21 v3(68.84,115.49)
  TOP w0.254: PU2501.4 72.25,114.23 72.43,114.41 72.43,115.3 PC2504.1 PR2504.2
N48611923: length 1
  TOP w0.089: PCM11.1 v3(51.98,26.98)
N48611974: length 2.4
  TOP w0.203: PRM06.2 33.77,26.66 34.51,27.4 34.51,27.62 34.51,27.75 34.78,28.01 PUM01.10
N48613026: length 3.1
  TOP w0.089: v3(176.86,55.85) 176.3,55.29 v1(176.03,55.29)
  TOP w0.254: PR1803.2 175.96,55.36 v1(176.03,55.29)
  BOTTOM w0.254: v1(176.03,55.29) 176.03,55.29 176.35,55.61 PU1801.4
N48613121: length 1
  TOP w0.089: PC1806.1 v3(181.14,53.53)
N48614351: length 3.5
  TOP w0.203: PUV01.15 73.98,126.04 73.77,125.84 73.19,125.84 PCV33.2
  TOP w0.254: PCV33.2 72.68,125.33 PRV33.2
N48614360: length 0.8
  TOP w0.254: PRV35.2 71.78,124.61 PCV33.1
N48614362: length 4.3
  TOP w0.178: PRV13.2 79.57,129.63 78.68,129.63 v3(78.35,129.3) 77.51,129.3 77.37,129.44 PUV01.25
  TOP w0.254: PRV13.2 79.66,129.73 PCV11.1
N48614371: length 5.8
  TOP w0.203: PUV01.11 72.38,127.07 72.17,126.87 71.41,126.87 70.51,127.77 v3(70.27,127.77) 70.12,127.92 69.57,127.92 69.37,127.71 69.37,127.29 69.17,127.08 68.44,127.08 PRV19.1
N48614372: length 4.5
  TOP w0.203: PCV25.1 74.66,125.52 74.38,125.8 PUV01.16
  TOP w0.254: PRV34.2 PCV27.1 74.72,124.39 PRV29.1 74.66,124.61 PCV25.1
N48614375: length 4.2
  TOP w0.203: PCV34.1 76.36,125.34 75.86,125.84 74.98,125.84 74.78,126.04 PUV01.17
  TOP w0.254: PRV36.2 77.55,125.34 PCV34.1
N48614410: length 1.2
  TOP w0.089: PCV21.1 80.68,128.33 v3(80.81,128.46)
N48614414: length 38.2
  TOP w0.089: PRV24.1 v3(68.08,117.24)
  TOP w0.254: PRV24.1 68.27,118.27 68.9,118.27 69.33,118.7 69.33,119.5 70.08,120.25 PRV22.1 70.39,120.38 70.88,120.38 70.88,120.39 v1(70.89,120.39)
  IN1 w0.254: v1(70.89,120.39) 70.89,120.81 71.57,121.49 72.41,121.49 73.16,122.24 78.65,122.24 79.45,121.44 81.18,121.44 82.02,120.6 85.86,120.6 87.06,119.41 87.65,119.41 87.78,119.28 92.08,119.28 92.11,119.25 92.38,119.25 93.98,120.86 93.98,122.98 94.84,123.83 v1(94.84,125.03)
  BOTTOM w0.254: PLV01.3 94.84,125.33 v1(94.84,125.03)
N48614416: length 34.3
  TOP w0.254: v1(71.5,120.39) 71.42,120.47 71.42,121.59 71.67,121.84 PRV25.1
  IN1 w0.254: v1(95.47,125.03) 95.47,123.98 94.33,122.83 94.33,120.71 92.4,118.78 92.14,118.78 92.11,118.75 91.93,118.93 87.64,118.93 87.51,119.06 86.91,119.06 85.82,120.16 81.97,120.16 81.03,121.09 79.31,121.09 78.51,121.89 73.31,121.89 72.56,121.14 71.98,121.14 71.5,120.66 v1(71.5,120.39)
  BOTTOM w0.254: PLV01.2 95.47,124.69 v1(95.47,125.03)
N48614440: length 34.8
  TOP w0.089: v1(89.65,121.6) v3(90.33,121.6)
  TOP w0.254: v1(66.98,125.01) 66.98,125.54 PRV18.1 PRV19.2
  IN3 w0.254: v1(66.98,125.01) 66.96,125.01 66.96,125.01 66.61,125.01 65.54,123.93 65.54,123.51 66.71,122.33 71.57,122.33 74.58,125.34 74.58,126.3 75.01,126.73 75.56,126.73 75.92,126.37 75.92,126.11 76.33,125.69 76.65,125.69 78.65,123.69 79.92,123.69 82.46,121.15 88.74,121.15 89.19,121.6 v1(89.65,121.6)
  BOTTOM w0.254: PHV01.1 v1(89.65,121.6)
N48614448: length 9.2
  TOP w0.203: v1(75.36,126.27) 75.18,126.46 PUV01.18
  TOP w0.254: PRV29.2 PRV26.2 73.76,122.88 PCV26.1 ; PRV31.1 PRV32.1 73.68,122 PCV26.1 ; PCV26.1 73.67,122.79 73.31,122.79 v1(73.07,123.03)
  IN3 w0.254: v1(75.36,126.27) 75.36,125.3 73.09,123.03 v1(73.07,123.03)
N48614451: length 0.8
  TOP w0.254: PCV25.2 73.74,124.54 PRV26.1
N48614453: length 0.9
  TOP w0.254: PCV31.1 73.64,121.03 PRV32.2
N48614455: length 10.5
  TOP w0.203: PUV01.19 75.58,126.7 75.79,126.49 75.79,126.33 76.28,125.84 76.81,125.84 76.82,125.83 77.92,125.83 78.12,125.63 78.12,123.9 77.05,122.83 PRV27.1
  TOP w0.254: PRV27.1 77.05,122.17 76.64,121.76 v3(76.49,121.76) 75.64,121.76 PCV29.2 75.38,121.99 74.6,122.77 PCV26.2
N48614458: length 2.9
  TOP w0.089: PCV29.1 75.9,121.08 76.4,120.58 76.4,119.92 v3(76.31,119.83)
  TOP w0.254: PRV31.2 PCV29.1
N48614482: length 31.6
  TOP w0.254: PRV28.2 70.65,121.12 70.27,120.73 69.88,120.73 69.33,120.19 69.33,119.99 68.87,119.53 v1(68.87,118.89)
  IN2 w0.254: v1(92.94,118.23) 92.58,117.86 92.14,117.86 91.67,118.33 88.44,118.33 87.16,119.6 77.7,119.6 76.57,118.47 73.83,118.47 73.57,118.2 71.9,118.2 70.91,119.18 69.16,119.18 v1(68.87,118.89)
  BOTTOM w0.254: v1(92.94,118.23) 92.94,118.28 94.2,119.54 PHV02.1
N48614490: length 49.2
  TOP w0.254: v1(66.56,124.31) 66.56,124.26 66.35,124.05 66.35,122.33 66.9,121.79 PRV07.1 67.01,121.74 67.01,120.99 PRV03.1
  IN3 w0.254: v1(66.56,124.31) 66.56,124.13 66.94,123.76 70.61,123.76 72.13,125.28 72.13,131.34 72.46,131.68 75.78,131.68 77.11,133.01 77.11,133.13 77.11,133.13 77.11,133.47 77.48,133.84 77.83,133.84 79.4,135.41 79.4,138.32 81.29,140.22 87.8,140.22 89.84,138.17 89.84,138.17 90.76,137.26 93.76,137.26 94.94,136.08 94.94,135.58 v1(94.97,135.55)
  BOTTOM w0.254: PLV02.3 94.97,135.53 v1(94.97,135.55)
N48614505: length 1.1
  TOP w0.089: v3(79.41,132.08) 79.21,132.28 PCV08.1
N48614510: length 45.7
  TOP w0.254: v1(67.14,124.45) 67.14,124.09 66.89,123.83 PRV08.1
  IN3 w0.254: v1(95.4,135.95) 95.4,136.11 93.9,137.61 90.9,137.61 89.93,138.58 89.93,138.58 87.94,140.56 81.15,140.56 79.05,138.47 79.05,135.56 77.68,134.19 77.23,134.19 76.76,133.72 76.76,133.16 75.63,132.03 72.32,132.03 71.78,131.49 71.78,125.42 70.52,124.16 67.39,124.16 67.14,124.42 v1(67.14,124.45)
  BOTTOM w0.254: v1(95.4,135.95) PLV02.2
N48614539: length 1.6
  TOP w0.089: v3(72.77,134.59) 72.77,134.15 73.2,133.71 PRV02.1
N48614544: length 4
  TOP w0.089: PRV10.1 72.34,133.71 v3(72.75,133.29)
  TOP w0.203: PUV01.1 71.42,131.44 71.22,131.64 71.22,133.14 PRV10.1
N48614545: length 2.5
  TOP w0.203: PRV09.1 70.32,132.33 70.52,132.13 70.52,131.76 71.24,131.04 PUV01.2
N48614550: length 1.6
  TOP w0.203: PUV01.34 74.78,133.1 74.65,133.23 PRV04.1
N48637343: length 8.4
  TOP w0.089: v3(61.62,114.66) 61.36,114.92 PR7.1
  TOP w0.254: PQ1.2 58.91,119.4 58.68,119.17 58.68,117.56 59.44,116.8 PR4.2 59.85,116.2 PQ2.1 59.53,115.31 59.93,114.92 PR7.1
N48637352: length 4
  TOP w0.254: PQ1.1 57.95,118.28 57.69,118.03 56.87,118.03 PL3.2 56.21,117.91 55.53,117.91 55.47,117.86 PD1.2 55.47,117.04 PR3.1
N48637376: length 3.7
  TOP w0.089: PR35.2 175.01,32.39 v3(175.24,32.15)
  TOP w0.254: PR31.2 174.12,33.09 174.12,33.09 PR35.2 ; PR31.2 173.93,33.31 PQ13.2 ; PR31.2 174.05,33.05 PR45.1
N48637377: length 5.6
  TOP w0.089: v3(171.32,32.92) PR32.2
  TOP w0.254: PR32.2 171.89,34.2 172.91,35.23 173.5,35.23 174.58,34.15 PQ13.3
N48637383: length 3.3
  TOP w0.089: v3(168.22,30.01) 168.22,30.28 168.69,30.76 PR40.1
  TOP w0.254: PQ12.5 169.85,29.9 169.81,29.86 PC13.2 169.15,29.96 PR40.1
N48637390: length 5.2
  TOP w0.089: v3(173.72,31.31) 173.46,31.57 PR36.2
  TOP w0.254: PR36.2 172.81,31.55 172.31,31.05 171.69,31.05 171.41,30.77 171.41,30.17 171.68,29.9 PQ12.2 172.81,29.9 PR44.2
N48637396: length 3.2
  TOP w0.089: v3(175.99,28.57) PQ11.2
  TOP w0.254: PQ11.2 176.08,29.7 176.51,29.26 PC14.2 177.1,30.07 PR43.1
N48637398: length 3.6
  TOP w0.089: PR34.2 174.61,37.71 v3(174.77,37.88)
  TOP w0.254: PR34.2 173.79,37.67 PR38.1 173.79,36.56 173.93,36.43 PQ13.5 PQ13.6
N48637416:
  vias: v1(72.68,143.51) v1(72.68,142.87) v1(72.68,142.24) v1(73.31,143.51) v1(73.31,142.87) v1(73.31,142.24) v1(73.95,143.51) v1(73.95,142.87) v1(74.58,143.51) v1(74.58,142.87) v4(74.65,142.3)
N48637453: length 2.4
  TOP w0.089: PD3.1 61.68,116.1 62.35,115.43 v3(62.72,115.43)
  TOP w0.254: PD3.1 61.28,116.1 61.01,115.83 PR7.2
N48637469: length 2.1
  BOTTOM w0.254: PQ6.1 94.49,146.78 v3(94.7,146.78) 95.3,146.78 PR12.2
N48637473: length 11.7
  TOP w0.089: v1(90.39,143.11) 90.53,143.11 v3(91.09,142.55)
  TOP w0.254: PQ3.4 92.38,144.09 PC5.2 91.95,143.67 PR8.2 90.39,143.18 v1(90.39,143.11)
  IN2 w0.254: v1(90.39,143.11) 93.63,146.35 v1(93.63,147.18)
  BOTTOM w0.254: PR10.1 92.96,148.43 93.63,147.75 v1(93.63,147.18)
N48637478: length 2.4
  BOTTOM w0.089: PR10.2 92.69,149.41 v3(93.55,150.27)
  BOTTOM w0.254: PR10.2 92.1,149.34 91.74,149.7 91.72,149.7 PQ5.1
N48637524: length 9.4
  TOP w0.089: v3(172.22,43.58) 171.52,42.88 PR39.1
  TOP w0.254: PR39.1 171,42.57 v1(170.91,42.48)
  BOTTOM w0.254: v1(170.91,42.48) 170.47,42.03 166.09,42.03 165.01,40.95 PBATT1.5
N48637560: length 6.1
  TOP w0.089: PRS27.2 65.8,122.52 66.47,121.84 v3(66.47,119.9)
  TOP w0.254: PRS27.2 65.75,121.78 PRS26.2 65.3,121.75 64.98,122.07 64.21,122.07 64.02,121.88 PQS10.2
N309648960: length 1.7
  TOP w0.254: PRB26.1 207.71,46.21 v1(207.42,46.5)
  BOTTOM w0.203: PUB01.27 207.4,46.49 v1(207.42,46.5)
