# Allegro board LAF121PR10-1117.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VALW on BOTTOM (solid shape): outline of 106 points within 23.32,108.91 29.43,112.69
+5VALW on BOTTOM (solid shape): outline of 173 points within 60.91,114.48 66.58,120.32
+5VALW on IN1 (solid shape): outline of 440 points within 36.1,94.24 53.09,100.44
+5VALW on IN1 (solid shape): outline of 1134 points within 15.51,23.85 36.04,52.07
+5VALW on IN2 (solid shape): 39.9,100.41 39.9,96.68 39.65,96.43 36.73,96.43 36.36,96.81 36.36,97.21 37.14,97.21 37.15,97.16 37.16,97.11 37.18,97.06 37.2,97.01 37.24,96.97 37.28,96.93 37.32,96.9 37.37,96.88 37.42,96.87 37.47,96.86 37.53,96.86 37.58,96.87 37.63,96.88 37.68,96.9 37.72,96.93 37.76,96.97 37.79,97.01 37.82,97.06 37.84,97.11 37.85,97.16 37.86,97.21 37.85,97.27 37.84,97.32 37.82,97.37 37.79,97.41 37.76,97.46 37.72,97.49 37.68,97.52 37.63,97.55 37.58,97.56 37.53,97.57 37.47,97.57 37.42,97.56 37.37,97.55 37.32,97.52 37.28,97.49 37.24,97.46 37.2,97.41 37.18,97.37 37.16,97.32 37.15,97.27 37.14,97.21 36.36,97.21 36.36,100.36 36.61,100.62 39.7,100.62
+5VALW on IN2 (solid shape): outline of 507 points within 26.41,111.94 33.18,129.85
+5VALW on IN2 (solid shape): outline of 894 points within 173.08,36.61 202.19,46.25
+5VALW on IN3 (solid shape): outline of 322 points within 33.82,24.36 43.74,31.56
+5VALW on IN3 (solid shape): outline of 377 points within 51.95,95.33 63.93,120.34
+5VALW on IN3 (solid shape): outline of 626 points within 64.91,110.05 94.63,118.34
+5VALW on IN3 (solid shape): outline of 3125 points within 131.85,42.44 174.89,115.5
+5VALW on VCC: 41.29,29.01 35.09,35.22 35.09,37.88 31.66,41.31 31.66,56.55 27.29,60.92 27.29,107.99 26.2,109.08 26.2,112.92 26.75,113.47 37.14,113.47 37.56,113.05 37.56,102.89 39.15,101.3 39.15,97.7 37.56,96.11 37.56,86.89 38.2,86.25 38.2,76.09 39.66,74.63 39.66,73.44 37.5,71.28 37.5,57.99 42.98,52.51 41.82,51.35 41.82,33.23 42.6,32.44 46.49,32.44 46.49,29.01
+5VALWP on TOP (solid shape): 29.12,108.33 29.12,106.5 28.91,106.29 21.69,106.29 21.62,106.36 21.62,108.39 21.72,108.49 28.96,108.49
+5VALWP on BOTTOM (solid shape): 24.17,109.27 24.17,108.76 24.67,108.76 24.67,109.28 24.97,109.28 24.97,108.76 25.86,108.76 25.89,108.79 27.74,108.79 27.74,109.28 28.03,109.28 28.03,108.79 28.54,108.79 28.54,109.28 28.83,109.28 28.83,108.79 28.99,108.79 28.99,106.93 28.29,106.23 23.78,106.23 23.12,105.56 23.12,104.61 21.97,103.47 19.06,103.47 18.77,103.62 18.49,103.47 17.08,103.47 16.73,103.82 16.73,104.41 16.93,104.66 16.86,104.96 16.83,105.03 16.86,105.09 16.93,105.4 16.73,105.64 16.73,107.63 17.13,108.03 17.17,108.01 19.69,107.53 21.95,108.76 23.87,108.76 23.87,109.27 23.89,109.29 24.15,109.29
+5VS on TOP (solid shape): 39.14,8.16 39.14,6.92 38.88,6.66 37.49,6.66 37.41,6.74 37.41,8.25 37.47,8.31 38.98,8.31
+5VS on TOP (solid shape): 193.52,66.59 193.52,64.49 193.39,64.37 191.87,64.37 191.55,64.68 191.55,65.11 191.49,65.18 191.49,66.53 191.68,66.72 193.39,66.72
+5VS on TOP (solid shape): 17.07,106.02 17.07,103.43 16.95,103.31 14.51,103.31 14.32,103.5 14.32,105.41 14.33,105.41 14.33,105.75 14.67,106.09 17,106.09
+5VS on TOP (solid shape): 180.45,69.5 180.45,69.29 180,68.84 180.1,68.74 180.1,68.57 180.08,68.55 180.08,68.02 180,67.95 178.44,67.95 178.31,68.07 178.31,70.01 178.46,70.16 179.79,70.16
+5VS on TOP (solid shape): 218.2,31.35 218.2,30.27 216.99,29.06 215.89,29.06 215.72,29.23 215.72,30.17 215.74,30.19 216.62,30.19 216.86,30.43 217.13,30.65 217.08,31 217.08,31.32 217.18,31.42 218.12,31.42
+5VS on TOP (solid shape): 48.18,106.26 48.52,105.99 48.87,106.26 48.88,106.29 51.88,106.29 52.33,105.85 52.33,102.77 51.98,102.42 47.95,102.42 47.95,102.43 47.17,102.43 47.17,102.42 46.68,102.42 46.68,102.43 45.97,102.43 45.97,102.42 45.48,102.42 45.48,102.43 44.7,102.43 44.7,102.42 42.25,102.42 42.25,102.43 41.67,102.43 41.67,102.42 41.37,102.42 41.37,102.43 40.87,102.43 40.87,102.42 40.57,102.42 40.57,102.43 39.99,102.43 39.99,102.42 38.77,102.42 38.26,102.93 38.26,105.53 39.02,106.29 48.17,106.29
+5VS on TOP (solid shape): outline of 118 points within 188.49,40.25 192.65,43.03
+5VS on TOP (solid shape): outline of 116 points within 51.22,29.04 93.13,39.3
+5VS on BOTTOM (solid shape): 181.16,68.29 181.16,67.97 180.92,67.73 178.62,67.73 178.47,67.88 178.47,69.04 178.53,69.1 180.34,69.1
+5VS on BOTTOM (solid shape): outline of 142 points within 213.39,33.78 224.39,40.95
+5VS on IN1 (solid shape): outline of 336 points within 178.43,59.76 193.91,68.75
+5VS on IN1 (solid shape): outline of 529 points within 16.11,102.36 40.29,107.03
+5VS on IN3 (solid shape): 224.31,34.9 224.31,33.92 224.18,33.79 223.43,33.79 222.9,33.26 222.9,31.41 219.96,28.47 215.25,28.47 215.09,28.62 215.09,29.57 219.14,29.57 219.15,29.52 219.16,29.47 219.18,29.42 219.2,29.37 219.24,29.33 219.28,29.29 219.32,29.26 219.37,29.24 219.42,29.23 219.47,29.22 219.53,29.22 219.58,29.23 219.63,29.24 219.68,29.26 219.72,29.29 219.76,29.33 219.79,29.37 219.82,29.42 219.84,29.47 219.85,29.52 219.86,29.57 219.85,29.63 219.84,29.68 219.82,29.73 219.79,29.77 219.76,29.82 219.72,29.85 219.68,29.88 219.63,29.91 219.58,29.92 219.53,29.93 219.47,29.93 219.42,29.92 219.37,29.91 219.32,29.88 219.28,29.85 219.24,29.82 219.2,29.77 219.18,29.73 219.16,29.68 219.15,29.63 219.14,29.57 215.09,29.57 215.09,30.01 215.24,30.16 219.92,30.16 221.75,31.99 221.75,33.6 223.14,34.99 224.22,34.99
+5VS on IN3 (solid shape): outline of 1428 points within 191.27,39.2 215.87,62.33
+5VS on VCC: outline of 131 points within 38.01,27.62 216.89,153.48 ; 1 cut-out
+5VS on IN3: 41.56,27.62 41.01,27.06 40.98,27.07 40.6,26.99 40.52,26.62 40.53,26.59 39.02,25.08 39.02,24 37.42,22.4 37.42,16.8 37.83,16.39 37.83,8.59 38.07,8.35 38.77,8.35 39.07,8.05 39.07,7.17 38.83,6.93 36.39,6.93 36.06,7.26 36.06,14.89 34.53,16.43 34.53,21.66 37.09,24.23 37.11,24.23 37.39,24.47 37.31,24.83 37.31,25.97 39.17,27.83 39.2,27.83 39.4,27.88 39.54,28.04 39.6,28.09 39.68,28.08 40.41,28 40.9,28.53 40.91,28.57 43.73,28.57 44.15,28.43 44.38,28.82 44.37,28.84 46.33,30.79 48.23,30.79 48.42,30.6 48.42,29.78 48.17,29.52 46.96,29.52 45.06,27.62 43.15,27.62 42.9,27.72 42.65,27.62 42.51,27.62 42.26,27.72 42.01,27.62
+5VS_KBL on TOP (solid shape): 95.67,36.83 95.67,35.92 96.14,35.45 96.63,35.45 96.7,35.38 96.7,33.72 96.44,33.46 93.89,33.46 93.57,33.78 93.57,36.95 93.7,37.08 95.41,37.08
+5VS_KBL on BOTTOM (solid shape): 96.88,35.05 96.88,33.84 96.8,33.76 94.86,33.76 94.76,33.85 94.76,35.16 94.84,35.23 96.7,35.23
+5VS_ODD on TOP (solid shape): 195.87,66.39 195.87,64.17 196.47,63.57 196.47,62.6 196.21,62.34 195.7,62.34 195.7,62.34 195.59,62.34 195.59,62.34 194.75,62.34 194.75,62.11 194.64,62 194.64,61.77 194.46,61.58 193.84,61.58 193.71,61.72 193.71,64.88 194.28,64.88 194.28,65.45 193.71,65.45 193.71,65.7 194.28,65.7 194.28,66.27 193.71,66.27 193.71,66.59 193.84,66.72 194.59,66.72
+5VS_ODD on BOTTOM (solid shape): 195.31,67.57 195.31,66.58 195.75,66.14 195.75,63.72 195.45,63.42 192.97,63.42 192.78,63.61 192.78,65.02 192.82,65.1 192.9,65.12 193.26,65.31 193.2,65.72 193.17,65.79 193.2,65.86 193.26,66.27 192.9,66.46 192.82,66.48 192.78,66.56 192.78,67.57 192.99,67.78 195.1,67.78
+17.4V_BATT+ on BOTTOM (solid shape): 147.85,36.06 148.43,36.06 148.43,36.06 148.72,36.06 148.72,36.06 149.23,36.06 149.23,36.06 149.52,36.06 149.52,36.06 150.1,36.06 150.1,36.06 150.66,36.06 150.91,35.81 150.91,32 150.4,31.49 147.8,31.49 147.48,31.81 147.48,33.27 147.16,33.59 146.45,33.59 146.27,33.76 146.26,33.79 146.23,33.82 146.21,33.84 146.21,34.59 146.74,34.59 146.74,34.54 146.75,34.49 146.77,34.43 146.79,34.39 146.82,34.34 146.86,34.3 146.9,34.27 146.95,34.24 146.99,34.22 147.05,34.21 147.1,34.21 147.15,34.21 147.21,34.22 147.25,34.24 147.3,34.27 147.34,34.3 147.38,34.34 147.41,34.39 147.43,34.43 147.45,34.49 147.46,34.54 147.46,34.59 147.45,34.64 147.43,34.7 147.41,34.74 147.38,34.79 147.34,34.83 147.3,34.86 147.25,34.89 147.21,34.91 147.15,34.92 147.1,34.92 147.05,34.92 146.99,34.91 146.95,34.89 146.9,34.86 146.86,34.83 146.82,34.79 146.79,34.74 146.77,34.7 146.75,34.64 146.74,34.59 146.21,34.59 146.21,35.43 146.85,36.06 147.85,36.06
+17.4V_BATT++ on BOTTOM (solid shape): outline of 88 points within 147.29,36.25 159.33,41.91
+19V_ADPIN on TOP (solid shape): 88.16,144.25 88.71,144.25 88.71,144.82 88.97,144.82 88.97,144.25 89.86,144.25 89.92,144.2 89.92,141.94 89.73,141.76 89.73,140.51 89.56,140.33 83.85,140.33 83.19,141 83.19,141.88 83.27,141.96 85.91,141.96 86.4,142.44 86.4,143.68 86.98,144.26 87.9,144.26 87.9,144.82 88.16,144.82
+19V_ADPIN on BOTTOM (solid shape): outline of 89 points within 81.83,140.89 86.11,145.14
+19VB on TOP (solid shape): 180.15,26.86 180.15,24.99 180.14,24.98 180.14,24.59 180.02,24.47 175.92,24.47 175.79,24.6 175.79,26.43 175.91,26.56 177.13,26.56 177.53,26.96 180.04,26.96
+19VB on TOP (solid shape): 186.98,44.99 186.98,41.86 186.43,41.31 184.99,41.31 184.57,40.88 180.41,40.88 179.97,41.32 179.97,46.07 180.42,46.52 185.45,46.52
+19VB on TOP (solid shape): 53.67,25.58 53.67,23.9 53.28,23.52 47.97,23.52 47.74,23.76 47.74,24.94 48.19,25.4 48.19,25.48 48.37,25.66 48.66,25.66 48.79,25.54 48.79,25.23 48.8,25.22 49.24,25.22 49.26,25.25 49.26,25.54 49.45,25.73 53.52,25.73
+19VB on TOP (solid shape): 201.3,66.61 201.3,59.15 201.52,58.94 201.52,58.8 201.66,58.8 201.79,58.67 203.49,58.67 204.13,58.04 204.13,56.32 204.13,56.31 204.13,56.09 204.85,55.37 208.7,55.37 208.73,55.36 208.83,55.26 208.83,54.79 208.83,54.78 208.8,54.61 208.83,54.43 208.83,54.42 208.83,53.94 208.73,53.65 208.83,53.35 208.73,53.06 208.83,52.76 208.83,52.15 208.75,51.93 208.78,51.7 208.79,51.67 208.74,51.62 207.04,51.62 206.85,51.66 206.66,51.62 206.19,51.62 205.95,51.73 205.68,51.69 205.6,51.77 205.6,51.99 205.62,52.01 205.62,52.31 205.6,52.33 205.6,52.87 205.46,53.02 203.87,53.02 202.86,54.03 202.86,56.67 202.26,57.26 199.5,57.26 198.9,57.86 198.9,66.71 199.25,67.05 200.86,67.05
+19VB on BOTTOM (solid shape): 168.25,96.64 168.25,94.67 168.06,94.48 166.09,94.48 165.9,94.67 165.9,96.58 166.15,96.83 168.06,96.83
+19VB on BOTTOM (solid shape): 174.34,78.57 174.34,76.32 173.83,75.81 170.91,75.81 170.02,76.7 170.02,77.5 172.56,80.04 172.87,80.04
+19VB on BOTTOM (solid shape): 91.12,141.7 91.12,138.7 90.9,138.49 88.74,138.49 88.49,138.74 88.49,141.61 88.6,141.68 88.67,141.79 91.03,141.79
+19VB on BOTTOM (solid shape): 170.71,51.41 170.71,50.38 170.52,50.19 168.49,50.19 168.48,50.2 168.42,50.2 168.42,50.45 167.94,50.45 167.94,50.2 167.53,50.2 167.4,50.33 167.4,51.3 167.56,51.46 170.65,51.46
+19VB on BOTTOM (solid shape): 208.44,55.22 208.44,53.72 207.98,53.25 205.42,53.25 205.33,53.34 205.33,54.79 205.38,54.84 205.38,54.84 205.5,54.96 207.15,54.96 207.53,55.34 208.32,55.34
+19VB on BOTTOM (solid shape): 17.52,38.18 18.45,38.18 18.45,37.71 18.96,37.71 18.96,38.22 19.47,38.22 19.53,38.16 19.53,36.76 19.47,36.7 17.69,36.7 16.61,35.62 16.1,35.62 15.82,35.9 15.82,38.37 16.02,38.58 17.13,38.58
+19VB on BOTTOM (solid shape): 31.55,104.11 31.55,100.7 31.48,100.63 29.94,100.63 29.87,100.7 29.87,102.1 29.29,102.67 26.58,102.67 26.45,102.8 26.45,104.14 26.58,104.26 31.4,104.26
+19VB on BOTTOM (solid shape): 136.18,113.16 136.18,111.42 135.87,111.07 136,110.63 135.97,110.6 135.56,110.6 135.48,110.68 135.48,111.06 135.42,111.12 134.89,111.12 134.81,111.04 134.81,110.55 134.35,110.55 134.2,110.7 134.2,113.22 134.58,113.6 135.75,113.6
+19VB on BOTTOM (solid shape): outline of 451 points within 174.43,25.1 195.74,47.38
+19VB on IN1 (solid shape): 170.89,51.47 170.89,49.26 170.8,49.17 168.73,49.17 168.51,49.39 168.51,51.43 168.73,51.65 170.71,51.65
+19VB on IN1 (solid shape): 185.53,45.5 185.53,42.07 185.35,41.89 182.38,41.89 182.18,42.1 182.18,45.6 182.72,46.15 184.88,46.15
+19VB on IN1 (solid shape): 135.38,113.58 137.1,113.58 137.29,113.39 137.29,112.31 137.1,112.12 134.65,112.12 134.52,112.25 134.52,112.25 134.22,112.55 134.22,113.11 134.7,113.6 135.37,113.6
+19VB on IN1 (solid shape): 201.3,66.61 201.3,59.15 201.79,58.67 203.49,58.67 204.13,58.04 204.13,56.32 204.13,56.31 204.13,56.09 204.85,55.37 208.36,55.37 208.51,55.22 208.51,53.6 207.93,53.02 203.87,53.02 202.86,54.03 202.86,56.67 202.26,57.26 199.5,57.26 198.9,57.86 198.9,66.71 199.25,67.05 200.86,67.05
+19VB on IN1 (solid shape): outline of 233 points within 161.32,108.67 170.07,117.72
+19VB on IN1 (solid shape): outline of 1296 points within 86.55,139.46 135.13,154.17
+19VB on IN2 (solid shape): 180.15,26.86 180.15,24.57 179.99,24.42 175.83,24.42 175.8,24.45 175.8,26.4 175.92,26.52 177.09,26.52 177.53,26.96 180.04,26.96
+19VB on IN2 (solid shape): outline of 1845 points within 184.01,39.46 208.8,55.37
+19VB on IN2 (solid shape): outline of 3952 points within 15.85,23.17 53.56,106.23
+19VB on IN3 (solid shape): outline of 1936 points within 160.82,63.62 202.28,118.74
+19VB on GND1: 163.97,103.25 161.58,105.64 161.58,114.57 165.83,118.83 165.83,150.53 164.73,151.63 133.79,151.63 129.28,147.12 120.34,147.12 116.6,150.87 108.55,150.87 104.68,147 93.5,147 92.44,145.93 92.44,140.07 91.24,138.87 87.31,138.87 86.57,139.61 86.57,150.5 86.62,150.55 86.62,150.7 87.4,150.7 88.15,150.96 88.58,151.63 89.02,153.58 89.3,154.02 89.8,154.2 97.3,154.2 97.3,152.3 100.7,152.3 100.7,154.2 102.8,154.2 102.8,153.4 103,152.9 103.5,152.7 104.5,152.7 105,152.9 105.2,153.4 105.2,154.2 112.84,154.2 113.3,154.29 113.69,154.55 114.43,155.3 120.5,155.3 120.5,154 120.7,153.5 121.2,153.3 122.2,153.3 122.7,153.5 122.9,154 122.9,155.3 129.94,155.3 130.37,154.93 130.92,154.8 137.43,154.8 137.98,154.93 138.41,155.3 157.57,155.3 158,154.93 158.55,154.8 167,154.8 167.21,154.71 167.3,154.5 167.3,153.5 167.5,153 168,152.8 169,152.8 169.21,152.71 169.3,152.5 169.3,140.89 170.69,119.04 170.7,118.83 171.12,112.21 171.12,112.2 169.05,112.2 166.35,109.5 169.05,106.8 171.47,106.8 171.69,103.25
+19VB_1.2V on TOP (solid shape): 46.27,28.38 46.58,28.18 46.91,28.37 46.92,28.35 47.58,28.35 47.81,28.13 49.54,28.13 49.92,27.74 49.92,26.09 49.75,25.92 49.13,25.92 49.12,25.91 49.12,25.38 49.11,25.37 48.93,25.37 48.93,25.37 48.93,25.91 48.92,25.92 48.53,25.92 48.52,25.93 48.52,26.03 48.5,26.04 48.49,26.04 47.13,26.04 46.95,26.22 46.39,26.22 46.21,26.04 44.38,26.04 43.79,25.46 41.55,25.46 41.54,25.46 41.23,25.46 41.13,25.56 41.13,26.52 41.21,26.74 41.13,26.96 41.13,26.99 41.55,27.4 41.55,27.41 41.6,27.47 41.6,28.27 41.69,28.35 44.76,28.35 44.79,28.38
+19VB_1.2V on BOTTOM (solid shape): 46.38,29.27 46.38,28.82 46.36,28.81 46.33,28.77 46.29,28.73 46.27,28.68 46.25,28.63 46.24,28.58 46.24,28.53 46.24,28.48 46.25,28.43 46.27,28.38 46.29,28.34 46.33,28.29 46.36,28.26 46.38,28.24 46.38,27.11 46.29,27.01 43.57,27.01 43.39,26.83 43.39,25.43 43.26,25.31 41.78,25.31 41.55,25.53 41.55,28.26 41.75,28.46 43.19,28.46 43.37,28.63 43.37,28.89 43.62,28.89 43.62,27.9 43.77,27.74 43.92,27.74 43.96,27.73 44.02,27.71 44.08,27.71 44.13,27.71 44.19,27.73 44.27,27.77 44.31,27.8 44.35,27.84 44.38,27.88 44.41,27.93 44.42,27.98 44.43,28.04 44.43,28.15 44.42,28.2 44.4,28.26 44.38,28.3 44.38,28.92 44.23,29.07 44.21,29.07 44.18,29.08 44.13,29.1 44.08,29.11 44.03,29.12 43.98,29.11 43.93,29.1 43.88,29.08 43.84,29.07 43.8,29.07 43.62,28.89 43.37,28.89 43.37,29.3 43.44,29.37 46.29,29.37
+19VB_+1.35VGPU on TOP (solid shape): 140.58,109.76 140.58,108.54 140.37,108.33 138.91,108.33 138.7,108.54 138.7,109.77 138.83,109.9 140.44,109.9
+19VB_+1.35VGPU on BOTTOM (solid shape): 140.62,109.72 140.62,109.13 140.94,108.82 143.24,108.82 143.35,108.71 143.35,108.58 143.27,108.5 140.62,108.5 140.38,108.25 139.03,108.25 138.72,107.95 136.37,107.95 135.96,108.35 134.08,108.35 133.99,108.45 133.99,109.19 137.27,109.19 137.27,109.14 137.28,109.08 137.3,109.04 137.33,108.99 137.36,108.95 137.4,108.91 137.45,108.88 137.5,108.86 137.55,108.84 137.6,108.83 137.65,108.83 137.71,108.84 137.76,108.86 137.8,108.88 137.85,108.91 137.89,108.95 137.92,108.99 137.95,109.04 137.97,109.08 137.98,109.14 137.98,109.19 137.98,109.24 137.97,109.3 137.95,109.34 137.92,109.39 137.89,109.43 137.85,109.47 137.8,109.5 137.76,109.52 137.71,109.54 137.65,109.55 137.6,109.55 137.55,109.54 137.5,109.52 137.45,109.5 137.4,109.47 137.36,109.43 137.33,109.39 137.3,109.34 137.28,109.3 137.27,109.24 137.27,109.19 133.99,109.19 133.99,110.14 134.21,110.36 139.99,110.36
+19VB_+VDDP on TOP (solid shape): 165.17,50.48 165.17,50.09 165.4,49.85 165.4,48.5 164.98,48.08 163.77,48.08 163.6,48.25 162.94,48.25 162.7,48.5 162.7,50.53 162.77,50.6 165.05,50.6
+19VB_+VDDP on BOTTOM (solid shape): 165.21,50.54 165.21,50.11 165.42,49.9 167.02,49.9 167.18,49.74 168.91,49.74 168.93,49.73 168.93,48.41 168.92,48.39 168.53,48.58 168.25,48.27 165.04,48.27 164.61,47.83 164.61,47.56 164.6,47.52 164.6,47.47 164.6,46.89 164.6,46.85 164.61,46.81 164.61,45.34 164.51,45.24 164.23,45.24 164.16,45.31 164.16,47.47 163.55,48.08 163.55,50.5 163.65,50.6 165.15,50.6
+19VB_APU on TOP (solid shape): outline of 118 points within 150.81,64.96 168.74,78.35
+19VB_APU on BOTTOM (solid shape): outline of 262 points within 150.66,64.7 172.31,84.92
+19VB_NB on TOP (solid shape): 165.28,98.44 166.9,98.44 166.98,98.37 166.98,97.06 166.83,97.04 166.7,96.98 163.6,96.98 163.49,97.09 163.49,98.45 163.62,98.58 165.14,98.58
+19VB_NB on BOTTOM (solid shape): 168.74,98.92 168.74,97.86 168.52,97.64 166.27,97.64 165.69,97.06 165.69,96.25 165.21,96.25 165.21,95.8 165.69,95.8 165.69,95.45 165.21,95.45 165.21,94.99 165.69,94.99 165.69,94.62 165.44,94.37 161.3,94.37 160.28,95.39 158.68,95.39 158.43,95.64 158.43,96.46 162.09,96.46 162.09,95.69 162.55,95.22 163.58,95.22 163.75,95.39 163.75,96.33 164.12,96.33 164.12,96.27 164.13,96.22 164.14,96.17 164.16,96.12 164.19,96.08 164.23,96.04 164.27,96 164.32,95.98 164.37,95.96 164.42,95.95 164.47,95.94 164.53,95.95 164.58,95.96 164.63,95.98 164.67,96 164.72,96.04 164.75,96.08 164.78,96.12 164.81,96.17 164.82,96.22 164.83,96.27 164.83,96.33 164.82,96.38 164.81,96.43 164.78,96.48 164.75,96.52 164.72,96.56 164.67,96.59 164.63,96.62 164.58,96.64 164.53,96.65 164.47,96.66 164.42,96.65 164.37,96.64 164.32,96.62 164.27,96.59 164.23,96.56 164.19,96.52 164.16,96.48 164.14,96.43 164.13,96.38 164.12,96.33 163.75,96.33 163.75,96.44 163.54,96.65 162.27,96.65 162.09,96.46 158.43,96.46 158.43,97.62 158.73,97.93 162.8,97.93 163.86,98.99 168.67,98.99
+19VB_VGA on TOP (solid shape): outline of 86 points within 80.95,121.17 89.49,125.83
+19VB_VGA on TOP (solid shape): outline of 153 points within 80.1,134.26 89.16,138.57
+19VB_VGA on BOTTOM (solid shape): 84.73,125.28 84.73,124.73 85.1,124.37 88.96,124.37 89.19,124.14 89.19,123.57 89.02,123.4 88.79,123.4 88.32,122.93 88.32,122.31 87.85,121.84 84.32,121.84 84.28,121.85 84.24,121.87 84.2,121.92 84.21,121.95 84.23,122.15 84.12,122.33 84.11,122.37 84.12,122.4 84.14,122.42 84.17,122.43 84.21,122.42 84.82,122.65 84.24,122.94 84.17,122.92 84.11,122.94 83.63,122.91 83.61,122.43 83.63,122.37 83.61,122.3 83.53,122.14 83.54,121.97 83.52,121.88 83.44,121.84 81.49,121.84 81.47,121.86 81.47,123.78 80.98,124.26 80.98,125.59 81.23,125.83 84.18,125.83
+19VB_VGA on BOTTOM (solid shape): outline of 199 points within 81.09,134.16 89.36,141.74
+19VB_VGA on IN2 (solid shape): outline of 753 points within 78.27,123.48 88.3,140.14
+VBUS_DC_SS on TOP (solid shape): outline of 219 points within 55.23,132.58 62.84,140.27
+VBUS_DC_SS on BOTTOM (solid shape): 207.27,57.04 207.27,55.82 207.01,55.57 205.19,55.57 205.05,55.71 205.05,56.99 205.18,57.12 207.18,57.12
+VBUS_DC_SS on IN2 (solid shape): 205.03,57.65 205.78,56.9 205.78,56.47 205.35,56.05 204.78,56.05 204.12,56.7 204.12,56.87 204.9,57.65
+VCC_TPM on TOP (solid shape): outline of 377 points within 99.03,31.86 108.61,41.84
+VCC_TPM on BOTTOM (solid shape): 109.29,34.63 109.29,32.49 109.22,32.42 108.52,32.42 108.41,32.53 108.41,33.68 107.98,34.11 107.41,34.11 107.29,34.23 107.29,34.77 107.47,34.95 108.97,34.95
+VDD_CT on IN2 (solid shape): outline of 282 points within 112.21,135.17 120.08,137.84
+VDD_TOUCH on TOP (solid shape): outline of 126 points within 206.06,36.18 211.98,40.86
+VDD_TOUCH on BOTTOM (solid shape): 213.2,41.03 213.2,38.11 213.06,37.97 210.56,37.97 210.48,38.05 210.48,39.22 210.61,39.34 211.53,39.34 211.55,39.32 211.76,39.53 211.76,40.94 211.93,41.11 213.12,41.11
+VDDP_ALWP on TOP (solid shape): 157.01,48 157.01,43.11 158.07,42.05 158.07,38.91 158.03,38.83 157.95,38.81 157.5,38.46 157.95,38.12 158.03,38.1 158.07,38.02 158.07,34.63 157.67,34.22 155.86,34.22 155.67,34.41 155.67,35.11 155.1,35.11 155.1,35.56 155.67,35.56 155.67,36.32 155.1,36.32 155.1,36.76 155.67,36.76 155.67,37.46 155.93,37.72 155.93,39.61 155.82,39.72 155.82,42.51 155.48,42.86 155.48,47.87 155.8,48.19 156.82,48.19
+VDDP_ALWP on BOTTOM (solid shape): 154.45,47.7 154.72,47.58 154.99,47.7 156.3,47.7 156.5,47.5 156.5,42.69 156.4,42.59 155.51,42.59 155.42,42.69 155.42,43.37 155.18,43.6 153.24,43.6 153.14,43.7 153.14,47.48 153.36,47.7
+VDDR3 on TOP (solid shape): 120.26,134.9 120.26,133.46 119.9,133.1 119.36,133.1 119.18,133.29 119.18,133.32 119.08,133.61 118.78,133.71 118.76,133.71 118.02,134.45 118.02,134.63 118.12,134.74 118.34,134.74 118.71,134.36 119.36,134.36 119.54,134.54 119.54,134.9 119.63,134.99 120.17,134.99
GND on TOP (solid shape): 10.75,127 3.85,127 3.85,134.1 10.75,134.1
GND on TOP (solid shape): 88.39,49.64 80.39,49.64 80.39,57.64 88.39,57.64
GND on TOP (solid shape): 100.8,94.96 85.8,94.96 85.8,104.96 100.8,104.96
GND on TOP (solid shape): 100.86,49.7 92.86,49.7 92.86,57.7 100.86,57.7
GND on TOP (solid shape): 51.9,33.13 51.9,32.39 51.85,32.33 48.3,32.33 48.16,32.47 48.16,33.55 48.2,33.58 51.45,33.58
GND on TOP (solid shape): 57.77,123.99 57.77,122.93 57.63,122.79 56.36,122.79 56.18,122.97 56.18,123.99 56.26,124.06 57.69,124.06
GND on TOP (solid shape): 121.67,120.01 121.67,119.06 121.59,118.97 119.39,118.97 119.24,119.12 119.24,119.86 119.44,120.06 121.62,120.06
GND on TOP (solid shape): 143.4,107.91 143.4,106.73 143.24,106.56 139.07,106.56 138.93,106.7 138.93,108.02 139.02,108.11 143.2,108.11
GND on TOP (solid shape): 154.18,106.46 154.18,100.66 154.02,100.51 151.45,100.51 151.13,100.82 151.13,106.51 151.38,106.76 153.88,106.76
GND on TOP (solid shape): 156.4,108.09 156.4,107.04 156.24,106.88 153.99,106.88 153.68,107.19 153.68,108.03 153.88,108.24 156.26,108.24
GND on TOP (solid shape): 157.72,102.19 157.72,101.33 157.56,101.18 156.55,101.18 156.45,101.28 156.45,102.19 156.55,102.29 157.62,102.29
GND on TOP (solid shape): 202.73,56.54 202.73,53.49 202.62,53.38 201.46,53.38 201.27,53.57 201.27,56.49 201.46,56.68 202.58,56.68
GND on TOP (solid shape): 37.7,29.57 37.7,28.05 37.57,27.92 36.05,27.92 35.98,27.98 35.98,29.63 36.05,29.7 37.57,29.7
GND on TOP (solid shape): 89.7,139.89 89.7,139.16 89.24,138.7 84.41,138.7 84.15,138.97 84.15,139.55 84.59,139.99 89.59,139.99
GND on TOP (solid shape): 159.17,47.94 159.17,43.09 158.98,42.91 157.54,42.91 157.31,43.14 157.31,47.94 157.58,48.22 158.89,48.22
GND on TOP (solid shape): 166.95,100.83 166.95,98.64 166.91,98.6 165.39,98.6 164.64,99.35 163.63,99.35 163.52,99.46 163.52,100.85 163.7,101.04 166.74,101.04
GND on TOP (solid shape): 168.79,64.96 168.79,63.09 168.66,62.96 167.43,62.96 167.27,63.13 167.27,64.91 167.42,65.06 168.69,65.06
GND on TOP (solid shape): 176.85,45.9 176.85,45.63 176.02,44.8 175.55,44.8 174.96,45.39 174.96,45.73 175.85,46.62 176.13,46.62
GND on TOP (solid shape): 184.18,49.28 184.18,47.37 183.99,47.18 180.95,47.18 180.76,47.37 180.76,49.15 181.03,49.42 184.04,49.42
GND on TOP (solid shape): 43.09,29.72 43.09,28.66 43.06,28.63 41.69,28.63 41.56,28.76 41.56,29.17 41.92,29.52 41.92,29.71 41.97,29.77 43.04,29.77
GND on TOP (solid shape): 118.34,123.62 118.34,122.04 118.23,121.93 118.23,121.32 118.14,121.23 116.73,121.23 115.69,122.27 115.69,122.55 117.53,124.39 117.57,124.39
GND on TOP (solid shape): 154.67,113.37 154.67,112.53 154.59,112.45 152.75,112.45 152.56,112.64 152.56,113.47 152.64,113.55 154.49,113.55
GND on TOP (solid shape): 24.12,117.87 24.12,116.17 24.05,116.09 23.22,116.09 23.09,116.23 23.09,117.03 22.8,117.32 19.32,117.32 19.19,117.45 19.19,117.88 19.29,117.98 24.01,117.98
GND on TOP (solid shape): 37.37,27.64 37.37,26.86 38.69,25.54 38.69,24.67 38.54,24.52 38.31,24.52 38.21,24.62 38.21,25.41 37.09,26.53 37.09,27.59 37.19,27.69 37.32,27.69
GND on TOP (solid shape): 172.42,58.48 172.42,54.51 172.29,54.37 171.32,54.37 171.24,54.45 171.24,56.33 170.67,56.89 170.34,56.89 169.4,57.83 169.4,58.67 169.52,58.79 172.11,58.79
GND on TOP (solid shape): 11.1,108.9 4.05,108.9 4.05,114.8 4,115.07 3.85,115.29 3.85,115.65 11.1,115.65
GND on TOP (solid shape): 29.73,53.4 29.73,50.2 29.56,50.03 28.39,50.03 28.18,50.25 28.18,53.14 28.58,53.55 29.57,53.55
GND on TOP (solid shape): 153.25,150.91 153.25,149.91 153.18,149.84 148.25,149.84 148,149.59 140.19,149.59 140.16,149.56 137.85,149.56 137.83,149.54 137.64,149.73 137.64,150.62 138.01,150.99 153.17,150.99
GND on TOP (solid shape): 145.04,103.49 145.04,99.71 145.37,99.38 148.54,99.38 148.79,99.13 148.79,98.48 148.64,98.33 143.33,98.33 143.22,98.44 143.22,103.46 143.39,103.63 144.9,103.63
GND on TOP (solid shape): 28,105.86 28,104.68 27.87,104.55 21.72,104.55 21.69,104.58 21.69,106.04 21.73,106.08 27.78,106.08
GND on TOP (solid shape): 38.85,125.4 38.85,121.14 38.67,120.97 35.49,120.97 35.4,120.87 35.4,119.62 35.2,119.42 34.63,119.42 34.47,119.57 34.47,120.24 33.77,120.94 33.77,125.4 33.95,125.59 38.66,125.59
GND on TOP (solid shape): 157.2,33.27 157.2,32.32 156.94,32.06 154.47,32.06 154.09,31.68 154.09,30.16 154.28,29.97 154.28,28.95 154.09,28.76 151.35,28.76 148.12,32 148.12,33.46 148.18,33.52 156.94,33.52
GND on TOP (solid shape): 38.9,35.76 38.9,35.01 38.72,34.83 37.5,34.83 37.12,34.45 37.12,32.75 37.07,32.7 35.62,32.7 35.47,32.85 35.47,33.79 35.28,33.98 34.25,33.98 33.92,34.31 33.92,35.66 34.13,35.87 38.79,35.87
GND on TOP (solid shape): 102.38,38.73 103.44,38.73 103.65,38.51 103.65,37.93 103.74,37.84 104.41,37.84 104.62,37.63 104.62,34.48 104.43,34.29 101,34.29 100.87,34.41 100.87,39.37 101.06,39.56 101.56,39.56
GND on TOP (solid shape): 165.19,51.55 165.79,51.55 165.97,51.37 165.97,50.18 165.83,50.04 165.48,50.04 165.35,50.18 165.35,50.6 165.21,50.73 162.67,50.73 162.46,50.52 162.46,48.43 162.2,48.16 160.69,48.16 160.51,48.33 160.51,49.74 162.32,51.55 165.18,51.55
GND on TOP (solid shape): 115.33,128.48 116.02,128.48 116.12,128.38 116.12,127.56 113.12,124.56 112.82,124.56 112.45,124.93 112.45,125.1 112.11,125.44 111.38,125.44 111.2,125.61 111.2,126.29 111.23,126.32 112.75,126.32 113.5,127.06 113.97,127.06 114.51,127.6 114.51,128.79 114.69,128.97 114.84,128.97
GND on TOP (solid shape): 127.02,138.11 127.02,137.73 127.32,137.42 127.44,137.42 127.71,137.15 127.71,135.89 127.54,135.71 126.64,135.71 126.37,135.44 125.83,135.44 125.65,135.62 125.65,136.05 125.47,136.23 125.47,136.52 125.74,136.79 125.74,137.59 126.39,138.25 126.88,138.25
GND on TOP (solid shape): 31.07,97.89 31.07,94.1 30.78,93.81 28.18,93.81 28.01,93.88 27.83,93.85 27.79,93.84 27.62,94.01 27.62,94.93 27.3,95.25 25.56,95.25 25.48,95.32 25.48,96.63 25.23,96.88 25.23,97.65 25.41,97.82 28.05,97.82 28.23,98 30.96,98
GND on TOP (solid shape): 87.35,149.78 87.35,148.9 87.28,148.84 86.46,148.84 86.27,148.65 86.27,148.33 86.14,148.2 85.25,148.2 85.04,148.42 85.04,148.51 84.95,148.51 84.93,148.52 84.92,148.52 82.22,148.52 82.1,148.41 82.1,147.7 82.62,147.18 82.62,145.54 82.53,145.45 81.35,145.45 80.93,145.87 80.93,149.53 81.26,149.86 87.27,149.86
GND on TOP (solid shape): 213.28,53.13 213.28,51.73 213.43,51.58 213.55,51.58 213.65,51.52 213.76,51.49 214.21,51.49 214.26,51.45 214.26,50.51 214.16,50.41 213.92,50.41 213.78,50.44 213.63,50.41 213.27,50.41 213.06,50.2 212.3,50.2 212.15,50.36 212.15,53.11 212.31,53.27 213.14,53.27
GND on TOP (solid shape): 56.71,131.09 56.71,130.78 56.79,130.7 56.79,130.69 56.88,130.54 57.02,130.45 57.04,130.45 57.23,130.26 58.34,130.26 58.52,130.08 58.52,129.55 58.42,129.45 58.02,129.45 57.63,129.06 57.63,129.05 57.54,128.96 56.01,128.96 55.81,128.77 54.91,128.77 54.77,128.91 54.77,129.97 56.02,131.23 56.57,131.23
GND on TOP (solid shape): 22.26,125.14 22.26,124.58 22.11,124.43 21.56,124.43 21.55,124.42 21.51,124.42 21.51,124.38 21.4,124.26 21.4,121.13 21.52,121 22.42,121 22.44,121.01 23.1,121.01 23.24,120.87 23.24,120.19 23.15,120.1 18.66,120.1 18.55,120.21 18.55,120.77 18.54,120.78 18.54,120.85 18.47,120.85 18.42,120.9 18.11,120.9 17.97,121.04 17.97,124.24 17.65,124.56 17.65,125.21 17.74,125.29 22.11,125.29
GND on TOP (solid shape): 53.15,124.79 53.15,124.56 52.83,124.25 52.52,124.25 51.47,123.2 50.85,123.2 50.49,122.83 49.89,122.83 49.76,122.97 49.76,123.72 49.96,123.93 50.55,123.93 51.14,124.52 51.18,124.5 51.44,124.49 51.64,124.65 51.65,124.66 51.92,124.94 52.99,124.94
GND on TOP (solid shape): 88.38,117.07 88.38,116.55 88.32,116.49 86.87,116.49 86.43,116.05 84.81,116.05 84.3,115.55 84.3,112.41 84.6,112.12 86.29,112.12 86.43,111.98 86.43,109.66 86.29,109.52 85.09,109.52 82.66,111.95 82.66,112.46 81.7,113.42 81.7,115.71 81.78,115.79 82.38,115.79 82.46,115.78 82.54,115.79 83.24,115.79 83.87,116.42 83.87,117.23 84.08,117.43 88.02,117.43
GND on TOP (solid shape): 30.29,35.47 30.29,30.5 30.07,30.28 30.07,30.19 30.04,30.16 30.04,29.3 29.82,29.08 28.74,29.08 28.67,29.14 28.67,31.94 28.66,31.95 28.66,32.06 28.36,32.37 28.36,32.89 28.42,32.95 28.42,35.05 28.16,35.3 27.09,35.3 26.77,34.98 26.77,34.91 26.77,33.47 26.77,33.47 26.77,33.21 27.08,32.89 27.08,32.38 26.89,32.19 21.37,32.19 21.12,32.44 21.12,35.56 21.69,36.13 29.63,36.13
GND on TOP (solid shape): 68.2,113.48 68.25,113.49 68.8,113.49 68.86,113.48 68.91,113.49 69.4,113.49 69.45,113.48 69.5,113.49 70.07,113.49 70.13,113.48 70.19,113.48 70.21,113.48 70.34,113.36 70.34,109.13 69.97,108.76 66.29,108.76 66.14,108.91 66.14,109.58 65.9,109.82 65.46,109.82 65.32,109.95 65.32,110.81 65.5,110.99 67.3,110.99 67.59,111.27 67.59,113.36 67.71,113.49 68.14,113.49
GND on TOP (solid shape): 71.66,118.83 71.66,116.94 71.53,116.81 71.07,116.81 70.46,116.19 69.4,116.19 69.34,116.25 69.34,117.54 70.29,118.5 70.9,118.26 70.66,118.87 70.75,118.95 71.53,118.95
GND on TOP (solid shape): 97.5,152.5 100.5,152.5 100.5,154.4 103,154.4 103,150 99,150 96.17,151.17 95,154 95,154.4 97.5,154.4
GND on TOP (solid shape): 79.82,149.01 79.82,148.33 79.94,148.21 79.94,145.13 79.37,144.56 79.37,143 79.35,143 79.35,142.29 79.19,142.13 79.01,142.13 78.8,142.19 78.59,142.13 78.22,142.13 78.05,142.3 78.05,144.7 77.61,145.14 76.18,145.14 76.17,145.14 75.79,145.52 74.94,145.52 74.94,146.05 74.43,146.05 74.43,145.52 74.14,145.52 74.14,146.05 73.63,146.05 73.63,145.52 73,145.52 72.68,145.84 72.68,148.93 73.04,149.3 79.54,149.3
GND on TOP (solid shape): 46.36,25.79 46.72,25.43 47.08,25.79 47.75,25.79 47.86,25.67 47.86,25.33 47.37,24.84 47.37,23.95 46.95,23.53 44.18,23.53 44.01,23.36 44,23.36 43.92,23.3 43.82,23.22 43.72,23.22 43.24,22.74 39.33,22.74 39.18,22.89 39.18,24.27 39.54,24.63 39.76,24.63 39.79,24.61 43.47,24.61 43.8,24.28 44.15,24.28 44.4,24.52 44.4,24.87 44.28,24.99 44.28,25.38 44.69,25.79
GND on TOP (solid shape): 125.61,61.51 125.72,61.48 125.83,61.49 125.92,61.47 125.95,61.39 125.95,61.3 125.92,61.22 125.84,61.19 125.52,61.03 125.54,60.67 125.55,60.57 125.46,60.51 124.18,60.51 124.11,60.57 124.11,61.22 124.33,61.22 124.33,61.46 124.88,61.46 124.93,61.52 125.6,61.52
GND on TOP (solid shape): 77.75,117.12 78.06,117.12 78.19,116.98 78.19,116.45 78.01,116.28 77.51,116.28 77.38,116.14 77.38,115.97 77.29,115.88 77.28,115.88 77.22,115.95 75.36,115.95 75.21,115.81 75.18,115.83 74.64,115.68 74.91,115.19 74.95,115.19 74.95,114.51 74.87,114.43 72.88,114.43 72.79,114.52 72.79,115.85 72.7,115.94 72.05,115.94 71.93,116.06 71.93,116.67 72.01,116.75 73.8,116.75 74.15,117.1 74.27,117.1 74.46,117.29 74.46,117.4 74.63,117.58 77.29,117.58
GND on TOP (solid shape): 129.19,68.92 129.19,68.42 129.07,68.29 128.11,68.29 128.05,68.23 128.05,68.08 128.01,68.05 128.01,67.81 127.92,67.72 127.42,67.72 127.35,67.78 127.35,68.1 127.16,68.29 127.08,68.29 127.08,68.3 126.61,68.3 126.42,68.11 126.42,68.06 126.4,68.04 126.4,67.78 126.34,67.72 125.89,67.72 125.83,67.78 125.83,68.16 125.7,68.29 125.56,68.29 125.55,68.3 125.09,68.3 125.08,68.29 124.81,68.29 124.75,68.23 124.75,67.85 124.62,67.72 124.18,67.72 124.11,67.78 124.11,68.16 124.05,68.23 123.91,68.23 123.9,68.23 123.63,68.23 123.44,68.23 123.43,68.23 123.35,68.23 123.22,68.1 123.22,68.02 122.98,67.78 122.53,67.78 122.36,67.95 122.34,68.03 122.34,68.92 122.46,69.05 129.07,69.05
GND on TOP (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 15.1,22.51 15.1,20.96 14.77,20.63 9.69,20.63 9.18,20.12 4.7,20.12 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.19,22.88 13.74,23.66 13.7,23.67 13.7,24.54 14.16,24.54
GND on TOP (solid shape): 118.97,129.31 119.03,129.31 119.07,129.27 119.58,129.27 119.81,129.17 120.05,129.27 120.23,129.27 120.24,129.28 121.08,129.28 121.13,129.23 121.13,128.52 120.82,128.21 120.8,128.22 120.62,128.14 120.54,127.96 120.54,127.93 120.51,127.9 120.05,127.9 120.04,127.94 119.95,128.07 119.8,128.13 119.78,128.13 119.53,128.38 118.72,128.38 118.43,128.66 118.43,128.68 118.37,128.82 118.25,128.91 118.22,128.93 118.22,129.41 117.94,129.69 117.94,129.87 117.95,129.87 117.96,129.87 117.96,129.89 118.07,129.99 118.28,129.99
GND on TOP (solid shape): 129.13,75.24 129.13,74.73 129.04,74.65 128.26,74.65 128.22,74.61 128.05,74.61 127.99,74.54 127.99,74.16 127.9,74.08 127.31,74.08 127.29,74.1 127.29,74.42 127.2,74.51 127.2,74.52 127.08,74.65 126.55,74.65 126.42,74.52 126.42,74.44 126.34,74.35 126.34,74.12 126.29,74.08 125.79,74.08 125.76,74.1 125.76,74.48 125.64,74.61 125.53,74.61 125.49,74.65 124.96,74.65 124.92,74.61 124.75,74.61 124.68,74.54 124.68,74.16 124.56,74.04 124.11,74.04 124.05,74.1 124.05,74.48 123.99,74.54 123.86,74.54 123.63,74.63 123.41,74.54 123.29,74.54 123.16,74.42 123.16,74.16 123.1,74.1 122.46,74.1 122.35,74.21 122.35,74.24 122.35,74.4 122.27,74.53 122.27,75.24 122.4,75.37 129,75.37
GND on TOP (solid shape): 2.19,126.65 2.83,126.65 2.83,125.98 7.48,125.98 7.73,125.74 7.73,125.17 7.53,124.96 6.83,124.96 6.32,124.46 6.32,124.07 6.1,123.86 5.52,123.86 5.27,124.11 5.27,124.57 5.27,124.58 5.19,125.16 4.67,125.41 4.21,125.22 4.04,124.74 4.02,124.67 3.94,124.63 0.2,124.63 0.2,126.6 0.29,126.81 0.5,126.9 2.19,126.9
GND on TOP (solid shape): 122.09,145.62 122.09,145.02 122.22,144.89 123.23,144.89 123.61,145.27 123.81,145.27 123.92,145.25 124.04,145.27 125.07,145.27 125.28,145.06 125.28,144.39 125.08,144.19 124.76,144.19 123.8,143.24 123.8,143.11 124.18,142.54 124.22,142.51 124.34,142.51 124.39,142.51 124.52,142.65 124.78,142.64 124.88,142.53 124.88,142.29 124.57,141.97 124.57,140.57 124.76,140.38 124.77,140.38 125.14,140.27 125.14,139.72 125.07,139.66 121.87,139.66 121.83,139.7 121.83,140.32 121.72,140.44 121.27,140.44 121.16,140.55 121.16,140.83 121.91,141.58 122.52,141.58 122.59,141.57 122.66,141.58 123.6,141.58 123.6,141.59 123.74,141.59 123.99,141.84 123.99,142 124.03,142 124.03,142.16 124.03,142.22 124.03,142.29 124.03,142.39 123.42,142.99 123.42,143.67 123.42,143.75 123.17,144 121.71,144 121.33,144.38 121.33,145.65 121.41,145.73 121.98,145.73
GND on TOP (solid shape): 153.72,49.51 153.73,49.51 155.32,47.92 155.32,42.89 155.35,42.85 155.35,42.81 155.7,42.46 155.7,38.78 155.65,38.73 155.42,38.73 155.42,38.73 154.59,38.73 154.4,38.92 154.4,42.24 154.02,42.62 154.02,47.3 152.62,48.7 148.81,48.7 148.69,48.83 148.69,49.51 151.25,49.51 151.26,49.46 151.27,49.41 151.29,49.36 151.31,49.31 151.35,49.27 151.39,49.23 151.43,49.2 151.48,49.18 151.53,49.16 151.58,49.16 151.64,49.16 151.69,49.16 151.74,49.18 151.79,49.2 151.83,49.23 151.87,49.27 151.9,49.31 151.93,49.36 151.95,49.41 151.96,49.46 151.97,49.51 151.96,49.57 151.95,49.62 151.93,49.67 151.9,49.71 151.87,49.76 151.83,49.79 151.79,49.82 151.74,49.84 151.69,49.86 151.64,49.87 151.58,49.87 151.53,49.86 151.48,49.84 151.43,49.82 151.39,49.79 151.35,49.76 151.31,49.71 151.29,49.67 151.27,49.62 151.26,49.57 151.25,49.51 148.69,49.51 148.69,50.1 148.88,50.29 152.94,50.29
GND on TOP (solid shape): 23.97,53.56 23.97,52.3 21.22,49.55 21.22,48.87 21.13,48.64 21.22,48.4 21.22,48.22 20.95,47.95 20.95,47 20.85,46.9 20.1,46.9 20.09,46.91 19.79,46.91 19.59,47.11 19.59,49.67 19.63,49.75 19.73,49.76 20.15,49.9 20.1,50.34 20.07,50.41 20.1,50.48 20.13,50.95 19.67,51.04 19.62,51.04 19.59,51.08 19.59,51.13 22.27,53.81 23.73,53.81
GND on TOP (solid shape): 128.84,63.62 129.32,63.62 129.36,63.58 129.36,62.91 129.24,62.8 128.75,62.8 128.69,62.86 128.69,63.03 128.7,63.11 128.69,63.2 128.69,63.27 128.49,63.46 127.85,63.46 127.84,63.47 126.61,63.47 125.92,62.78 125.92,62.23 125.88,62.16 125.8,62.13 125.72,62.14 125.65,62.12 125.55,62.13 125.51,62.21 125.51,62.77 125.45,62.77 125.42,62.83 125.46,62.87 125.57,62.99 125.57,63.4 125.51,63.46 124.75,63.46 124.69,63.41 124.66,63.43 124.35,63.44 124.15,63.19 124.14,63.16 124.05,63.16 124.05,63.34 123.99,63.4 123.78,63.4 123.77,63.4 123.63,63.43 123.49,63.4 123.48,63.4 123.29,63.4 123.16,63.27 123.16,62.75 122.69,62.75 122.42,62.48 121.7,62.48 121.32,62.86 121.32,63.41 122.13,64.23 128.24,64.23
GND on TOP (solid shape): 6.19,118.61 6.19,118.11 6.87,117.43 7.3,117.43 8.47,116.26 8.47,115.78 8.95,115.78 9.56,115.17 9.56,111.46 8.19,110.09 5.72,110.09 4.15,111.67 4.05,111.67 4.05,114.8 3.85,115.3 3.35,115.5 0.5,115.5 0.29,115.59 0.2,115.8 0.2,117.73 4.11,117.73 4.11,117.54 4.29,117.1 4.74,116.93 5.19,117.1 5.37,117.54 5.37,117.66 5.3,117.96 5.09,118.18 5.09,118.23 5.12,118.27 5.6,118.75 6.05,118.75
GND on TOP (solid shape): 81.34,133.84 84.77,133.84 84.87,133.74 84.87,132.6 84.79,132.52 84.51,132.52 84.4,132.4 84.39,132.4 84.22,132.18 84.26,131.9 84.26,131.69 84.21,131.51 84.25,131.33 84.26,131.32 84.26,131.3 84.45,131.11 84.74,131.11 84.92,131.29 84.92,132.01 85.06,132.15 88.11,132.15 88.32,131.94 88.32,131.36 88.69,131 92.82,131 92.96,131.14 92.96,131.79 93.43,132.25 95.44,132.25 95.73,131.96 95.73,128.42 94.92,127.61 93.34,127.61 93.25,127.69 93.25,128.65 93.09,128.81 90.13,128.81 90.11,128.8 89.4,128.8 89.28,128.67 89.28,127.76 89.19,127.67 86.15,127.67 86,127.82 86,128.54 85.56,128.97 84.6,128.97 84.59,128.96 84.26,128.96 84.26,128.96 84.22,128.96 84.11,128.85 84.11,128.59 84.11,127.69 84.23,127.57 84.24,127.57 84.33,127.47 84.69,127.47 84.79,127.37 84.79,126.17 84.63,126 81.05,126 80.77,126.28 80.77,127.15 82.86,129.24 83.75,129.24 83.9,129.4 83.9,131.05 82.43,132.52 80.51,132.52 80.44,132.6 80.44,133.26 80.43,133.6 80.14,133.78 80.14,134.33 80.24,134.43 80.75,134.43
GND on TOP (solid shape): outline of 83 points within 121.26,77.27 129.26,79.12
GND on TOP (solid shape): 188.36,40.72 188.36,40.38 188.44,40.31 188.44,38.98 187.87,38.41 187.87,38.03 187.74,37.9 187.16,37.9 187.1,37.97 187.1,38.39 187.29,38.58 187.29,39.08 186.78,39.08 186.74,39.04 186.64,39.02 186.57,39.1 186.12,39.4 185.9,38.91 185.89,38.81 185.8,38.76 185.69,38.76 185.48,38.55 185.48,37.98 185.34,37.84 184.07,37.84 184.02,37.89 184.02,39.03 183.97,39.08 183.97,39.09 183.85,39.21 183.42,39.27 183.25,38.87 183.26,38.86 183.26,38.76 182.55,38.76 182.43,38.64 182.43,37.88 182.38,37.83 181.02,37.83 180.97,37.87 180.97,38.55 180.95,38.55 180.95,38.62 180.82,38.76 179.65,38.76 179.37,39.04 179.37,40.11 179.59,40.33 184.57,40.33 185.07,40.83 188.25,40.83
GND on TOP (solid shape): 14.16,47.85 14.58,47.32 14.63,46.64 15.15,46.13 15.15,44.94 14.71,44.5 13.34,44.5 13.29,44.46 13.13,44.46 12.86,44.19 12.86,38.05 13.21,37.7 14.54,37.7 14.87,37.37 14.87,36.02 14.63,35.77 14.58,35.09 14.16,34.55 14.16,34.18 13.7,34.18 13.7,34.83 13.74,34.84 14.19,35.62 13.5,36.2 5,36.2 4.79,36.29 4.7,36.5 4.7,45.9 4.79,46.11 5,46.2 13.5,46.2 14.19,46.78 13.74,47.56 13.7,47.57 13.7,48.12 14.16,48.12
GND on TOP (solid shape): 3.01,117.1 3.01,116.16 3.21,115.96 3.35,115.96 4.17,115.62 4.51,114.8 4.51,113.39 4.83,113.07 4.83,111.79 4.51,111.46 4.51,108.3 4.45,107.94 4.29,107.62 4.29,107.02 6.05,105.26 10.05,105.26 10.14,105.26 10.23,105.25 13.14,105.25 13.88,104.5 13.88,103.77 13.42,103.31 11.07,103.31 10.71,102.95 10.71,102.63 10.25,102.63 10.25,103.43 10.29,103.44 10.74,104.22 10.05,104.8 2,104.8 1.79,104.89 1.7,105.1 1.7,107.6 3.35,107.6 3.85,107.8 4.05,108.3 4.05,114.8 3.85,115.3 3.35,115.5 0.5,115.5 0.29,115.59 0.2,115.8 0.2,117.61 2.5,117.61
GND on TOP (solid shape): 12.53,64.09 15.1,61.53 15.1,60.34 14.58,59.83 14.61,59.06 14.16,58.45 14.16,58.4 13.7,58.4 13.7,58.73 13.74,58.74 14.19,59.52 13.5,60.1 5,60.1 4.79,60.19 4.7,60.4 4.7,64.2 4.5,64.7 4,64.9 0.6,64.9 0.39,64.99 0.3,65.2 0.3,66.45 0.39,66.66 0.6,66.75 5.4,66.75 5.4,66.25 5.6,65.75 6.1,65.55 6.9,65.55 7.4,65.75 7.6,66.25 7.6,66.75 11.5,66.75 11.6,66.75 11.7,66.77 12.53,66.77
GND on TOP (solid shape): 161.68,53.73 162.19,53.73 162.21,53.71 162.21,53.48 162.57,53.12 162.92,53.48 162.92,53.73 163.46,53.73 163.46,53.48 163.81,53.12 164.17,53.48 164.17,53.73 164.64,53.73 164.64,53.46 164.99,53.11 165.35,53.46 165.35,53.73 165.48,53.73 165.84,53.73 165.84,53.49 166.2,53.13 166.56,53.49 166.56,53.73 166.7,53.73 167.14,53.73 167.14,53.46 167.36,53.13 167.86,53.24 167.93,53.15 167.93,52.35 167.84,52.26 166.84,52.26 166.7,52.12 162.33,52.12 160.19,49.98 158.93,49.98 158.67,50.24 158.67,53.44 158.96,53.73 161.68,53.73
GND on TOP (solid shape): outline of 138 points within 122.27,69.6 133.03,72.45
GND on TOP (solid shape): 10.71,90.66 11.01,90.36 13.32,90.36 13.78,89.9 13.78,89.24 12.05,87.51 12.05,81.94 12.27,81.72 12.56,81.33 12.66,80.85 12.66,79.2 12.2,79.2 12.2,80.85 12,81.35 11.5,81.55 7.6,81.55 7.6,82.05 7.4,82.55 6.9,82.75 6.1,82.75 5.6,82.55 5.4,82.05 5.4,81.55 0.6,81.55 0.39,81.64 0.3,81.85 0.3,83.35 0.39,83.56 0.6,83.65 2,83.65 2.5,83.85 2.7,84.35 2.7,88.6 2.79,88.81 3,88.9 10.05,88.9 10.74,89.48 10.29,90.26 10.25,90.27 10.25,91.41 10.71,91.41
GND on TOP (solid shape): outline of 148 points within 119.99,127.97 127.45,136.79
GND on TOP (solid shape): outline of 304 points within 156.32,61.6 163.41,76.17
GND on TOP (solid shape): outline of 286 points within 0.2,0.2 228.2,155.3
GND on TOP (solid shape): outline of 4963 points within 59.22,80.83 121.7,109.02
GND on TOP (solid shape): outline of 6512 points within 57.5,36.52 120.37,67.53
GND on BOTTOM (solid shape): 88.35,27.9 85.3,27.9 85.3,30.95 88.35,30.95
GND on BOTTOM (solid shape): 147.42,94.09 147.42,92.2 147.17,91.95 142.69,91.95 142.69,93.23 143.67,94.2 147.31,94.2
GND on BOTTOM (solid shape): 25.26,77.5 25.26,75.8 25.18,75.72 23.67,75.72 23.54,75.85 23.54,77.6 23.62,77.68 25.09,77.68
GND on BOTTOM (solid shape): 154.06,105.51 154.06,101.61 153.95,101.5 149.65,101.5 149.53,101.62 149.53,105.44 149.8,105.71 153.86,105.71
GND on BOTTOM (solid shape): 156.59,107.97 156.59,106.78 156.32,106.51 153.9,106.51 153.68,106.73 153.68,108.13 153.84,108.29 156.26,108.29
GND on BOTTOM (solid shape): 168.94,90.93 168.94,85.76 168.78,85.6 165.31,85.6 165.13,85.78 165.13,90.93 165.32,91.12 168.75,91.12
GND on BOTTOM (solid shape): 170.01,71.31 170.01,68 169.79,67.78 168.19,67.78 168.06,67.92 168.06,71.4 168.16,71.51 169.81,71.51
GND on BOTTOM (solid shape): 172.49,61.52 172.49,57.8 172.26,57.57 169.42,57.57 169.12,57.87 169.12,61.47 169.35,61.7 172.31,61.7
GND on BOTTOM (solid shape): 11.82,116.5 13.64,116.5 13.94,116.2 13.94,114.99 13.75,114.8 10.77,114.8 10.09,115.48 10.09,116.71 11.61,116.71
GND on BOTTOM (solid shape): 22.07,34.79 22.07,32.13 21.75,31.81 17.94,31.81 17.69,32.06 17.69,34.73 17.88,34.92 21.94,34.92
GND on BOTTOM (solid shape): 154.67,113.39 154.67,112.56 154.54,112.43 152.71,112.43 152.56,112.58 152.56,113.47 152.66,113.57 154.49,113.57
GND on BOTTOM (solid shape): 168.79,64.96 168.79,63.11 168.64,62.96 167.39,62.96 167.27,63.09 167.27,64.91 167.42,65.06 168.69,65.06
GND on BOTTOM (solid shape): 202.79,57.86 202.79,53.51 202.66,53.38 201.39,53.38 201.27,53.51 201.27,56.38 201.58,56.7 201.58,58.33 201.71,58.46 202.19,58.46
GND on BOTTOM (solid shape): 29.65,53.48 29.65,50.19 29.5,50.03 28.39,50.03 28.16,50.26 28.16,53.32 28.44,53.6 29.52,53.6
GND on BOTTOM (solid shape): 51.89,33.1 51.89,32.47 51.77,32.35 48.27,32.35 48.06,32.56 48.06,33.56 48.12,33.61 51.37,33.61
GND on BOTTOM (solid shape): 173.65,50.16 173.65,50 172.51,48.85 172.3,48.85 171.58,49.57 171.58,49.8 172.74,50.96 172.86,50.96
GND on BOTTOM (solid shape): 176.83,45.93 176.83,45.58 176.4,45.14 175.98,44.72 175.64,44.72 174.93,45.43 174.93,45.83 175.86,46.76 176.01,46.76
GND on BOTTOM (solid shape): 200.09,59.46 200.09,57.03 199.68,56.62 196.88,56.62 196.44,57.06 196.44,60.05 196.45,60.06 196.45,60.58 196.69,60.83 198.73,60.83
GND on BOTTOM (solid shape): 23.9,55.18 23.9,50.34 23.64,50.08 21.47,50.08 20.51,51.05 20.51,52.04 20.63,52.17 21.13,52.17 21.43,52.47 21.43,55.1 21.66,55.33 23.74,55.33
GND on BOTTOM (solid shape): 78.09,121.53 78.09,120.92 78.17,120.83 79.72,120.83 79.81,120.74 79.81,120.63 79.69,120.51 79.69,118.99 79.62,118.92 77.26,118.92 77.25,118.93 76.9,118.93 76.88,118.95 76.88,121.46 77.05,121.62 77.99,121.62
GND on BOTTOM (solid shape): 108.2,120.11 108.2,119.76 108.15,119.71 107.39,119.71 107.08,119.4 106.45,119.4 106.26,119.21 106.26,116.8 105.72,116.26 102.02,116.26 101.81,116.47 101.81,119.82 102.12,120.12 106,120.12 106.07,120.19 108.12,120.19
GND on BOTTOM (solid shape): 105.29,145.16 105.29,142.85 105.29,142.84 105.25,142.68 105.29,142.52 105.29,142.51 105.29,142.27 105,141.98 101.06,141.98 100.05,143 100.05,144.52 101.06,145.54 104.91,145.54
GND on BOTTOM (solid shape): 155.39,90.19 157.58,90.19 157.84,89.93 157.84,88.97 157.42,88.55 157.42,84.94 157.19,84.71 151.76,84.71 151.51,84.96 151.51,86.99 152.12,87.6 152.12,89.47 151.69,89.89 151.69,90.15 151.87,90.33 154.3,90.33 154.5,90.52 155.06,90.52
GND on BOTTOM (solid shape): 136.33,107.74 138.72,107.74 138.82,107.84 138.88,107.84 138.88,107.91 139.09,108.11 140.94,108.11 140.99,108.16 143.29,108.16 143.46,108 143.46,106.88 143.25,106.68 140.41,106.68 140.35,106.73 134.23,106.73 134.1,106.87 134.1,108.06 134.22,108.18 135.89,108.18
GND on BOTTOM (solid shape): 178.65,58.31 178.65,57.37 179.04,56.98 182.22,56.98 182.33,56.87 182.33,55.4 182.25,55.32 179.31,55.32 178.17,56.46 178.17,56.92 177.91,57.17 175.42,57.17 175.24,57.35 172.94,57.35 172.8,57.49 172.8,57.97 172.97,58.15 174.88,58.15 175.62,58.89 178.06,58.89
GND on BOTTOM (solid shape): 162.35,53.76 162.21,53.47 162.36,53.19 162.36,52.73 162.06,52.43 162.06,50.31 161.78,50.03 158.91,50.03 158.72,50.22 158.72,53.46 159.02,53.76
GND on BOTTOM (solid shape): 168.25,103.64 168.25,100.4 168.74,99.91 168.74,99.37 168.67,99.3 163.76,99.3 163.61,99.45 163.61,102.43 163.32,102.72 163.32,102.73 163.16,102.89 162.07,102.89 161.87,102.69 161.87,102.67 161.68,102.49 161.68,101.58 161.48,101.38 157.41,101.38 157.06,101.74 157.06,103.82 157.41,104.17 161.14,104.17 161.14,104.18 167.72,104.18
GND on BOTTOM (solid shape): 187.56,39.33 187.62,39.34 187.69,39.33 187.73,39.32 188.14,39.32 188.17,39.33 188.25,39.34 188.33,39.33 188.36,39.32 188.38,39.32 188.56,39.13 190.17,39.13 190.35,38.95 190.35,37.89 190.26,37.8 187.94,37.8 187.86,37.87 187.86,38.71 187.78,38.79 187.6,38.79 187.42,38.97 187.42,39.3
GND on BOTTOM (solid shape): 150.56,69.33 150.62,69.27 150.62,68.85 150.48,68.7 146.64,68.7 146.64,71.76 147.5,72.62 147.52,72.62 147.78,72.72 147.88,72.98 147.88,73 148.33,73.45 148.35,73.46 148.49,73.51 148.59,73.62 150.56,73.62
GND on BOTTOM (solid shape): 167.25,51.46 167.25,50.18 167.11,50.04 165.47,50.04 165.35,50.16 165.35,50.61 165.21,50.75 163.62,50.75 163.38,50.51 163.38,48.06 163.85,47.6 163.85,45.32 163.78,45.25 162.79,45.25 162.52,45.53 162.52,47.37 161.89,48.01 160.61,48.01 160.53,48.08 160.53,49.81 160.61,49.89 162.02,49.89 162.2,50.07 162.2,51.45 162.32,51.58 167.12,51.58
GND on BOTTOM (solid shape): 24.08,89.31 24.28,89.25 24.47,89.31 25.79,89.31 25.99,89.11 25.99,86.44 25.66,86.1 23.76,86.1 23.69,86.17 23.61,86.22 23.58,86.24 23.58,86.79 23.91,87.12 23.91,87.27 23.99,87.46 23.91,87.65 23.91,89.16 24.07,89.31
GND on BOTTOM (solid shape): 35.25,104.94 35.25,94.17 34.78,93.69 28.31,93.69 28.18,93.82 28.18,96.8 27.96,97.02 27.58,97.02 27.55,97.05 26.47,97.05 26.02,96.61 25.11,96.61 25.07,96.66 25.03,96.69 24.73,96.99 24.73,96.99 23.61,96.99 23.55,97.05 23.55,97.25 23.61,97.31 24.63,97.31 25.07,97.75 27.98,97.75 28.23,98.01 30.3,98.01 31.82,99.53 31.82,104.18 31.45,104.55 25.62,104.55 25.18,104.1 25.18,99.94 24.99,99.75 24.55,99.75 24.48,99.82 24.48,102.36 23.9,102.94 23.55,102.94 23.36,103.13 23.36,105.49 23.97,106.1 34.09,106.1
GND on BOTTOM (solid shape): 185.32,39.22 185.32,38.91 184.83,38.42 183.81,38.42 183.8,38.41 181.48,38.41 181.47,38.43 179.68,38.43 179.51,38.6 179.51,38.99 183.24,38.99 183.24,38.93 183.25,38.88 183.27,38.83 183.29,38.78 183.32,38.74 183.36,38.7 183.4,38.66 183.45,38.64 183.49,38.62 183.55,38.61 183.6,38.6 183.65,38.61 183.7,38.62 183.75,38.64 183.8,38.66 183.84,38.7 183.88,38.74 183.91,38.78 183.93,38.83 183.95,38.88 183.96,38.93 183.96,38.99 183.95,39.04 183.93,39.09 183.91,39.14 183.88,39.18 183.84,39.22 183.8,39.25 183.75,39.28 183.7,39.3 183.65,39.31 183.6,39.32 183.55,39.31 183.49,39.3 183.45,39.28 183.4,39.25 183.36,39.22 183.32,39.18 183.29,39.14 183.27,39.09 183.25,39.04 183.24,38.99 179.51,38.99 179.51,39.02 179.55,39.06 179.55,39.95 179.81,40.21 184.33,40.21
GND on BOTTOM (solid shape): 171.31,41.44 171.31,39.23 171.18,39.1 170.37,39.1 169.95,38.68 169.95,38.44 169.95,38.36 169.34,37.75 168.9,37.75 168.75,37.6 168.33,37.6 167.99,37.95 167.99,38.33 167.88,38.65 167.55,38.73 167.52,38.73 167.51,38.74 166.61,38.74 166.61,40.75 166.64,40.83 166.72,40.85 167.04,40.99 167.09,41.34 167.08,41.37 167.5,41.79 170.95,41.79
GND on BOTTOM (solid shape): 14.16,23.95 14.54,23.51 14.66,22.95 15.1,22.51 15.1,21.17 14.56,20.63 5.52,20.63 5.16,20.28 5.16,19.85 4.7,19.85 4.7,22 4.79,22.21 5,22.3 13.5,22.3 14.19,22.88 13.74,23.66 13.7,23.67 13.7,24.54 14.16,24.54
GND on BOTTOM (solid shape): 151.22,54.47 151.22,51.42 151.35,51.28 151.35,49.76 151.26,49.6 151.27,49.41 151.27,49.39 150.78,48.89 150.78,44.57 147.23,44.57 146.78,45.02 146.78,46.03 146.97,46.22 148.5,46.22 148.75,46.48 148.75,51.37 148.5,51.62 148.5,54.19 148.54,54.26 148.62,54.28 149.06,54.63 148.62,54.98 148.54,55 148.5,55.08 148.5,55.41 148.71,55.62 150.07,55.62
