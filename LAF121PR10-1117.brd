# Allegro board LAF121PR10-1117.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
ACES_50224-00401-001_4P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 1.194x1.803 smd: 5(4.3,-3.875) 6(-1.3,-3.875)
ACES_50458-00601-001_6P-T
  oval 0.559x1.6 smd: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0)
  rect 1.295x2.057 smd: 7(-3.1,-5.175) 8(13.1,-5.175)
ACES_50458-01001-P01_10P-T
  oval 0.559x1.803 smd: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0) 7(12,0) 8(14,0) 9(16,0) 10(18,0)
  rect 1.295x2.057 smd: 11(-3.1,-5.275) 12(21.1,-5.275)
ACES_50673-0120N-001_12P-T
  oval 0.61x1.499 smd: 1(0,0) 3(-1,0) 5(-2,0) 7(-3,0) 9(-4,0) 11(-5,0) 13(-6,0) 15(-7,0) 17(-8,0) 19(-9,0) 21(-10,0) 23(-11,0)
  oval 0.61x1.194 smd: 2(0,2.85) 4(-1,2.85) 6(-2,2.85) 8(-3,2.85) 10(-4,2.85) 12(-5,2.85) 14(-6,2.85) 16(-7,2.85) 18(-8,2.85) 20(-9,2.85) 22(-10,2.85) 24(-11,2.85)
  rect 1.702x2.311 smd: 25(-13.25,1.425) 26(2.25,1.425)
ACES_50699-03041-P01_30P
  oval 0.229x0.787 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 9(6.4,0) 10(7.2,0) 11(8,0) 12(8.8,0) 13(9.6,0) 14(10.4,0) 15(11.2,0) 16(12,0) 17(12.8,0) 18(13.6,0) 19(14.4,0) 20(15.2,0) 21(16,0) 22(16.8,0) 23(17.6,0) 24(18.4,0) 25(19.2,0) 26(20,0) 27(20.8,0) 28(21.6,0) 29(22.4,0) 30(23.2,0)
  rect 0.559x1.295 smd: 31(-1.475,-3.3) 32(24.675,-3.3)
ACES_51522-00601-001_6P-NPM
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 2.489x1.905 smd: 7(-2.15,-3.3) 8(4.65,-3.3)
ACES_51522-00801-001_8P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0)
  rect 2.489x1.905 smd: 9(5.65,-3.3) 10(-2.15,-3.3)
ACES_51524-0080N-001_8P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0)
  rect 2.489x2.21 smd: 9(10,-3.05) 10(-3,-3.05)
ACES_51524-0160N-001_16P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0) 11(10,0) 12(11,0) 13(12,0) 14(13,0) 15(14,0) 16(15,0)
  rect 2.159x2.21 smd: 17(-2.825,-3.05) 18(17.825,-3.05)
ACES_51540-04001-P01_40P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 0.787x2.489 smd: 41(21.2,-3.6) 42(-1.7,-3.6)
ACES_51575-00401-001_4P-T
  oval 0.406x1.194 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 0.787x2.007 smd: 5(-2.2,-3.4) 6(5.2,-3.4)
ACES_51625-01201-001_12P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0)
  rect 0.991x2.489 smd: 13(-1.8,-3.6) 14(7.3,-3.6)
ACES_51625-01601-001_16P-T
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0)
  rect 0.991x2.489 smd: 17(1.8,-3.6) 18(-9.3,-3.6)
ACES_91960-0084L_8P-T-NPM
  oval 0.889x1.346 smd: 1(0,0) 2(-1.27,0) 3(-2.54,0) 4(-3.81,0) 5(-3.81,-7.35) 6(-2.54,-7.35) 7(-1.27,-7.35) 8(0,-7.35)
ACON_HMRF6-AK120C_19P-T
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.499x2.21 hole 0.889x1.6: 20(11.75,1.7) 21(13.65,-7.75) 22(-4.65,-6.5) 23(-2.75,1.7)
ACON_TARAN-9R1391_9P
  round 0.991 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(-11.35,-2.38) 12(4.35,-2.38)
  oval 1.397x2.388 hole 0.787x1.803: 11(-11.35,-9.48) 13(4.35,-9.48)
ALC3246-CG_MQFN48_6X6-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
AO3409_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AON6970_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.62)
AON6994_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.665)
  rect 3.988x2.667 smd: 7(1.905,3.63)
AON7409_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7934_DFN3X3A8-10
  oval 0.457x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.76) 6(1.3,2.76) 7(0.65,2.76) 8(0,2.76)
  rect 2.54x1.041 smd: 9(0.975,1.813)
  rect 2.54x0.559 smd: 10(0.975,0.708)
AP2138N-1P5TRG1_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AP2204R-5P0TRG1_SOT89-3
  oval 0.889x1.295 smd: 1(0,0) 3(3,0)
  custom 0.433x0.433 smd: 2(1.5,1.775)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
AZ5123-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AZC199-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAS40C_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54C-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BAV99W_SC70-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
BOTH_NS0013LF_16P
  oval 0.762x1.905 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(8.89,8.8) 10(7.62,8.8) 11(6.35,8.8) 12(5.08,8.8) 13(3.81,8.8) 14(2.54,8.8) 15(1.27,8.8) 16(0,8.8)
C_6P3X4P5
  oval 3.505x1.6 smd: 1(0,0) 2(5.6,0)
C_25CL33LD
  oval 3.607x1.803 smd: 1(0,0) 2(5.4,0)
C_0402
  rect 0.508x0.584 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.778 smd: 1(0,0) 2(2.667,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_EEFCX1E330R-NPM
  rect 2.388x2.794 smd: 1(0,0) 2(-6.4,0)
CYNTE_PCMB104T-1R0MH_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
CYPD4225-40LQXIT_QFN40_6X6
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 9(0,-4) 10(0,-4.5) 21(6.1,-4.5) 22(6.1,-4) 23(6.1,-3.5) 24(6.1,-3) 25(6.1,-2.5) 26(6.1,-2) 27(6.1,-1.5) 28(6.1,-1) 29(6.1,-0.5) 30(6.1,0)
  oval 0.254x0.889 smd: 11(0.8,-5.3) 12(1.3,-5.3) 13(1.8,-5.3) 14(2.3,-5.3) 15(2.8,-5.3) 16(3.3,-5.3) 17(3.8,-5.3) 18(4.3,-5.3) 19(4.8,-5.3) 20(5.3,-5.3) 31(5.3,0.8) 32(4.8,0.8) 33(4.3,0.8) 34(3.8,0.8) 35(3.3,0.8) 36(2.8,0.8) 37(2.3,0.8) 38(1.8,0.8) 39(1.3,0.8) 40(0.8,0.8)
  rect 4.597x4.597 smd: 41(3.05,-2.25)
DB2J31400L_SOD323-2
  rect 0.991x1.092 smd: 1(0,0)
  rect 0.991x0.889 smd: 2(2.1,0)
DC021611210
  round 1.016 smd: 1(0,0) 2(2.54,0) 3(5.08,0) 4(7.62,0) 5(10.16,0)
DFLS160-7_POWERDI123-2
  rect 2.21x1.397 smd: 1(0,0)
  rect 0.889x1.397 smd: 2(-2.55,0)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN3009LFV-13_POWERDI3333-8-5
  oval 0.432x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.562x0.562 smd: 5(0.975,2.225)
EMIST_SQ-55G_1P
  rect 7.798x3.658 smd: 1(0,0)
ESD101-B1-02ELS_TSSLP-2-4-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
F_1206L150PR
  rect 0.991x1.803 smd: 1(0,0) 2(2.8,0)
F_MF-NSMF050-2
  rect 0.991x1.6 smd: 1(0,0) 2(3,0)
F_SMD1812P110TF-24
  rect 1.778x3.15 smd: 1(0,0) 2(5.23,0)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FE1P1S-BSOP28BCTR_SSOP28
  oval 0.381x1.727 smd: 1(0,0) 2(0.635,0) 3(1.27,0) 4(1.905,0) 5(2.54,0) 6(3.175,0) 7(3.81,0) 8(4.445,0) 9(5.08,0) 10(5.715,0) 11(6.35,0) 12(6.985,0) 13(7.62,0) 14(8.255,0) 15(8.255,5.28) 16(7.62,5.28) 17(6.985,5.28) 18(6.35,5.28) 19(5.715,5.28) 20(5.08,5.28) 21(4.445,5.28) 22(3.81,5.28) 23(3.175,5.28) 24(2.54,5.28) 25(1.905,5.28) 26(1.27,5.28) 27(0.635,5.28) 28(0,5.28)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
FP5_BGA_1140P
  round 0.305 smd: A3(0.9,0) A5(1.8,0) A7(3.3,0) A8(4.3,0) A10(5.3,0) A11(6.3,0) A12(7.3,0) A13(8.3,0) A14(9.3,0) A15(10.3,0) A16(11.3,0) A18(12.3,0) A19(13.3,0) A20(14.3,0) A21(15.3,0) A22(16.3,0) A23(17.3,0) A25(18.3,0) A26(19.3,0) A28(20.8,0) A30(21.7,0) AA1(0,-15.3) AA2(0.4,-14.8) AA3(0.8,-15.3) AA4(1.2,-14.8) AA5(1.9,-15.3) AA13(8.5,-15.1) AA14(9.3,-15.1) AA15(10.1,-15.1) AA16(10.9,-15.1) AA17(11.7,-15.1) AA18(12.5,-15.1) AA19(13.3,-15.1) AA20(14.1,-15.1) AA28(20.7,-15.3) AA29(21.4,-14.8) AA30(21.8,-15.3) AA31(22.2,-14.8) AA32(22.6,-15.3) AB2(0.4,-15.8) AB4(1.2,-15.8) AB13(8.5,-15.9) AB14(9.3,-15.9) AB15(10.1,-15.9) AB16(10.9,-15.9) AB17(11.7,-15.9) AB18(12.5,-15.9) AB19(13.3,-15.9) AB20(14.1,-15.9) AB29(21.4,-15.8) AB31(22.2,-15.8) AC1(0,-16.3) AC2(0.4,-16.8) AC3(0.8,-16.3) AC4(1.2,-16.8) AC5(1.9,-16.3) AC13(8.5,-16.7) AC14(9.3,-16.7) AC15(10.1,-16.7) AC16(10.9,-16.7) AC17(11.7,-16.7) AC18(12.5,-16.7) AC19(13.3,-16.7) AC20(14.1,-16.7) AC28(20.7,-16.3) AC29(21.4,-16.8) AC30(21.8,-16.3) AC31(22.2,-16.8) AC32(22.6,-16.3) AD1(0,-17.3) AD2(0.4,-17.8) AD3(0.8,-17.3) AD4(1.2,-17.8) AD5(1.9,-17.3) AD13(8.5,-17.5) AD14(9.3,-17.5) AD15(10.1,-17.5) AD16(10.9,-17.5) AD17(11.7,-17.5) AD18(12.5,-17.5) AD19(13.3,-17.5) AD20(14.1,-17.5) AD28(20.7,-17.3) AD29(21.4,-17.8) AD30(21.8,-17.3) AD31(22.2,-17.8) AD32(22.6,-17.3) AE1(0,-18.3) AE3(0.8,-18.3) AE5(1.9,-18.3) AE13(8.5,-18.3) AE14(9.3,-18.3) AE15(10.1,-18.3) AE16(10.9,-18.3) AE17(11.7,-18.3) AE18(12.5,-18.3) AE19(13.3,-18.3) AE20(14.1,-18.3) AE28(20.7,-18.3) AE30(21.8,-18.3) AE32(22.6,-18.3) AF1(0,-19.3) AF2(0.4,-18.8) AF3(0.8,-19.3) AF4(1.2,-18.8) AF5(1.9,-19.3) AF13(8.5,-19.1) AF14(9.3,-19.1) AF15(10.1,-19.1) AF16(10.9,-19.1) AF17(11.7,-19.1) AF18(12.5,-19.1) AF19(13.3,-19.1) AF20(14.1,-19.1) AF28(20.7,-19.3) AF29(21.4,-18.8) AF30(21.8,-19.3) AF31(22.2,-18.8) AF32(22.6,-19.3) AG1(0,-20.3) AG2(0.4,-19.8) AG3(0.8,-20.3) AG4(1.2,-19.8) AG5(1.9,-20.3) AG13(8.5,-19.9) AG14(9.3,-19.9) AG15(10.1,-19.9) AG16(10.9,-19.9) AG17(11.7,-19.9) AG18(12.5,-19.9) AG19(13.3,-19.9) AG20(14.1,-19.9) AG28(20.7,-20.3) AG29(21.4,-19.8) AG30(21.8,-20.3) AG31(22.2,-19.8) AG32(22.6,-20.3) AH2(0.4,-20.8) AH4(1.2,-20.8) AH13(8.5,-20.7) AH14(9.3,-20.7) AH15(10.1,-20.7) AH16(10.9,-20.7) AH17(11.7,-20.7) AH18(12.5,-20.7) AH19(13.3,-20.7) AH20(14.1,-20.7) AH29(21.4,-20.8) AH31(22.2,-20.8) AJ1(0,-21.3) AJ2(0.4,-21.8) AJ3(0.8,-21.3) AJ4(1.2,-21.8) AJ5(1.9,-21.3) AJ13(8.5,-21.5) AJ14(9.3,-21.5) AJ15(10.1,-21.5) AJ16(10.9,-21.5) AJ17(11.7,-21.5) AJ18(12.5,-21.5) AJ19(13.3,-21.5) AJ20(14.1,-21.5) AJ28(20.7,-21.3) AJ29(21.4,-21.8) AJ30(21.8,-21.3) AJ31(22.2,-21.8) AJ32(22.6,-21.3) AK1(0,-22.3) AK3(0.8,-22.3) AK5(1.9,-22.3) AK13(8.5,-22.3) AK14(9.3,-22.3) AK15(10.1,-22.3) AK16(10.9,-22.3) AK17(11.7,-22.3) AK18(12.5,-22.3) AK19(13.3,-22.3) AK20(14.1,-22.3) AK28(20.7,-22.3) AK30(21.8,-22.3) AK32(22.6,-22.3) AL1(0,-23.3) AL2(0.4,-22.8) AL3(0.8,-23.3) AL4(1.2,-22.8) AL5(1.9,-23.3) AL13(8.5,-23.1) AL14(9.3,-23.1) AL15(10.1,-23.1) AL16(10.9,-23.1) AL17(11.7,-23.1) AL18(12.5,-23.1) AL19(13.3,-23.1) AL20(14.1,-23.1) AL28(20.7,-23.3) AL29(21.4,-22.8) AL30(21.8,-23.3) AL31(22.2,-22.8) AL32(22.6,-23.3) AM1(0,-24.3) AM2(0.4,-23.8) AM3(0.8,-24.3) AM4(1.2,-23.8) AM5(1.9,-24.3) AM13(8.5,-23.9) AM14(9.3,-23.9) AM15(10.1,-23.9) AM16(10.9,-23.9) AM17(11.7,-23.9) AM18(12.5,-23.9) AM19(13.3,-23.9) AM20(14.1,-23.9) AM28(20.7,-24.3) AM29(21.4,-23.8) AM30(21.8,-24.3) AM31(22.2,-23.8) AM32(22.6,-24.3) AN1(0,-25.3) AN2(0.4,-24.8) AN3(0.8,-25.3) AN4(1.2,-24.8) AN5(1.9,-25.3) AN28(20.7,-25.3) AN29(21.4,-24.8) AN30(21.8,-25.3) AN31(22.2,-24.8) AN32(22.6,-25.3) AP1(0,-26.3) AP2(0.4,-25.8) AP3(0.8,-26.3) AP4(1.2,-25.8) AP5(1.9,-26.3) AP28(20.7,-26.3) AP29(21.4,-25.8) AP30(21.8,-26.3) AP31(22.2,-25.8) AP32(22.6,-26.3) AR1(0,-27.3) AR2(0.4,-26.8) AR3(0.8,-27.3) AR4(1.2,-26.8) AR5(1.9,-27.3) AR28(20.7,-27.3) AR29(21.4,-26.8) AR30(21.8,-27.3) AR31(22.2,-26.8) AR32(22.6,-27.3) AT2(0.4,-27.8) AT4(1.2,-27.8) AT29(21.4,-27.8) AT31(22.2,-27.8) AU1(0,-28.3) AU2(0.4,-28.8) AU3(0.8,-28.3) AU4(1.2,-28.8) AU5(1.9,-28.3) AU28(20.7,-28.3) AU29(21.4,-28.8) AU30(21.8,-28.3) AU31(22.2,-28.8) AU32(22.6,-28.3) AV1(0,-29.3) AV3(0.8,-29.3) AV5(1.9,-29.3) AV28(20.7,-29.3) AV30(21.8,-29.3) AV32(22.6,-29.3) AW2(0.4,-29.8) AW3(0.8,-30.3) AW4(1.2,-29.8) AW5(1.8,-30.3) AW28(20.8,-30.3) AW29(21.4,-29.8) AW30(21.8,-30.3) AW31(22.2,-29.8) AY1(0,-30.8) AY4(1.2,-30.8) AY6(2.3,-30.8) AY7(3.3,-30.7) AY8(4.3,-30.7) AY10(5.3,-30.7) AY11(6.3,-30.7) AY12(7.3,-30.7) AY13(8.3,-30.7) AY14(9.3,-30.7) AY15(10.3,-30.7) AY16(11.3,-30.7) AY18(12.3,-30.7) AY19(13.3,-30.7) AY20(14.3,-30.7) AY21(15.3,-30.7) AY22(16.3,-30.7) AY23(17.3,-30.7) AY25(18.3,-30.7) AY26(19.3,-30.7) AY27(20.3,-30.8) AY29(21.4,-30.8) AY32(22.6,-30.8) B6(2.8,-0.4) B8(3.8,-0.4) B9(4.8,-0.4) B10(5.8,-0.4) B11(6.8,-0.4) B12(7.8,-0.4) B13(8.8,-0.4) B15(9.8,-0.4) B16(10.8,-0.4) B17(11.8,-0.4) B18(12.8,-0.4) B20(13.8,-0.4) B21(14.8,-0.4) B22(15.8,-0.4) B23(16.8,-0.4) B24(17.8,-0.4) B25(18.8,-0.4) B27(19.8,-0.4) BA5(1.8,-31.4) BA6(2.8,-31.4) BA8(3.8,-31.4) BA9(4.8,-31.4) BA10(5.8,-31.4) BA11(6.8,-31.4) BA12(7.8,-31.4) BA13(8.8,-31.4) BA15(9.8,-31.4) BA16(10.8,-31.4) BA17(11.8,-31.4) BA18(12.8,-31.4) BA20(13.8,-31.4) BA21(14.8,-31.4) BA22(15.8,-31.4) BA23(16.8,-31.4) BA24(17.8,-31.4) BA25(18.8,-31.4) BA27(19.8,-31.4) BA28(20.8,-31.4) BB1(0,-31.7) BB3(0.9,-31.7) BB6(2.3,-31.8) BB7(3.3,-31.8) BB8(4.3,-31.8) BB10(5.3,-31.8) BB11(6.3,-31.8) BB12(7.3,-31.8) BB13(8.3,-31.8) BB14(9.3,-31.8) BB15(10.3,-31.8) BB16(11.3,-31.8) BB18(12.3,-31.8) BB19(13.3,-31.8) BB20(14.3,-31.8) BB21(15.3,-31.8) BB22(16.3,-31.8) BB23(17.3,-31.8) BB25(18.3,-31.8) BB26(19.3,-31.8) BB27(20.3,-31.8) BB30(21.7,-31.7) BB32(22.6,-31.7) BC6(2.8,-32.2) BC8(3.8,-32.2) BC9(4.8,-32.2) BC10(5.8,-32.2) BC11(6.8,-32.2) BC12(7.8,-32.2) BC13(8.8,-32.2) BC15(9.8,-32.2) BC16(10.8,-32.2) BC17(11.8,-32.2) BC18(12.8,-32.2) BC20(13.8,-32.2) BC21(14.8,-32.2) BC22(15.8,-32.2) BC23(16.8,-32.2) BC24(17.8,-32.2) BC25(18.8,-32.2) BC27(19.8,-32.2) BD3(0.9,-32.6) BD5(1.8,-32.6) BD7(3.3,-32.6) BD8(4.3,-32.6) BD10(5.3,-32.6) BD11(6.3,-32.6) BD12(7.3,-32.6) BD13(8.3,-32.6) BD14(9.3,-32.6) BD15(10.3,-32.6) BD16(11.3,-32.6) BD18(12.3,-32.6) BD19(13.3,-32.6) BD20(14.3,-32.6) BD21(15.3,-32.6) BD22(16.3,-32.6) BD23(17.3,-32.6) BD25(18.3,-32.6) BD26(19.3,-32.6) BD28(20.8,-32.6) BD30(21.7,-32.6) C1(0,-0.9) C3(0.9,-0.9) C6(2.3,-0.8) C7(3.3,-0.8) C8(4.3,-0.8) C10(5.3,-0.8) C11(6.3,-0.8) C12(7.3,-0.8) C13(8.3,-0.8) C14(9.3,-0.8) C15(10.3,-0.8) C16(11.3,-0.8) C18(12.3,-0.8) C19(13.3,-0.8) C20(14.3,-0.8) C21(15.3,-0.8) C22(16.3,-0.8) C23(17.3,-0.8) C25(18.3,-0.8) C26(19.3,-0.8) C27(20.3,-0.8) C30(21.7,-0.9) C32(22.6,-0.9) D5(1.8,-1.2) D6(2.8,-1.2) D8(3.8,-1.2) D9(4.8,-1.2) D10(5.8,-1.2) D11(6.8,-1.2) D12(7.8,-1.2) D13(8.8,-1.2) D15(9.8,-1.2) D16(10.8,-1.2) D17(11.8,-1.2) D18(12.8,-1.2) D20(13.8,-1.2) D21(14.8,-1.2) D22(15.8,-1.2) D23(16.8,-1.2) D24(17.8,-1.2) D25(18.8,-1.2) D27(19.8,-1.2) D28(20.8,-1.2) E1(0,-1.8) E4(1.2,-1.8) E6(2.3,-1.8) E7(3.3,-1.9) E8(4.3,-1.9) E10(5.3,-1.9) E11(6.3,-1.9) E12(7.3,-1.9) E13(8.3,-1.9) E14(9.3,-1.9) E15(10.3,-1.9) E16(11.3,-1.9) E18(12.3,-1.9) E19(13.3,-1.9) E20(14.3,-1.9) E21(15.3,-1.9) E22(16.3,-1.9) E23(17.3,-1.9) E25(18.3,-1.9) E26(19.3,-1.9) E27(20.3,-1.8) E29(21.4,-1.8) E32(22.6,-1.8) F2(0.4,-2.8) F3(0.8,-2.3) F4(1.2,-2.8) F5(1.8,-2.3) F28(20.8,-2.3) F29(21.4,-2.8) F30(21.8,-2.3) F31(22.2,-2.8) G1(0,-3.3) G3(0.8,-3.3) G5(1.9,-3.3) G28(20.7,-3.3) G30(21.8,-3.3) G32(22.6,-3.3) H1(0,-4.3) H2(0.4,-3.8) H3(0.8,-4.3) H4(1.2,-3.8) H5(1.9,-4.3) H28(20.7,-4.3) H29(21.4,-3.8) H30(21.8,-4.3) H31(22.2,-3.8) H32(22.6,-4.3) J2(0.4,-4.8) J4(1.2,-4.8) J29(21.4,-4.8) J31(22.2,-4.8) K1(0,-5.3) K2(0.4,-5.8) K3(0.8,-5.3) K4(1.2,-5.8) K5(1.9,-5.3) K28(20.7,-5.3) K29(21.4,-5.8) K30(21.8,-5.3) K31(22.2,-5.8) K32(22.6,-5.3) L1(0,-6.3) L2(0.4,-6.8) L3(0.8,-6.3) L4(1.2,-6.8) L5(1.9,-6.3) L28(20.7,-6.3) L29(21.4,-6.8) L30(21.8,-6.3) L31(22.2,-6.8) L32(22.6,-6.3) M1(0,-7.3) M2(0.4,-7.8) M3(0.8,-7.3) M4(1.2,-7.8) M5(1.9,-7.3) M28(20.7,-7.3) M29(21.4,-7.8) M30(21.8,-7.3) M31(22.2,-7.8) M32(22.6,-7.3) N1(0,-8.3) N2(0.4,-8.8) N3(0.8,-8.3) N4(1.2,-8.8) N5(1.9,-8.3) N13(8.5,-8.7) N14(9.3,-8.7) N15(10.1,-8.7) N16(10.9,-8.7) N17(11.7,-8.7) N18(12.5,-8.7) N19(13.3,-8.7) N20(14.1,-8.7) N28(20.7,-8.3) N29(21.4,-8.8) N30(21.8,-8.3) N31(22.2,-8.8) N32(22.6,-8.3) P1(0,-9.3) P2(0.4,-9.8) P3(0.8,-9.3) P4(1.2,-9.8) P5(1.9,-9.3) P13(8.5,-9.5) P14(9.3,-9.5) P15(10.1,-9.5) P16(10.9,-9.5) P17(11.7,-9.5) P18(12.5,-9.5) P19(13.3,-9.5) P20(14.1,-9.5) P28(20.7,-9.3) P29(21.4,-9.8) P30(21.8,-9.3) P31(22.2,-9.8) P32(22.6,-9.3) R1(0,-10.3) R3(0.8,-10.3) R5(1.9,-10.3) R13(8.5,-10.3) R14(9.3,-10.3) R15(10.1,-10.3) R16(10.9,-10.3) R17(11.7,-10.3) R18(12.5,-10.3) R19(13.3,-10.3) R20(14.1,-10.3) R28(20.7,-10.3) R30(21.8,-10.3) R32(22.6,-10.3) T1(0,-11.3) T2(0.4,-10.8) T3(0.8,-11.3) T4(1.2,-10.8) T5(1.9,-11.3) T13(8.5,-11.1) T14(9.3,-11.1) T15(10.1,-11.1) T16(10.9,-11.1) T17(11.7,-11.1) T18(12.5,-11.1) T19(13.3,-11.1) T20(14.1,-11.1) T28(20.7,-11.3) T29(21.4,-10.8) T30(21.8,-11.3) T31(22.2,-10.8) T32(22.6,-11.3) U2(0.4,-11.8) U4(1.2,-11.8) U13(8.5,-11.9) U14(9.3,-11.9) U15(10.1,-11.9) U16(10.9,-11.9) U17(11.7,-11.9) U18(12.5,-11.9) U19(13.3,-11.9) U20(14.1,-11.9) U29(21.4,-11.8) U31(22.2,-11.8) V1(0,-12.3) V2(0.4,-12.8) V3(0.8,-12.3) V4(1.2,-12.8) V5(1.9,-12.3) V13(8.5,-12.7) V14(9.3,-12.7) V15(10.1,-12.7) V16(10.9,-12.7) V17(11.7,-12.7) V18(12.5,-12.7) V19(13.3,-12.7) V20(14.1,-12.7) V28(20.7,-12.3) V29(21.4,-12.8) V30(21.8,-12.3) V31(22.2,-12.8) V32(22.6,-12.3) W1(0,-13.3) W2(0.4,-13.8) W3(0.8,-13.3) W4(1.2,-13.8) W5(1.9,-13.3) W13(8.5,-13.5) W14(9.3,-13.5) W15(10.1,-13.5) W16(10.9,-13.5) W17(11.7,-13.5) W18(12.5,-13.5) W19(13.3,-13.5) W20(14.1,-13.5) W28(20.7,-13.3) W29(21.4,-13.8) W30(21.8,-13.3) W31(22.2,-13.8) W32(22.6,-13.3) Y1(0,-14.3) Y3(0.8,-14.3) Y5(1.9,-14.3) Y13(8.5,-14.3) Y14(9.3,-14.3) Y15(10.1,-14.3) Y16(10.9,-14.3) Y17(11.7,-14.3) Y18(12.5,-14.3) Y19(13.3,-14.3) Y20(14.1,-14.3) Y28(20.7,-14.3) Y30(21.8,-14.3) Y32(22.6,-14.3)
  round 0.406 smd: AA6(2.6,-15.3) AA7(3.3,-15.3) AA8(4.1,-15.3) AA9(4.9,-15.3) AA10(5.7,-15.3) AA11(6.5,-15.3) AA12(7.3,-15.3) AA21(15.3,-15.3) AA22(16.1,-15.3) AA23(16.9,-15.3) AA24(17.7,-15.3) AA25(18.5,-15.3) AA26(19.3,-15.3) AA27(20,-15.3) AC6(2.6,-16.3) AC7(3.3,-16.3) AC8(4.1,-16.3) AC9(4.9,-16.3) AC10(5.7,-16.3) AC11(6.5,-16.3) AC12(7.3,-16.3) AC21(15.3,-16.3) AC22(16.1,-16.3) AC23(16.9,-16.3) AC24(17.7,-16.3) AC25(18.5,-16.3) AC26(19.3,-16.3) AC27(20,-16.3) AD6(2.6,-17.3) AD7(3.3,-17.3) AD8(4.1,-17.3) AD9(4.9,-17.3) AD10(5.7,-17.3) AD11(6.5,-17.3) AD12(7.3,-17.3) AD21(15.3,-17.3) AD22(16.1,-17.3) AD23(16.9,-17.3) AD24(17.7,-17.3) AD25(18.5,-17.3) AD26(19.3,-17.3) AD27(20,-17.3) AE6(2.6,-18.3) AE7(3.3,-18.3) AE8(4.1,-18.3) AE9(4.9,-18.3) AE10(5.7,-18.3) AE11(6.5,-18.3) AE12(7.3,-18.3) AE21(15.3,-18.3) AE22(16.1,-18.3) AE23(16.9,-18.3) AE24(17.7,-18.3) AE25(18.5,-18.3) AE26(19.3,-18.3) AE27(20,-18.3) AF6(2.6,-19.3) AF7(3.3,-19.3) AF8(4.1,-19.3) AF9(4.9,-19.3) AF10(5.7,-19.3) AF11(6.5,-19.3) AF12(7.3,-19.3) AF21(15.3,-19.3) AF22(16.1,-19.3) AF23(16.9,-19.3) AF24(17.7,-19.3) AF25(18.5,-19.3) AF26(19.3,-19.3) AF27(20,-19.3) AG6(2.6,-20.3) AG7(3.3,-20.3) AG8(4.1,-20.3) AG9(4.9,-20.3) AG10(5.7,-20.3) AG11(6.5,-20.3) AG12(7.3,-20.3) AG21(15.3,-20.3) AG22(16.1,-20.3) AG23(16.9,-20.3) AG24(17.7,-20.3) AG25(18.5,-20.3) AG26(19.3,-20.3) AG27(20,-20.3) AJ6(2.6,-21.3) AJ7(3.3,-21.3) AJ8(4.1,-21.3) AJ9(4.9,-21.3) AJ10(5.7,-21.3) AJ11(6.5,-21.3) AJ12(7.3,-21.3) AJ21(15.3,-21.3) AJ22(16.1,-21.3) AJ23(16.9,-21.3) AJ24(17.7,-21.3) AJ25(18.5,-21.3) AJ26(19.3,-21.3) AJ27(20,-21.3) AK6(2.6,-22.3) AK7(3.3,-22.3) AK8(4.1,-22.3) AK9(4.9,-22.3) AK10(5.7,-22.3) AK11(6.5,-22.3) AK12(7.3,-22.3) AK21(15.3,-22.3) AK22(16.1,-22.3) AK23(16.9,-22.3) AK24(17.7,-22.3) AK25(18.5,-22.3) AK26(19.3,-22.3) AK27(20,-22.3) AL6(2.6,-23.3) AL7(3.3,-23.3) AL8(4.1,-23.3) AL9(4.9,-23.3) AL10(5.7,-23.3) AL11(6.5,-23.3) AL12(7.3,-23.3) AL21(15.3,-23.3) AL22(16.1,-23.3) AL23(16.9,-23.3) AL24(17.7,-23.3) AL25(18.5,-23.3) AL26(19.3,-23.3) AL27(20,-23.3) AM6(2.6,-24.3) AM7(3.3,-24.3) AM8(4.1,-24.3) AM9(4.9,-24.3) AM10(5.7,-24.3) AM11(6.5,-24.3) AM12(7.3,-24.3) AM21(15.3,-24.3) AM22(16.1,-24.3) AM23(16.9,-24.3) AM24(17.7,-24.3) AM25(18.5,-24.3) AM26(19.3,-24.3) AM27(20,-24.3) AN6(2.6,-25.3) AN7(3.3,-25.3) AN8(4.1,-25.3) AN9(4.9,-25.3) AN10(5.7,-25.3) AN11(6.5,-25.3) AN12(7.3,-25.3) AN13(8.3,-25.3) AN14(9.3,-25.3) AN15(10.3,-25.3) AN16(11.3,-25.3) AN18(12.3,-25.3) AN19(13.3,-25.3) AN20(14.3,-25.3) AN21(15.3,-25.3) AN22(16.1,-25.3) AN23(16.9,-25.3) AN24(17.7,-25.3) AN25(18.5,-25.3) AN26(19.3,-25.3) AN27(20,-25.3) AP6(2.6,-26.3) AP7(3.3,-26.3) AP8(4.1,-26.3) AP9(4.9,-26.3) AP10(5.7,-26.3) AP12(7.3,-26.1) AP13(8.3,-26.1) AP14(9.3,-26.1) AP15(10.3,-26.1) AP16(11.3,-26.1) AP18(12.3,-26.1) AP19(13.3,-26.1) AP20(14.3,-26.1) AP21(15.3,-26.1) AP23(16.9,-26.3) AP24(17.7,-26.3) AP25(18.5,-26.3) AP26(19.3,-26.3) AP27(20,-26.3) AR6(2.6,-27.3) AR7(3.3,-27.3) AR8(4.1,-27.3) AR11(6.3,-26.9) AR12(7.3,-26.9) AR13(8.3,-26.9) AR14(9.3,-26.9) AR15(10.3,-26.9) AR16(11.3,-26.9) AR18(12.3,-26.9) AR19(13.3,-26.9) AR20(14.3,-26.9) AR21(15.3,-26.9) AR22(16.3,-26.9) AR25(18.5,-27.3) AR26(19.3,-27.3) AR27(20,-27.3) AT10(5.2,-27.4) AT11(6.3,-27.7) AT12(7.3,-27.7) AT13(8.3,-27.7) AT14(9.3,-27.7) AT15(10.3,-27.7) AT16(11.3,-27.7) AT18(12.3,-27.7) AT19(13.3,-27.7) AT20(14.3,-27.7) AT21(15.3,-27.7) AT22(16.3,-27.7) AT23(17.4,-27.4) AU6(2.6,-28.3) AU7(3.3,-28.3) AU8(4.3,-28.3) AU10(5.3,-28.5) AU11(6.3,-28.5) AU12(7.3,-28.5) AU13(8.3,-28.5) AU14(9.3,-28.5) AU15(10.3,-28.5) AU16(11.3,-28.5) AU18(12.3,-28.5) AU19(13.3,-28.5) AU20(14.3,-28.5) AU21(15.3,-28.5) AU22(16.3,-28.5) AU23(17.3,-28.5) AU25(18.3,-28.3) AU26(19.3,-28.3) AU27(20,-28.3) AV6(2.6,-29.3) AV7(3.3,-29.3) AV8(4.3,-29.3) AV10(5.3,-29.3) AV11(6.3,-29.3) AV12(7.3,-29.3) AV13(8.3,-29.3) AV14(9.3,-29.3) AV15(10.3,-29.3) AV16(11.3,-29.3) AV18(12.3,-29.3) AV19(13.3,-29.3) AV20(14.3,-29.3) AV21(15.3,-29.3) AV22(16.3,-29.3) AV23(17.3,-29.3) AV25(18.3,-29.3) AV26(19.3,-29.3) AV27(20,-29.3) AW7(3.3,-30) AW8(4.3,-30) AW10(5.3,-30) AW11(6.3,-30) AW12(7.3,-30) AW13(8.3,-30) AW14(9.3,-30) AW15(10.3,-30) AW16(11.3,-30) AW18(12.3,-30) AW19(13.3,-30) AW20(14.3,-30) AW21(15.3,-30) AW22(16.3,-30) AW23(17.3,-30) AW25(18.3,-30) AW26(19.3,-30) F7(3.3,-2.6) F8(4.3,-2.6) F10(5.3,-2.6) F11(6.3,-2.6) F12(7.3,-2.6) F13(8.3,-2.6) F14(9.3,-2.6) F15(10.3,-2.6) F16(11.3,-2.6) F18(12.3,-2.6) F19(13.3,-2.6) F20(14.3,-2.6) F21(15.3,-2.6) F22(16.3,-2.6) F23(17.3,-2.6) F25(18.3,-2.6) F26(19.3,-2.6) G6(2.6,-3.3) G7(3.3,-3.3) G8(4.3,-3.3) G10(5.3,-3.3) G11(6.3,-3.3) G12(7.3,-3.3) G13(8.3,-3.3) G14(9.3,-3.3) G15(10.3,-3.3) G16(11.3,-3.3) G18(12.3,-3.3) G19(13.3,-3.3) G20(14.3,-3.3) G21(15.3,-3.3) G22(16.3,-3.3) G23(17.3,-3.3) G25(18.3,-3.3) G26(19.3,-3.3) G27(20,-3.3) H6(2.6,-4.3) H7(3.3,-4.3) H8(4.3,-4.3) H10(5.3,-4.1) H11(6.3,-4.1) H12(7.3,-4.1) H13(8.3,-4.1) H14(9.3,-4.1) H15(10.3,-4.1) H16(11.3,-4.1) H18(12.3,-4.1) H19(13.3,-4.1) H20(14.3,-4.1) H21(15.3,-4.1) H22(16.3,-4.1) H23(17.3,-4.1) H25(18.3,-4.3) H26(19.3,-4.3) H27(20,-4.3) J10(5.2,-5.2) J11(6.3,-4.9) J12(7.3,-4.9) J13(8.3,-4.9) J14(9.3,-4.9) J15(10.3,-4.9) J16(11.3,-4.9) J18(12.3,-4.9) J19(13.3,-4.9) J20(14.3,-4.9) J21(15.3,-4.9) J22(16.3,-4.9) J23(17.4,-5.2) K6(2.6,-5.3) K7(3.3,-5.3) K8(4.1,-5.3) K11(6.3,-5.7) K12(7.3,-5.7) K13(8.3,-5.7) K14(9.3,-5.7) K15(10.3,-5.7) K16(11.3,-5.7) K18(12.3,-5.7) K19(13.3,-5.7) K20(14.3,-5.7) K21(15.3,-5.7) K22(16.3,-5.7) K25(18.5,-5.3) K26(19.3,-5.3) K27(20,-5.3) L6(2.6,-6.3) L7(3.3,-6.3) L8(4.1,-6.3) L9(4.9,-6.3) L10(5.7,-6.3) L12(7.3,-6.5) L13(8.3,-6.5) L14(9.3,-6.5) L15(10.3,-6.5) L16(11.3,-6.5) L18(12.3,-6.5) L19(13.3,-6.5) L20(14.3,-6.5) L21(15.3,-6.5) L23(16.9,-6.3) L24(17.7,-6.3) L25(18.5,-6.3) L26(19.3,-6.3) L27(20,-6.3) M6(2.6,-7.3) M7(3.3,-7.3) M8(4.1,-7.3) M9(4.9,-7.3) M10(5.7,-7.3) M11(6.5,-7.3) M12(7.3,-7.3) M13(8.3,-7.3) M14(9.3,-7.3) M15(10.3,-7.3) M16(11.3,-7.3) M18(12.3,-7.3) M19(13.3,-7.3) M20(14.3,-7.3) M21(15.3,-7.3) M22(16.1,-7.3) M23(16.9,-7.3) M24(17.7,-7.3) M25(18.5,-7.3) M26(19.3,-7.3) M27(20,-7.3) N6(2.6,-8.3) N7(3.3,-8.3) N8(4.1,-8.3) N9(4.9,-8.3) N10(5.7,-8.3) N11(6.5,-8.3) N12(7.3,-8.3) N21(15.3,-8.3) N22(16.1,-8.3) N23(16.9,-8.3) N24(17.7,-8.3) N25(18.5,-8.3) N26(19.3,-8.3) N27(20,-8.3) P6(2.6,-9.3) P7(3.3,-9.3) P8(4.1,-9.3) P9(4.9,-9.3) P10(5.7,-9.3) P11(6.5,-9.3) P12(7.3,-9.3) P21(15.3,-9.3) P22(16.1,-9.3) P23(16.9,-9.3) P24(17.7,-9.3) P25(18.5,-9.3) P26(19.3,-9.3) P27(20,-9.3) R6(2.6,-10.3) R7(3.3,-10.3) R8(4.1,-10.3) R9(4.9,-10.3) R10(5.7,-10.3) R11(6.5,-10.3) R12(7.3,-10.3) R21(15.3,-10.3) R22(16.1,-10.3) R23(16.9,-10.3) R24(17.7,-10.3) R25(18.5,-10.3) R26(19.3,-10.3) R27(20,-10.3) T6(2.6,-11.3) T7(3.3,-11.3) T8(4.1,-11.3) T9(4.9,-11.3) T10(5.7,-11.3) T11(6.5,-11.3) T12(7.3,-11.3) T21(15.3,-11.3) T22(16.1,-11.3) T23(16.9,-11.3) T24(17.7,-11.3) T25(18.5,-11.3) T26(19.3,-11.3) T27(20,-11.3) V6(2.6,-12.3) V7(3.3,-12.3) V8(4.1,-12.3) V9(4.9,-12.3) V10(5.7,-12.3) V11(6.5,-12.3) V12(7.3,-12.3) V21(15.3,-12.3) V22(16.1,-12.3) V23(16.9,-12.3) V24(17.7,-12.3) V25(18.5,-12.3) V26(19.3,-12.3) V27(20,-12.3) W6(2.6,-13.3) W7(3.3,-13.3) W8(4.1,-13.3) W9(4.9,-13.3) W10(5.7,-13.3) W11(6.5,-13.3) W12(7.3,-13.3) W21(15.3,-13.3) W22(16.1,-13.3) W23(16.9,-13.3) W24(17.7,-13.3) W25(18.5,-13.3) W26(19.3,-13.3) W27(20,-13.3) Y6(2.6,-14.3) Y7(3.3,-14.3) Y8(4.1,-14.3) Y9(4.9,-14.3) Y10(5.7,-14.3) Y11(6.5,-14.3) Y12(7.3,-14.3) Y21(15.3,-14.3) Y22(16.1,-14.3) Y23(16.9,-14.3) Y24(17.7,-14.3) Y25(18.5,-14.3) Y26(19.3,-14.3) Y27(20,-14.3)
G518A1TO1U_TSOT23-5
  oval 0.406x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
GD25LB128CSIGR_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.23) 6(2.54,7.23) 7(1.27,7.23) 8(0,7.23)
H5GC4H24AJR-R0C_BGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
H_3P0
  round 3.505 hole 2.997: 1(0,0)
H_3P0-G
  round 3.505 hole 2.997: 1(0,0)
H_3P0X4P0
  oval 3.505x4.496 hole 2.997x3.988: 1(0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P3
  round 3.81 hole 3.302: 1(0,0)
H_3P5
  round 4.013 hole 3.505: 1(0,0)
H_3P7
  round 4.216 hole 3.708: 1(0,0)
H_3P7X4P0
  oval 4.216x4.496 hole 3.708x3.988: 1(0,0)
H_4P0
  round 4.496 hole 3.988: 1(0,0)
H_4P0X3P7
  oval 4.496x4.216 hole 3.988x3.708: 1(0,0)
H_5P0-G
  round 5.512 hole 5.004: 1(0,0)
H_5P6N
  round 5.588 hole 5.588 unplated: (0,0)
INPAQ_HCM1012GH900BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
ISL9538HRTZ-T_TQFN32_4X4
  oval 0.787x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.2,-2.8) 18(4.2,-2.4) 19(4.2,-2) 20(4.2,-1.6) 21(4.2,-1.2) 22(4.2,-0.8) 23(4.2,-0.4) 24(4.2,0)
  oval 0.203x0.787 smd: 9(0.7,-3.5) 10(1.1,-3.5) 11(1.5,-3.5) 12(1.9,-3.5) 13(2.3,-3.5) 14(2.7,-3.5) 15(3.1,-3.5) 16(3.5,-3.5) 25(3.5,0.7) 26(3.1,0.7) 27(2.7,0.7) 28(2.3,0.7) 29(1.9,0.7) 30(1.5,0.7) 31(1.1,0.7) 32(0.7,0.7)
  rect 2.692x2.692 smd: 33(2.1,-1.4)
ISL62771HRTZ-T_TQFN40_5X5-S
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,4.975) 22(3.2,4.975) 23(2.8,4.975) 24(2.4,4.975) 25(2,4.975) 26(1.6,4.975) 27(1.2,4.975) 28(0.8,4.975) 29(0.4,4.975) 30(0,4.975)
  oval 1.016x0.203 smd: 11(4.288,0.688) 12(4.288,1.088) 13(4.288,1.488) 14(4.288,1.888) 15(4.288,2.288) 16(4.288,2.688) 17(4.288,3.088) 18(4.288,3.488) 19(4.288,3.888) 20(4.288,4.288) 31(-0.688,4.288) 32(-0.688,3.888) 33(-0.688,3.488) 34(-0.688,3.088) 35(-0.688,2.688) 36(-0.688,2.288) 37(-0.688,1.888) 38(-0.688,1.488) 39(-0.688,1.088) 40(-0.688,0.688)
  rect 3.505x3.505 smd: 41(1.8,2.488)
JAE_DX07S024JJ2R1300_24P
  round 0.711 hole 0.711 unplated: (-0.975,-2.7)
  oval 0.838x0.711 hole 0.838x0.711 unplated: (6.225,-2.635)
  oval 1.194x2.108 hole 0.711x1.702: 1(-1.695,-0.75) 4(6.945,-0.75)
  oval 1.651x1.092 hole 1.295x0.711: 2(-1.395,-1.25) 3(6.645,-1.25)
  oval 1.295x2.489 hole 0.711x1.905: 5(-1.695,-5.75) 6(6.945,-5.75)
  oval 0.279x0.889 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  oval 0.279x0.787 smd: B1(5.25,-1.6) B2(4.75,-1.6) B3(4.25,-1.6) B4(3.75,-1.6) B5(3.25,-1.6) B6(2.75,-1.6) B7(2.25,-1.6) B8(1.75,-1.6) B9(1.25,-1.6) B10(0.75,-1.6) B11(0.25,-1.6) B12(-0.25,-1.6)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X39-NPM
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X79-NPM
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JUMP_43X118-NPM
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JXT_FP226H-004S1AM_4P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 0.991x2.007 smd: 5(-2.6,-3.25) 6(5.6,-3.25)
KB9022QD_LQFP128_14X14
  oval 1.753x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 15(0,-5.6) 16(0,-6) 17(0,-6.4) 18(0,-6.8) 19(0,-7.2) 20(0,-7.6) 21(0,-8) 22(0,-8.4) 23(0,-8.8) 24(0,-9.2) 25(0,-9.6) 26(0,-10) 27(0,-10.4) 28(0,-10.8) 29(0,-11.2) 30(0,-11.6) 31(0,-12) 32(0,-12.4) 65(15.654,-12.4) 66(15.654,-12) 67(15.654,-11.6) 68(15.654,-11.2) 69(15.654,-10.8) 70(15.654,-10.4) 71(15.654,-10) 72(15.654,-9.6) 73(15.654,-9.2) 74(15.654,-8.8) 75(15.654,-8.4) 76(15.654,-8) 77(15.654,-7.6) 78(15.654,-7.2) 79(15.654,-6.8) 80(15.654,-6.4) 81(15.654,-6) 82(15.654,-5.6) 83(15.654,-5.2) 84(15.654,-4.8) 85(15.654,-4.4) 86(15.654,-4) 87(15.654,-3.6) 88(15.654,-3.2) 89(15.654,-2.8) 90(15.654,-2.4) 91(15.654,-2) 92(15.654,-1.6) 93(15.654,-1.2) 94(15.654,-0.8) 95(15.654,-0.4) 96(15.654,0)
  oval 0.203x1.753 smd: 33(1.627,-14.027) 34(2.027,-14.027) 35(2.427,-14.027) 36(2.827,-14.027) 37(3.227,-14.027) 38(3.627,-14.027) 39(4.027,-14.027) 40(4.427,-14.027) 41(4.827,-14.027) 42(5.227,-14.027) 43(5.627,-14.027) 44(6.027,-14.027) 45(6.427,-14.027) 46(6.827,-14.027) 47(7.227,-14.027) 48(7.627,-14.027) 49(8.027,-14.027) 50(8.427,-14.027) 51(8.827,-14.027) 52(9.227,-14.027) 53(9.627,-14.027) 54(10.027,-14.027) 55(10.427,-14.027) 56(10.827,-14.027) 57(11.227,-14.027) 58(11.627,-14.027) 59(12.027,-14.027) 60(12.427,-14.027) 61(12.827,-14.027) 62(13.227,-14.027) 63(13.627,-14.027) 64(14.027,-14.027) 97(14.027,1.627) 98(13.627,1.627) 99(13.227,1.627) 100(12.827,1.627) 101(12.427,1.627) 102(12.027,1.627) 103(11.627,1.627) 104(11.227,1.627) 105(10.827,1.627) 106(10.427,1.627) 107(10.027,1.627) 108(9.627,1.627) 109(9.227,1.627) 110(8.827,1.627) 111(8.427,1.627) 112(8.027,1.627) 113(7.627,1.627) 114(7.227,1.627) 115(6.827,1.627) 116(6.427,1.627) 117(6.027,1.627) 118(5.627,1.627) 119(5.227,1.627) 120(4.827,1.627) 121(4.427,1.627) 122(4.027,1.627) 123(3.627,1.627) 124(3.227,1.627) 125(2.827,1.627) 126(2.427,1.627) 127(2.027,1.627) 128(1.627,1.627)
KC_FBMA-L11-160808-800LMT_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L05ESDL5V0NA-4_SLP2510P8-10-9
  rect 0.203x0.686 smd: 1(0,0) 2(-0.5,0) 4(-1.5,0) 5(-2,0) 6(-2,-0.875) 7(-1.5,-0.875) 8(-0.5,-0.875) 9(0,-0.875)
  rect 0.406x1.549 smd: 3(-1,-0.437)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_5X5X3_M_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
L_7X7X4_M
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
LCN_DAN05-67306-0100_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(19.6,-0.775) 77(-1.1,-0.775)
LCN_DAN05-67306-0103_75P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(19.6,-0.775) 77(-1.1,-0.775)
LED_LTW-295DSKS-5A_4P
  rect 0.508x0.406 smd: 1(0,0) 2(1.2,0) 3(0,0.7) 4(1.2,0.7)
LM393DGKR_VSSOP8
  oval 1.575x0.381 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(4.35,-1.95) 6(4.35,-1.3) 7(4.35,-0.65) 8(4.35,0)
LMBT3904LT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LN2306LT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
LNG2DMTR_LGA12_2X2
  oval 0.406x0.305 smd: 1(0,0) 4(0,-1.5) 7(1.602,-1.5) 10(1.602,0)
  oval 0.508x0.305 smd: 2(0.051,-0.5) 3(0.051,-1) 8(1.551,-1) 9(1.551,-0.5)
  oval 0.305x0.508 smd: 5(0.551,-1.5) 6(1.051,-1.5) 11(1.051,0) 12(0.551,0)
LOTES_ADDR0205-P001A02_260P
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 3.505x4.597 smd: 261(-0.425,16.1) 262(67.175,16.1)
LOTES_ADDR0206-P001A02_260P
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(-67.175,7.9) 262(0.425,7.9)
LRB715FT1G_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MESS138W-G_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
MMBT3904_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15AG102SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BB221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX330SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
NC7SZ08P5X_NL_SC70-5
  oval 0.457x0.711 smd: 1(-0.65,-0.925) 2(0,-0.925) 3(0.65,-0.925) 4(0.65,0.925) 5(-0.65,0.925)
NCT7718W_MSOP8
  oval 0.381x1.575 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.35) 6(1.3,4.35) 7(0.65,4.35) 8(0,4.35)
NPCT650VB2YX_QFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
NX3DV221GM_XQFN10U10_2X1P55
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 6(1.5,1.59) 7(1,1.59) 8(0.5,1.59) 9(0,1.59)
  oval 0.889x0.254 smd: 5(1.77,0.795) 10(-0.27,0.795)
PDS5100H-13_POWERDI5-3
  rect 4.851x3.353 smd: 1(0,0)
  rect 1.397x1.397 smd: 2(3.982,-0.92) 3(3.982,0.92)
PS8520BTQFN20GTR2_TQFN20_4X4-S
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.8) 12(1.5,3.8) 13(1,3.8) 14(0.5,3.8) 15(0,3.8)
  oval 1.194x0.254 smd: 6(2.9,0.9) 7(2.9,1.4) 8(2.9,1.9) 9(2.9,2.4) 10(2.9,2.9) 16(-0.9,2.9) 17(-0.9,2.4) 18(-0.9,1.9) 19(-0.9,1.4) 20(-0.9,0.9)
  rect 2.108x2.108 smd: 21(1,1.9)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0402-NPM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RB551V-30_SOD323-2
  rect 0.559x0.813 smd: 1(0,0) 2(2.3,0)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT6226AGQUF_UQFN12_3X3
  oval 0.838x0.254 smd: 1(0,0) 6(3.15,0)
  oval 1.397x0.254 smd: 2(0.275,-0.72) 3(0.275,-1.62)
  oval 2.337x0.254 smd: 4(2.41,-1.17) 5(2.41,-0.45)
  oval 0.254x0.838 smd: 7(2.7,0.955) 8(2.25,0.955) 9(1.8,0.955) 10(1.35,0.955) 11(0.9,0.955) 12(0.45,0.955)
RT8061AZQW_WDFN10_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,3.1) 7(1.5,3.1) 8(1,3.1) 9(0.5,3.1) 10(0,3.1)
  rect 2.464x1.626 smd: 11(1,1.55)
RT8207PGQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9059GSP_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.157) 6(2.54,5.157) 7(1.27,5.157) 8(0,5.157)
  rect 2.311x2.311 smd: 9(1.905,2.579)
RT9069-33GB_SOT23-5
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0,2.6)
RTL8106E-CG_QFN32_4X4-S
  oval 0.203x0.838 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 17(2.8,4.15) 18(2.4,4.15) 19(2,4.15) 20(1.6,4.15) 21(1.2,4.15) 22(0.8,4.15) 23(0.4,4.15) 24(0,4.15)
  oval 0.838x0.203 smd: 9(3.475,0.675) 10(3.475,1.075) 11(3.475,1.475) 12(3.475,1.875) 13(3.475,2.275) 14(3.475,2.675) 15(3.475,3.075) 16(3.475,3.475) 25(-0.675,3.475) 26(-0.675,3.075) 27(-0.675,2.675) 28(-0.675,2.275) 29(-0.675,1.875) 30(-0.675,1.475) 31(-0.675,1.075) 32(-0.675,0.675)
  rect 2.692x2.692 smd: 33(1.4,2.075)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SINGA_2RJ3076-078211F_8P-T
  round 1.295 hole 0.889: 1(0,0) 2(-1.02,1.1) 3(-2.04,0) 4(-3.06,1.1) 5(-4.08,0) 6(-5.1,1.1) 7(-6.12,0) 8(-7.14,1.1)
  oval 0.991x2.007 hole 0.61x1.6: 9(4.83,-2.3) 10(4.83,-10.1) 11(-11.97,-10.1) 12(-11.97,-2.3)
SN74AHC1G08DCKR_SC70-5
  oval 0.381x1.295 smd: 1(0,0.15) 2(0.65,0.15) 3(1.3,0.15) 4(1.3,1.89) 5(0,1.89)
SN74LVC1G07DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SW_TST71-N-220-T170-S017_2P
  rect 0.61x1.499 smd: 1(0,0) 2(3.2,0)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
