# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_ARX_GTX_N3: length 119.1
  IN3 w0.099: v1(132.89,80.9) 133.07,81.08 133.07,81.31 132.93,81.45 131.36,81.45 131.15,81.66 131.15,84.98 131.44,85.28 131.44,85.65 131.42,85.68 131.42,86.05 131.39,86.07 131.39,86.1
  IN3 w0.135: 131.39,86.1 131.39,91.35 131.84,91.79 131.84,93.29 130.49,94.63 130.49,108.04 129.11,109.43 127.2,109.43 125.46,107.69 120.36,107.69 118.93,106.25 107.06,106.25 98.83,114.49 98.83,121.75 100.03,122.96 100.03,125.08 103.89,128.94 103.89,131.76 100.53,135.12 100.53,142.08 103.58,145.13 103.58,147.65 105.51,149.58 106.65,149.58 107.33,150.25 113.85,150.25 113.94,150.16 v1(114.63,150.16)
  BOTTOM w0.089: UC1.L7 133.23,80.56 132.9,80.9 v1(132.89,80.9)
  BOTTOM w0.112: v1(114.63,150.16) 114.79,150 114.91,150 115.27,150.36 115.47,150.36 CV8.2
PEG_ARX_GTX_P0: length 121.7
  IN3 w0.099: 133.56,86.1 133.58,86.08 133.58,86.05 133.68,85.96 133.68,85.39 133.37,85.08 133.37,83.69 134.76,82.3 134.76,79.53 134.13,78.89 133.15,78.89 132.47,78.21 131.93,78.21 131.52,77.79 131.52,77.26 131.94,76.83 131.94,76.83 v1(131.96,76.81)
  IN3 w0.135: 133.56,86.1 133.1,86.56 133.1,87.84 133.8,88.54 133.8,90.38 134.22,90.8 134.22,95.61 132.09,97.74 132.09,104.54 132.73,105.17 132.73,106.28 132.09,106.92 132.09,108.71 129.77,111.03 126.53,111.03 125.32,109.81 124.2,109.81 123.68,109.29 119.5,109.29 118.07,107.86 107.73,107.86 100.43,115.15 100.43,121.09 101.64,122.29 101.64,124.41 105.49,128.27 105.49,132.42 102.16,135.75 102.16,141.45 105.19,144.47 105.19,146.98 106.04,147.84 108.77,147.84 108.95,147.66 110.87,147.66 111.29,148.08 111.29,149 111.47,149.18 111.59,149.18 111.8,148.96 v1(111.8,148.96)
  BOTTOM w0.089: UC1.P8 132.16,77.31 131.94,77.09 131.94,76.83 v1(131.96,76.81)
  BOTTOM w0.112: v1(111.8,148.96) 111.8,148.96 112.1,149.25 112.23,149.25 112.49,148.99 112.49,148.67 112.12,148.31 CV1.2
PEG_ARX_GTX_P1: length 120.9
  IN3 w0.099: v1(133.59,77.86) 133.49,77.76 133.32,77.76 133.22,77.86 133.22,78.24 133.48,78.5 134.73,78.5 135.89,79.65 135.89,82.86 134.32,84.43 134.32,86.1
  IN3 w0.135: v1(113.48,148.93) 113.29,149.12 113.17,149.12 112.94,148.89 112.94,147.26 112.61,146.93 108.71,146.93 108.49,147.16 106.64,147.16 105.87,146.38 105.87,144.19 102.85,141.17 102.85,136.03 106.18,132.7 106.18,127.99 102.4,124.21 102.4,121.92 101.11,120.64 101.11,115.43 107.93,108.62 115.68,108.62 116.43,109.37 118.36,109.37 118.96,109.97 123.39,109.97 123.92,110.49 125.03,110.49 126.25,111.71 130.05,111.71 130.86,110.9 132.81,108.95 132.81,107.33 133.41,106.74 133.41,104.89 132.77,104.25 132.77,98.46 134.9,96.33 134.9,90.21 134.48,89.79 134.48,87.93 134.21,87.65 134.21,86.42 134.32,86.31 134.32,86.1
  BOTTOM w0.089: UC1.N6 133.68,78.31 133.59,78.22 v1(133.59,77.86)
  BOTTOM w0.112: v1(113.48,148.93) 113.79,149.24 113.94,149.24 114.24,148.94 114.24,148.68 CV3.2
PEG_ARX_GTX_P2: length 115.7
  IN3 w0.099: v1(132.8,79.83) 132.62,79.83 132.52,79.93 132.52,80.19 132.62,80.28 133.92,80.28 134.2,80.56 134.2,82.16 132.83,83.52 132.83,85.49 132.32,86 132.32,86.1
  IN3 w0.135: v1(109.35,149.41) 109.2,149.26 109.2,148.8 108.92,148.52 105.75,148.52 104.5,147.27 104.5,144.75 101.48,141.73 101.48,135.47 104.81,132.14 104.81,128.55 100.96,124.7 100.96,122.57 99.75,121.37 99.75,114.87 107.45,107.18 118.54,107.18 119.98,108.61 123.96,108.61 124.48,109.13 125.6,109.13 126.82,110.35 129.49,110.35 131.41,108.42 131.41,107.86 131.41,107.86 131.41,95.81 133.21,94.02 133.21,91.94 132.83,91.56 132.83,88.68 132.32,88.17 132.32,86.1
  BOTTOM w0.089: UC1.M8 132.43,79.37 132.8,79.74 v1(132.8,79.83)
  BOTTOM w0.112: v1(109.35,149.41) 109.17,149.23 109.17,149.11 109.28,149 110.55,149 110.79,148.76 110.79,148.57 111.05,148.32 CV5.2
PEG_ARX_GTX_P3: length 119.2
  IN3 w0.099: v1(133.61,80.88) 133.56,80.83 133.37,80.83 133.27,80.93 133.27,81.39 133.02,81.64 131.44,81.64 131.34,81.74 131.34,84.9 131.64,85.19 131.64,86.1
  IN3 w0.135: 131.64,86.1 131.64,91.25 132.08,91.69 132.08,93.39 130.73,94.73 130.73,108.14 129.21,109.67 127.1,109.67 125.36,107.93 120.26,107.93 118.83,106.5 107.16,106.5 99.07,114.59 99.07,121.65 100.28,122.86 100.28,124.98 104.13,128.84 104.13,131.86 100.77,135.22 100.77,141.98 103.82,145.03 103.82,147.55 105.61,149.33 106.75,149.33 107.43,150.01 113.75,150.01 113.84,149.91 114.27,149.91 114.62,149.57 v1(114.63,149.57)
  BOTTOM w0.089: UC1.L6 133.93,80.46 133.61,80.78 v1(133.61,80.88)
  BOTTOM w0.112: v1(114.63,149.57) 114.83,149.77 115,149.77 115.36,150.13 115.52,150.13 115.77,149.88 CV7.2
PEG_ATX_C_GRX_N0: length 116.9
  IN1 w0.119: v1(116.3,148.4) 116.12,148.58 116.12,148.8 115.87,149.04 115.44,149.04 114.31,147.92 107.51,147.92 106.5,146.91 105.45,146.91 104.48,145.93 104.48,144.87 101.39,141.78 101.39,134.94 103.88,132.45 103.88,128.62 101.91,126.65 101.91,122.91 100.23,121.23 100.23,118.46 101.81,116.88 106.21,116.88 109.41,113.68 112.53,113.68 112.95,113.26 114.18,113.26 114.4,113.48 116.21,113.48 116.46,113.23 117.39,113.23 117.61,113.02 117.96,113.02 122.49,108.49 122.49,107.22 127.49,102.22 131.12,102.22 136.23,97.11 137.3,97.11 143.28,91.13 143.28,91.13 143.39,91.02 143.39,83.54 144.84,82.09 v1(145.66,82.09)
  BOTTOM w0.102: 116.74,144.78 116.74,144.05 116.74,144.05 116.74,143.91 116.85,143.8 UV1.AE31
  BOTTOM w0.112: v1(116.3,148.4) 116.24,148.33 116.24,147.38 116.74,146.88 116.74,144.78 ; CV306.2 144.81,82.27 145.47,82.27 v1(145.66,82.09)
PEG_ATX_C_GRX_N1: length 120.9
  IN1 w0.119: v1(117.27,148.51) 117.1,148.35 116.84,148.35 116.55,148.06 116.55,147.66 116.17,147.28 107.78,147.28 106.77,146.26 105.72,146.26 105.12,145.67 105.12,144.6 102.04,141.51 102.04,135.21 104.53,132.72 104.53,128.36 102.55,126.39 102.55,122.65 100.87,120.96 100.87,118.73 102.08,117.53 106.48,117.53 109.68,114.32 112.79,114.32 113.21,113.9 113.91,113.9 114.13,114.12 116.63,114.12 116.74,114.01 118.15,114.01 118.38,113.79 118.38,113.51 123.13,108.76 123.13,107.49 127.76,102.86 134.02,102.86 136.77,103.96 138.77,103.96 140.57,102.16 140.57,97.7 144.03,94.24 144.03,84.74 144.88,83.89 v1(145.43,83.89)
  BOTTOM w0.102: UV1.AD28 117.74,142.98 117.43,143.3 117.43,143.56 117.46,143.58 117.46,144.02 117.45,144.03 117.45,144.72 117.38,144.78
  BOTTOM w0.112: v1(117.27,148.51) 117.49,148.29 117.66,148.29 117.9,148.04 117.9,146.89 117.38,146.37 117.38,144.78 ; v1(145.43,83.89) 145.39,83.93 144.69,83.93 CV305.2
PEG_ATX_C_GRX_N2: length 118.5
  IN1 w0.119: v1(145.53,85.64) 145.5,85.67 144.93,85.67 144.67,85.93 144.67,94.5 144.57,94.61 141.21,97.97 141.21,102.45 139.06,104.6 137.19,104.6 136.65,104.6 133.89,103.51 128.02,103.51 123.88,107.65 123.88,110.24 119.46,114.66 117.64,114.66 117.05,115.24 110.17,115.24 107.24,118.17 102.4,118.17 101.57,118.99 101.57,120.75 103.2,122.38 103.2,126.12 105.17,128.09 105.17,132.99 102.68,135.48 102.68,141.25 103.51,142.07 110.08,142.07 110.62,142.62 112.16,142.62 114.76,145.22 115.64,145.22 117.68,147.26 117.68,147.53 117.69,147.55 117.69,147.96 117.94,148.21 118.43,148.21 v1(118.52,148.3)
  BOTTOM w0.102: 118.62,144.78 118.62,144.34 118.24,143.96 118.24,143.76 118.31,143.69 118.43,143.69 UV1.AC31
  BOTTOM w0.112: v1(145.53,85.64) 145.5,85.67 144.65,85.67 CV309.2 ; 118.62,144.78 118.62,146.02 118.82,146.22 118.82,146.74 119.28,147.19 119.28,147.88 119.03,148.12 118.7,148.12 v1(118.52,148.3)
PEG_ATX_C_GRX_N3: length 112.5
  IN1 w0.119: v1(145.36,88.02) 145.57,87.81 146.03,87.81 146.14,87.93 146.14,89.87 145.32,90.7 145.32,94.77 145.21,94.87 145.21,94.88 141.85,98.24 141.85,102.74 139.45,105.14 139.43,105.14 139.33,105.25 136.93,105.25 136.52,105.25 133.77,104.15 131.27,104.15 130.72,104.71 127.73,104.71 125.68,106.76 125.68,109.36 123.06,111.98 123.06,112.58 120.33,115.3 117.9,115.3 117.32,115.88 110.44,115.88 108.11,118.22 108.11,122.12 107.86,122.37 107.86,125.35 105.81,127.4 105.81,133.25 103.32,135.74 103.32,140.98 103.72,141.38 113.82,141.38 116.48,144.04 118.28,144.04 118.57,144.33 118.57,146.8 119.24,147.47 119.71,147.47 119.94,147.23 v1(120.18,147.23)
  BOTTOM w0.102: 119.26,144.78 119.26,144.76 119.26,144.76 119.26,144.69 119.25,144.69 119.25,144.55 119.05,144.34 119.05,144.02 119.06,144.01 119.06,143.54 119.04,143.52 119.04,143.27 119.06,143.25 119.06,143.24 119.19,143.11 119.19,142.74 UV1.AB28
  BOTTOM w0.112: v1(145.36,88.02) 145.16,87.81 144.89,87.81 CV304.2 ; v1(120.18,147.23) 120.18,146.9 120.28,146.8 120.28,146.42 119.26,145.41 119.26,144.78
PEG_ATX_C_GRX_P0: length 116.9
  IN1 w0.119: v1(115.72,148.4) 115.9,148.58 115.9,148.7 115.78,148.82 115.53,148.82 114.41,147.7 107.6,147.7 106.59,146.69 105.55,146.69 104.7,145.84 104.7,144.78 101.61,141.69 101.61,135.04 104.1,132.54 104.1,128.53 102.13,126.56 102.13,122.82 100.45,121.14 100.45,118.55 101.9,117.1 106.3,117.1 109.5,113.9 112.62,113.9 113.04,113.48 114.09,113.48 114.31,113.7 116.3,113.7 116.55,113.45 117.49,113.45 117.7,113.23 118.05,113.23 122.71,108.58 122.71,107.31 127.58,102.44 131.21,102.44 136.32,97.33 137.39,97.33 143.5,91.22 143.61,91.11 143.61,83.63 144.93,82.31 145.29,82.31 145.65,82.67 v1(145.66,82.67)
  BOTTOM w0.102: 116.52,144.78 116.52,144.76 116.53,144.76 116.53,144.61 116.53,144.6 116.53,144.14 116.53,144.14 116.53,143.73 116.6,143.67 116.6,143.52 116.38,143.3 116.23,143.3 UV1.AF30
  BOTTOM w0.112: CV312.2 144.88,82.49 145.47,82.49 v1(145.66,82.67) ; 116.52,144.78 116.52,146.78 116.02,147.29 116.02,148.1 v1(115.72,148.4)
PEG_ATX_C_GRX_P1: length 120.9
  IN1 w0.119: v1(117.27,147.92) 117.06,148.13 116.93,148.13 116.77,147.97 116.77,147.57 116.26,147.06 107.87,147.06 106.86,146.05 105.81,146.05 105.34,145.58 105.34,144.51 102.25,141.42 102.25,135.3 104.75,132.81 104.75,128.27 102.77,126.3 102.77,122.55 101.09,120.87 101.09,118.82 102.17,117.74 106.57,117.74 109.77,114.54 112.88,114.54 113.31,114.12 113.82,114.12 114.04,114.34 116.72,114.34 116.83,114.23 118.24,114.23 118.6,113.88 118.6,113.6 123.35,108.85 123.35,107.58 127.85,103.08 133.97,103.08 136.73,104.18 138.86,104.18 140.78,102.25 140.78,97.79 144.25,94.33 144.25,84.83 144.97,84.11 145.06,84.11 145.42,84.47 v1(145.43,84.47)
  BOTTOM w0.102: 117.16,144.78 117.16,144.78 117.16,144.69 117.24,144.61 117.24,143.94 117.24,143.93 117.24,143.67 117.22,143.64 117.22,143.21 117.45,142.98 117.45,142.76 117.31,142.62 117.08,142.62 116.94,142.77 UV1.AE29
  BOTTOM w0.112: v1(117.27,147.92) 117.41,148.06 117.56,148.06 117.68,147.95 117.68,146.98 117.16,146.46 117.16,144.78 ; CV308.2 144.69,84.46 144.69,84.4 144.94,84.15 145.1,84.15 v1(145.43,84.47)
PEG_ATX_C_GRX_P2: length 118.5
  IN1 w0.119: v1(145.53,86.23) 145.53,86.23 145.19,85.89 145.02,85.89 144.89,86.02 144.89,94.59 144.79,94.7 141.43,98.06 141.43,102.54 139.15,104.82 137.19,104.82 137.1,104.82 136.61,104.82 133.85,103.73 128.11,103.73 124.1,107.74 124.1,110.33 119.56,114.88 117.73,114.88 117.14,115.46 110.26,115.46 107.34,118.39 102.49,118.39 101.79,119.09 101.79,120.66 103.42,122.29 103.42,126.03 105.39,128 105.39,133.08 102.9,135.57 102.9,141.16 103.6,141.86 110.17,141.86 110.71,142.4 112.25,142.4 114.85,145 115.73,145 117.89,147.17 117.89,147.44 117.91,147.46 117.91,147.87 118.03,147.99 118.22,147.99 118.49,147.71 v1(118.52,147.71)
  BOTTOM w0.102: 118.4,144.78 118.4,144.76 118.41,144.76 118.41,144.69 118.41,144.69 118.41,144.43 118.02,144.04 118.02,143.67 118.15,143.54 118.15,143.4 118.02,143.26 117.87,143.26 UV1.AD30
  BOTTOM w0.112: v1(118.52,147.71) 118.71,147.9 118.94,147.9 119.05,147.78 119.05,147.28 118.6,146.83 118.6,146.31 118.4,146.11 118.4,144.78 ; CV307.2 145.04,85.89 145.19,85.89 v1(145.53,86.23)
PEG_ATX_C_GRX_P3: length 112.5
  IN1 w0.119: v1(119.76,146.82) 119.76,147.1 119.62,147.25 119.33,147.25 118.79,146.71 118.79,144.24 118.37,143.82 116.57,143.82 113.91,141.16 103.81,141.16 103.54,140.89 103.54,135.83 106.03,133.34 106.03,127.49 108.08,125.44 108.08,122.46 108.33,122.21 108.33,118.31 110.53,116.1 117.41,116.1 117.99,115.52 120.42,115.52 123.27,112.67 123.27,112.07 125.89,109.45 125.89,106.85 127.82,104.93 130.81,104.93 131.36,104.37 133.72,104.37 136.48,105.46 136.83,105.46 136.84,105.46 139.42,105.46 139.53,105.35 139.54,105.35 142.07,102.83 142.07,98.33 145.43,94.97 145.54,94.86 145.54,90.79 146.36,89.96 146.36,87.84 146.12,87.59 145.52,87.59 v1(145.36,87.43)
  BOTTOM w0.102: 119.04,144.78 119.04,144.63 118.84,144.43 118.84,143.93 118.84,143.92 118.84,143.63 118.82,143.61 118.82,143.18 118.84,143.16 118.84,143.16 118.98,143.02 118.98,142.83 118.78,142.63 118.64,142.63 118.54,142.73 UV1.AC29
  BOTTOM w0.112: CV313.2 144.79,87.59 145.21,87.59 v1(145.36,87.43) ; v1(119.76,146.82) 119.94,146.82 120.06,146.71 120.06,146.52 119.04,145.5 119.04,144.78
PEG_ATX_GRX_N0: length 9.6
  BOTTOM w0.112: UC1.N3 136.36,78.06 136.41,78.01 136.7,78.01 136.81,78.12 136.81,78.19 137.18,78.56 137.74,78.56 138.26,79.08 138.69,79.08 140.39,80.78 140.43,80.78 141.09,81.44 141.09,81.48 141.59,81.97 v2(142.58,81.97) CV306.1
PEG_ATX_GRX_N1: length 10.5
  BOTTOM w0.112: CV305.1 v2(142.45,83.75) 142.19,83.75 137.42,78.98 137.01,78.98 136.65,78.62 136.38,78.62 136.24,78.48 136.07,78.48 135.34,78.81 UC1.M4
PEG_ATX_GRX_N2: length 10.8
  BOTTOM w0.112: UC1.L4 136.01,79.51 136.25,79.51 136.43,79.68 136.43,79.69 136.49,79.75 136.7,79.75 137.05,80.11 137.22,80.11 138.88,81.77 138.92,81.77 139.54,82.38 139.54,82.43 140.75,83.64 140.76,83.64 v2(142.33,85.21) 142.65,85.53 CV309.1
PEG_ATX_GRX_N3: length 11.9
  BOTTOM w0.102: UC1.L3 135.74,80.3 136.32,80.57
  BOTTOM w0.112: CV304.1 142.69,88.2 v2(142.2,87.7) 141.3,86.8 141.28,86.8 140.89,86.41 140.89,86.39 140.28,85.78 140.28,84.49 138.99,83.2 137.83,82.04 137.83,81.89 136.99,81.06 136.8,81.06 136.32,80.57
PEG_ATX_GRX_P0: length 9.6
  BOTTOM w0.112: UC1.N1 136.62,78.31 137.09,78.78 137.66,78.78 138.17,79.29 138.61,79.29 v2(140.64,81.33) 141.5,82.19 142.22,82.19 142.24,82.21 142.92,82.21 143.07,82.36 143.07,82.98 143.19,83.1 143.48,83.1 143.59,82.98 CV312.1
PEG_ATX_GRX_P1: length 10.5
  BOTTOM w0.112: CV308.1 143.37,84.87 143.16,84.87 143.05,84.76 143.05,84.09 142.93,83.98 142.7,83.98 142.7,83.99 142.2,83.99 142.2,83.98 142.11,83.98 141.27,83.14 141.27,83.12 v2(140.94,82.8) 137.33,79.19 136.92,79.19 136.65,78.92 136.24,78.92 UC1.M2
PEG_ATX_GRX_P2: length 10.9
  BOTTOM w0.112: UC1.L2 136.23,79.81 136.38,79.96 136.61,79.96 136.96,80.32 137.13,80.32 v2(139.09,82.28) 140.66,83.85 140.67,83.85 141.85,85.04 141.85,85.09 142.49,85.72 142.54,85.72 142.57,85.75 142.95,85.75 143.06,85.86 143.06,86.51 143.2,86.65 143.46,86.65 143.59,86.51 CV307.1
PEG_ATX_GRX_P3: length 11.9
  BOTTOM w0.112: CV313.1 143.51,87.22 143.21,87.22 143.1,87.33 143.1,87.86 142.99,87.98 142.78,87.98 142.55,87.74 142.55,87.72 142.17,87.35 142.16,87.35 v2(141.26,86.45) 140.5,85.69 140.5,84.4 140.25,84.15 140.24,84.15 138.04,81.95 138.04,81.8 137.08,80.84 136.89,80.84 136.53,80.48 UC1.L1
PLL_ANALOG_IN: length 2.8
  BOTTOM w0.102: UV1.AA1 120.33,122.6 120.55,122.39 120.55,121.73 120.24,121.42 120.24,120.91 119.97,120.64 119.96,120.64 T65.1
PLL_ANALOG_OUT: length 6.6
  BOTTOM w0.089: v3(119.33,117.69) 119.33,118.41 120.17,119.26 RV83.1
  BOTTOM w0.102: UV1.AA3 120.14,123.17 120.84,122.47 120.84,121.71 120.47,121.34 120.47,119.66 RV83.1
PLT_RST#: length 286.1
  TOP w0.099: 126.52,44.06 126.6,44.14 RC602.2 RC681.1 CC615.2
  TOP w0.112: v1(111.4,118.47) 111.26,118.62 103.09,118.62 101.62,117.15 92.18,117.15 90.07,119.25 v3(90.07,119.82) v1(90.07,120.35) ; 126.52,44.06 126.21,43.75 126.21,42.44 125.46,41.69 124.5,41.69 v1(123.89,41.08) ; UE1.13 42.15,69.68 41.64,70.19 v1(39.62,70.19) ; v1(26.73,87.77) 26.55,87.77 26.2,88.11 24.77,88.11 RL4.1
  IN1 w0.119: v1(50.01,84.66) 49.98,84.66 49.37,84.06 34.99,84.06 34.55,83.62 31.03,83.62 29.52,85.12 29.25,85.12 28.66,85.71 28.66,85.76 26.73,87.69 v1(26.73,87.77) ; v1(90.07,120.35) 89.83,120.59 86.28,120.59 85.98,120.88 83.08,120.88 78.14,125.81 73.3,125.81 72.6,126.51 71.7,126.51 70.49,127.72 70.01,127.72 69.81,127.52 69.81,127.49 v1(69.8,127.48) ; v1(123.89,41.08) 123.84,41.03 123.57,41.03 122,39.46 120.65,39.46 120.21,39.02 118.13,39.02 114.78,35.67 111.31,35.67 108.96,38.02 106.51,38.02 v1(106.4,38.13)
  IN3 w0.102: 56.17,90.82 57.62,92.26 57.62,108.8
  IN3 w0.135: v1(106.4,38.13) 100.89,38.13 100.11,37.34 98.37,37.34 98.13,37.1 90.22,37.1 89.5,37.82 86.5,37.82 85.78,37.1 67.13,37.1 64.81,39.43 64.48,39.43 64.25,39.65 62.22,39.65 55.75,46.12 47.55,46.12 45.71,47.96 41.83,47.96 41.02,48.76 41.02,52.47 40.19,53.31 40.19,62.33 39.21,63.31 39.21,65.42 38.99,65.64 38.99,67.59 39.62,68.21 v1(39.62,70.19) 39.62,70.65 39.3,70.97 39.3,72.12 38.77,72.65 38.77,76.27 37.87,77.17 37.87,78.4 38.29,78.83 38.29,81.63 39.34,82.68 41.39,82.68 42.06,83.35 46.42,83.35 46.94,83.87 49.22,83.87 v1(50.01,84.66) 56.17,90.82 ; v1(69.45,113.84) 69.45,113.3 69.31,113.17 68.35,113.17 67.76,112.57 61.39,112.57 57.62,108.8
  BOTTOM w0.112: v1(69.45,113.84) 69.45,115.01 68.8,115.65 68.8,117.55 RW10.2 68.87,118.37 68.8,118.37 68.32,118.86 68.32,120.88 68.67,121.24 68.67,122.88 69.28,123.49 69.28,126.99 69.78,127.48 v1(69.8,127.48) ; RC49.2 v1(111.4,118.47) ; UX1.17 106.07,37.8 v1(106.4,38.13) 106.4,38.85 T114.1
PLT_RST#_R: length 3.9
  TOP w0.089: UL1.19 24.07,86.5 RL4.2 RL5.2 25.7,86.79 v3(26.16,87.24)
PLT_RST#_RW: length 22.1
  BOTTOM w0.089: JWLAN1.52 72.36,133.4 72.45,133.31 72.45,132.15 73.03,131.58 73.03,127.45 72.88,127.3 72.88,124.57 71.57,123.26 70.3,123.26 69.73,122.68 69.73,119.27 69.82,119.18 70.71,119.18 71.02,118.87 71.02,117.64 v3(70.99,117.61) 70.46,117.08 RW11.2
  BOTTOM w0.254: RW10.1 RW11.2
PLT_RST_VGA#: length 24
  BOTTOM w0.102: UV2.4 108.1,124.94 108,125.04 107.74,125.04 106.32,126.46 106.32,129.77 107.59,131.04 107.59,138.3 107.73,138.44 v3(107.73,139.66) 107.73,140.51 107.84,140.62 109.34,140.62 RV4.1 110.91,141.33 112.87,141.33 UV1.AL27
PM_SLP_S3#: length 19.3
  IN2 w0.089: v1(128.67,56.95) 129.12,56.51 129.12,55.06 130,54.18 130,51.73 131.34,50.38 131.66,50.38 132.47,49.58 132.47,48.63 134.32,46.78 134.32,44.67 133.2,43.54 132.51,43.54 v1(132.48,43.58)
  BOTTOM w0.089: v1(132.48,43.58) 132.18,43.87 RC631.2 RC618.2
  BOTTOM w0.1: v1(128.67,56.95) 128.65,56.95 128.3,57.31 UC1.AV13
PM_SLP_S3#_EC: length 2.3
  TOP w0.089: RE30.2 39.35,65.59 UE1.6
PM_SLP_S3#_R: length 117.2
  TOP w0.089: CE18.1 RE30.1 39.4,63.89 40.23,63.06 40.23,62.78 v3(41.12,61.89) v1(42.12,61.89)
  IN2 w0.089: v1(42.12,61.89) 42.31,61.89 44.1,60.1 44.1,59.07 44.89,58.28 45.71,58.28 50.8,53.19 50.8,48.99 56.17,43.62 ; 56.45,42.35 56.45,41.36 61.1,36.71 63.85,36.71 65.26,35.3 78.62,35.3 79.11,34.81 80.33,34.81 81.24,33.89 96.5,33.89 97.49,34.88 100.08,34.88 100.3,35.1 103.18,35.1 104.16,34.12 104.43,34.12 104.63,34.33 107.06,34.33 107.77,33.61 110.15,33.61 110.24,33.52 114.8,33.52 115.26,33.99 116.17,33.99 116.84,34.66 117.51,34.66 118.26,35.41 120.49,35.41 120.84,35.75 124.51,35.75 129.65,40.89 129.7,40.89 130.67,41.85 130.67,42.15 v1(130.2,42.62)
  IN2 w0.102: 56.17,43.62 56.45,43.33 56.45,42.35
  BOTTOM w0.089: RC631.1 130.68,43.87 130.2,43.39 v1(130.2,42.62)
PM_SLP_S5#: length 166.5
  TOP w0.089: RE50.1 CE17.1 31.42,71.75 30.63,71.75 30.55,71.66 30.55,68.92 31.97,67.5 36.29,67.5 36.92,68.13 36.92,68.73 37.12,68.93 37.12,71.69 38.06,72.63 42.46,72.63 43.2,71.89 44.08,71.89 v1(44.33,71.64)
  TOP w0.099: T115.1 127.87,57.98 127.73,58.12 v1(127.73,58.51)
  IN2 w0.089: 56.66,42.35 56.66,42.24 56.66,42.24 56.66,41.41 61.18,36.89 64.04,36.89 65.44,35.49 78.68,35.49 79.18,34.99 80.41,34.99 81.32,34.08 96.43,34.08 97.42,35.07 100.01,35.07 100.22,35.29 103.26,35.29 103.47,35.08 107.32,35.08 107.62,34.77 108.26,34.77 109.23,33.8 110.23,33.8 110.32,33.7 114.72,33.7 115.19,34.17 116.09,34.17 116.76,34.84 117.44,34.84 118.19,35.59 120.42,35.59 120.77,35.94 123.4,35.94 128.3,40.84 128.88,40.84 129.3,41.26 129.3,41.74 129.08,41.96 129.08,42.31 130.12,43.36 131.37,43.36 131.96,43.95 132.66,43.95 132.84,43.77 133.14,43.77 134.14,44.77 134.14,46.7 128.93,51.91 128.93,54.47 128.67,54.73 128.67,55.57 128.24,56 128.24,58 v1(127.73,58.51) ; v1(44.33,71.64) 44.53,71.45 44.53,70.71 43.87,70.05 43.87,68.17 44.51,67.53 44.51,65.87 43.41,64.78 43.41,61.05 44.29,60.18 44.29,59.15 44.97,58.46 45.78,58.46 50.98,53.26 50.98,49.14 56.17,43.95
  IN2 w0.102: 56.17,43.95 56.66,43.46 56.66,42.35
  BOTTOM w0.1: UC1.AT14 127.33,58.91 v1(127.73,58.51)
PM_SLP_S5#_R: length 2.2
  TOP w0.089: RE50.2 33.75,71.19 34.66,71.19 34.88,71.41 UE1.123
POK: length 321
  TOP w0.089: RT113.2 34.96,115.43 33.92,114.38 v3(33.92,113.34) 33.92,107.42 32.79,106.29 32.79,94.08 32.34,93.63 28.08,93.63 v1(27.97,93.53) ; v1(40.28,71.89) 41.59,71.89 42.91,70.57 45.37,70.57 45.71,70.91 48.89,70.91 49.99,69.81 UE1.34 ; v1(46.97,38.74) 46.93,38.78 32.58,38.78 29.83,41.54 19.35,41.54 18.52,42.37 PR304.2
  TOP w0.254: v1(174.3,31.4) 175.32,31.4 175.92,32 PR35.1 ; PR304.2 18.52,44.67 18.26,44.93 17.87,44.93 v1(17.87,44.93)
  IN2 w0.089: v1(174.3,31.4) 174,31.1 173.56,31.1 173.3,30.84 168.44,30.84 168.24,30.63 163.06,30.63 162.64,30.2 162.38,30.2 162.12,29.94 154.51,29.94 150.24,34.22 147.29,34.22 147.26,34.19 146.45,34.19 146.4,34.13 135.83,34.13 135.53,33.83 134.26,33.83 134.06,34.03 131.15,34.03 130.6,33.47 129.96,33.47 124.95,28.46 121.33,28.46 120.47,29.33 117.2,29.33 116.33,28.46 114.81,28.46 114.25,29.03 110.38,29.03 109.82,28.46 99.98,28.46 99.76,28.68 97.41,28.68 96.84,28.11 84.3,28.11 83.08,29.33 67.08,29.33 66.36,30.06 62.48,30.06 61.75,29.32 60.93,29.32 60.3,29.95 60.3,31.08 54.29,37.09 48.64,37.09 46.99,38.74 v1(46.97,38.74) 46.97,38.76 45.71,40.02 45.71,50.92 42.81,53.81 42.81,54.86 39.39,58.29 39.39,59.08 39.19,59.29 39.19,64.83 39.11,64.91 39.11,67.5 39.61,68 39.61,69.39 40.76,70.54 40.76,71.12 40.59,71.29 40.59,71.59 v1(40.28,71.89)
  IN3 w0.089: v1(27.97,93.53) 27.97,91.16 26.26,89.45 25.18,89.45 24.69,88.96 24.69,86.84 26.94,84.59 26.94,80.37 28.76,78.55 28.76,69.77 28.92,69.61 28.92,65.3 27.21,63.59 27.21,61.79 26.74,61.32 26.74,56.2 26.02,55.48 23.14,55.48 20.65,52.99 20.65,50.9 v1(19.85,50.1)
  BOTTOM w0.089: PU301.9 18.01,43.49 17.69,43.81 17.69,44.74 v1(17.87,44.93) 16.23,46.57 16.23,47.75 17.12,48.64 19.72,48.64 20.29,49.21 20.29,49.65 v1(19.85,50.1)
  BOTTOM w0.203: PU501.9 27.63,96.72 27.86,96.48 27.86,94.54
  BOTTOM w0.254: 27.86,94.54 27.86,93.63 v1(27.97,93.53) 28.29,93.2 PR504.2
PS_0: length 4
  TOP w0.102: v3(118.21,136.26) 118,136.05 v1(118,135.8) 118,135.69 CV29.1 RV9.1 115.7,135.17 RV8.2
  BOTTOM w0.102: v1(118,135.8) 118.54,135.26 UV1.AC19
PS_1: length 4.7
  TOP w0.102: v1(117.33,135.95) 117.12,136.16 CV28.1 116.15,135.64 114.86,135.64 RV12.1 114.77,135.69 RV11.2
  BOTTOM w0.102: v1(117.33,135.95) 117.33,135.61 UV1.AD19
PS_2: length 5
  TOP w0.102: RV28.2 112.82,133.91 RV13.1 CV11.1 v3(115.66,133.03) 116.17,133.03 116.6,133.46 v1(116.6,133.54)
  BOTTOM w0.102: v1(116.6,133.54) 116.6,133.66 UV1.AE17
PS_3: length 6.8
  TOP w0.102: v1(116.67,136.95) 116.67,136.98 116.05,137.6 115.58,137.6 v3(115.39,137.79) 115.39,138.58 114.39,139.57 RV15.2 113.99,139.01 RV16.1 CV15.1
  BOTTOM w0.102: v1(116.67,136.95) 116.67,136.67 UV1.AE20
PS_ID: length 73.3
  TOP w0.089: UE1.16 43.35,68.6 v1(42.93,69.03) ; v3(58.57,123.83) PR5.1
  TOP w0.254: v1(59.24,119.08) 59.38,119.08 60.82,120.52 61.25,120.52 61.5,120.77 PD2.1 61.4,120.91 59.8,120.91 59.06,121.65 58.94,121.65 58.51,122.08 PR1.2 58.47,122.15 58.47,122.79 PR5.1
  IN2 w0.089: v1(42.93,69.03) 43.12,69.22 43.12,70.65 43.34,70.88 43.34,71.21 43.51,71.37 43.51,72.1 43.3,72.3 42.84,72.76 42.84,75.98 43.09,76.23 43.09,78.69 42.84,78.94 42.84,81.66 42.7,81.81 42.7,85.66 42.82,85.79 42.82,88.49 43.57,89.24 43.57,110.62 44.02,111.06 44.02,112.06 47.14,115.18 48.55,115.18 49.95,116.57 54.57,116.57 55.2,117.21 56.74,117.21 56.95,117 57.39,117 57.9,117.51 59.04,117.51 59.37,117.84 59.37,118.96 v1(59.24,119.08)
PSID: length 51.5
  TOP w0.089: v3(79.43,141.46) 79.06,141.84 v1(78.8,141.84)
  TOP w0.254: PL3.1 56.88,117.18 56.92,117.18 57.17,117.44 v1(57.17,117.57)
  IN2 w0.254: v1(57.17,117.57) 56.45,118.3 56.45,119.48 53.25,122.68 53.25,125.2 54.34,126.29 54.34,131.21 55.57,132.45 55.57,135.96 56.64,137.03 60.7,137.03 63.22,139.55 72.42,139.55 73.26,138.72 75.31,138.72 78.43,141.85 78.79,141.85 78.8,141.84 v1(78.8,141.84)
  BOTTOM w0.254: v1(78.8,141.84) 78.8,142.15 79.27,142.61 PJPDC1.3
PSID-1: length 5.5
  TOP w0.254: PQ2.2 57.63,116.15 56.27,114.78 v3(56,114.78) 55.49,114.78 54.69,115.58 PR6.1 PR3.2
PSID-3: length 2.9
  TOP w0.089: v3(56.68,122.35) 56.91,122.11 PR1.1
  TOP w0.254: PR1.1 57.59,121.84 56.98,121.23 PQ1.3
PTP_DIS#: length 119.9
  TOP w0.089: v1(43.34,66.48) 43.4,66.54 44.23,66.54 44.55,66.87 UE1.19 ; v3(120.8,30.31) 121.36,30.87 v1(121.36,32.58)
  IN2 w0.089: v1(121.36,32.58) 120.52,32.58 120.14,32.96 117.54,32.96 116.87,32.29 115.97,32.29 115.49,31.81 109.22,31.81 108.67,31.26 104.62,31.26 103.06,32.81 100.54,32.81 100.17,33.18 98.2,33.18 97.21,32.19 80.54,32.19 80.07,32.66 68.03,32.66 67.85,32.84 63.38,32.84 61.21,35.01 60,35.01 50.83,44.19 50.83,45.25 48.79,47.29 48.45,47.29 47.71,48.03 47.71,51.75 45.68,53.78 45.68,55.9 43.01,58.57 43.01,58.85 41.02,60.84 41.02,62.35 42.42,63.76 42.42,65.08 43.34,66 v1(43.34,66.48)
  BOTTOM w0.089: R11.2 117.31,33.02 119.53,33.02 119.97,32.58 v1(121.36,32.58) 121.36,32.67 121.62,32.94 122.64,32.94 123.05,32.53 JTP1.3
PWR_SE2: length 39.1
  TOP w0.089: v1(41.99,125.97) 42.19,126.16 v3(42.83,126.16)
  TOP w0.254: PQS30.6 43.5,123.46 43.61,123.57 43.61,123.93 43.43,124.11 PQS30.5 42.08,124.11 PR63.2 41.73,124.15 41.47,124.4 41.47,125.45 v1(41.99,125.97) ; v1(69.86,134.62) 70.61,133.87 PRS45.1
  IN1 w0.254: v1(69.86,134.62) 69.86,134.67 69.39,135.14 61.16,135.14 60.77,134.74 55.29,134.74 48.98,128.43 48.98,128.18 47,126.19 42.22,126.19 v1(41.99,125.97)
PWR_SELECT: length 72
  TOP w0.089: v1(41.34,66.36) 41.35,66.36 41.44,66.45 41.44,66.45 41.75,66.76 42.26,66.76 42.55,67.05 UE1.14
  TOP w0.254: PR65.2 PR66.1 46.38,122.72 43.99,122.72 43.41,122.13 43.41,121.25 PR64.2 44.13,120.68 44.48,120.33 44.48,119.42 43.89,118.83 v3(43.89,118.28) 43.89,117.18 44.47,116.61 45.09,116.61 45.65,116.04 v1(45.97,116.04)
  IN2 w0.089: v1(41.34,66.36) 41.29,66.41 41.29,69.77 41.67,70.16 41.67,71.5 41.5,71.67 41.5,72.57 41.74,72.81 41.74,76.55 41.53,76.75 41.53,77.32 41.94,77.72 41.94,80.7 41.33,81.31 41.33,81.88 39.82,83.39 39,83.39 38.63,83.76 38.63,85.77 38.9,86.04 41.07,86.04 41.36,86.32 41.36,87.33 41.48,87.45 41.48,88.42 42.64,89.58 42.64,94.67 42.26,95.06 42.26,96.41 42.64,96.8 42.64,110.95 43.12,111.44 43.12,112.43 45.97,115.28 v1(45.97,116.04)
PWR_SELECT1: length 77.7
  TOP w0.089: v3(97.28,148.46) 96.78,147.96 v1(96.72,147.96)
  TOP w0.254: PQS30.2 45.49,124.11 45.56,124.04 PR65.1 v1(45.97,124.67) ; PU2.1 96.5,147.73 v1(96.72,147.96)
  IN1 w0.254: v1(59.42,121.94) 48.37,121.94 45.97,124.34 v1(45.97,124.67)
  IN2 w0.254: v1(59.42,121.94) 59.52,122.03 60.24,122.03 61.43,123.21 61.43,129.71 61.18,129.96 61.18,136.17 63.6,138.6 72.04,138.6 72.87,137.77 75.7,137.77 78.64,140.71 79.31,140.71 79.32,140.71 80.69,140.71 81.96,141.98 81.96,143.89 82.66,144.58 86.45,144.58 86.7,144.84 86.7,146.94 v1(86.63,147.02)
  IN3 w0.254: v1(86.63,147.02) 87.01,146.64 89.07,146.64 90.36,147.93 96.69,147.93 v1(96.72,147.96)
PWR_SELECT2: length 16.8
  TOP w0.089: v3(95.44,150.16) 94.93,149.66 94.93,149.43 v1(94.92,149.42)
  TOP w0.254: v1(94.92,149.42) 94.92,149.35 94.61,149.03 PU2.4 93.07,149.03 92.87,149.23 PR46.2 PR21.2
  IN3 w0.254: v1(94.92,149.42) 94.6,149.42 93.96,148.78 89.57,148.78 v1(87.91,147.11)
  BOTTOM w0.254: PQ15.2 95.17,149.17 v1(94.92,149.42)
  BOTTOM w0.508: PR49.1 87.21,146.41 v1(87.91,147.11)
PWRGD_VGA: length 228.5
  TOP w0.203: PRV17.2 78.3,126.13 76.89,126.13 76.87,126.14 76.66,126.14 76.47,126.32 v1(76.44,126.32) 76.39,126.37 76.35,126.37 75.98,126.74 PUV01.20 ; PUV01.9 71.05,128.24 70.78,128.51 69.77,128.51 69.59,128.68 v1(69.53,128.68)
  TOP w0.254: PRV17.2 78.58,125.06 PRV20.1
  IN1 w0.254: v1(69.53,128.68) 69.59,128.68 69.69,128.58 70.03,128.58 71.82,126.79 75.87,126.79 76.28,126.37 76.39,126.37 v1(76.44,126.32)
  IN2 w0.089: v1(125.37,52.4) 126.74,51.02 127.76,51.02 130.66,48.13 130.66,47.16 131.46,46.36 131.46,44.12 131.08,43.74 129.97,43.74 128.25,42.02 128.25,41.4 128.1,41.25 127.72,41.25 122.8,36.33 120.63,36.33 120.26,35.96 118.03,35.96 117.28,35.22 116.61,35.22 115.94,34.55 115.03,34.55 114.57,34.09 110.48,34.09 110.16,34.4 109.52,34.4 108.71,35.21 107.71,35.21 107.47,35.45 103.62,35.45 103.41,35.66 99.8,35.66 99.7,35.55 98.92,35.55 98.52,35.96 95.21,35.96 94.5,35.26 81.73,35.26 81.43,35.55 79.42,35.55 78.92,36.05 65.8,36.05 64.4,37.46 61.66,37.46 57.22,41.89 57.22,43.82 51.54,49.5 51.54,54.55 47.26,58.84 45.13,58.84 44.67,59.31 44.67,60.34 43.79,61.21 43.79,64.62 44.88,65.71 44.88,67.69 44.25,68.33 44.25,69.89 44.91,70.55 44.91,71.28 44.92,71.29 44.92,72.13 44.28,72.76 44.28,75.46 43.84,75.9 43.84,79 43.59,79.25 43.59,81.96 43.44,82.11 43.44,85 44.2,85.76 44.2,88.13 44.85,88.77 44.85,93.45 44.18,94.12 44.18,110.44 45.52,111.79 45.52,113.04 47.29,114.81 48.7,114.81 50.09,116.2 54.72,116.2 55.36,116.84 56.59,116.84 56.8,116.63 57.55,116.63 58.06,117.14 59.97,117.14 60.83,118.01 65.81,118.01 66.28,117.54 v1(66.29,117.54)
  BOTTOM w0.089: v1(66.29,117.54) 66.18,117.65 66.18,118.22 67.56,119.61 67.56,121.15 68.13,121.71 68.13,123.11 68.74,123.72 68.74,127.62 69.53,128.41 v1(69.53,128.68) ; v1(125.37,52.4) 125.17,52.59 125.17,53.06 124.88,53.34 124.88,54.09 125.07,54.28 125.07,54.57 124.73,54.9 UC1.BA17
PX_EN: length 1.2
  TOP w0.102: T69.1 118.82,132.92 v1(118.82,133.36)
  BOTTOM w0.102: UV1.AB16 118.98,133.36 v1(118.82,133.36)
PXS_PWREN: length 280.8
  TOP w0.099: v1(124.1,51.71) 124.88,50.94 RC938.2
  TOP w0.254: v1(79.93,117.35) 79.82,117.35 79.11,116.64 PRF01.1 ; v1(68.11,129.14) 68.32,129.34 PRV15.1
  IN2 w0.089: v1(124.68,108.39) 124.25,107.96 119.17,107.96 118.09,109.04 115.92,109.04 115.14,108.25 111.9,108.25 107.93,112.22 107.93,112.75 105.88,114.8 101.06,114.8 100.52,115.35 87.71,115.35 85.16,117.89 80.47,117.89 v1(79.93,117.35) 79.63,117.05 74.42,117.05 72.96,115.59 68.55,115.59 67.71,116.43 v1(66.75,116.43) 66.6,116.43 65.39,117.64 63.53,117.64 62.64,116.75 58.19,116.75 57.27,115.83 50.24,115.83 48.85,114.45 47.44,114.45 45.88,112.89 45.88,104.96 46.28,104.56 46.28,97.94 44.76,96.42 44.76,94.32 45.39,93.68 45.39,87.89 44.76,87.25 44.76,85.53 43.99,84.77 43.99,82.34 44.14,82.19 44.14,79.49 44.39,79.24 44.39,76.13 46.12,74.4 46.12,72.35 46.64,71.83 46.64,71.33 46,70.69 46,68.27 46.58,67.69 46.58,65.67 46.88,65.37 46.88,63.78 48.41,62.25 48.41,58.46 52.71,54.17 52.71,49.38 56.17,45.92 ; v1(124.1,51.71) 124.98,50.83 124.98,48.99 128.47,45.5 128.47,44.67 127.32,43.52 127.23,43.52 125.68,41.97 125.55,41.97 122.25,38.67 120.99,38.67 120.41,38.1 119.03,38.1 116.89,35.95 116.3,35.95 115.63,35.28 114.73,35.28 114.45,35.01 112.16,35.01 110.85,35.51 109.05,36.78 107.18,36.78 106.76,37.2 105.1,37.2 104.91,37.01 98.86,37.01 98.77,36.93 97.44,36.93 97.21,36.7 94.9,36.7 94.19,35.99 82.03,35.99 81.73,36.29 79.8,36.29 79.3,36.79 66.24,36.79 64.12,38.92 61.55,38.92 58.11,42.35
  IN2 w0.102: 56.17,45.92 57.98,44.11 57.98,42.48 58.11,42.35
  BOTTOM w0.089: v1(68.11,129.14) 68.37,128.88 68.37,123.87 66.99,122.48 66.99,119.6 65.66,118.27 65.66,117.37 66.6,116.43 v1(66.75,116.43) ; R438.1 R23.1 126.22,111.44 126.08,111.3 126.08,109.79 v1(124.68,108.39) ; v1(124.1,51.71) 123.77,52.04 123.77,54.37 UC1.BC18
PXS_RST#: length 263.8
  IN2 w0.089: v1(116.55,108.54) 116.55,108.42 116.2,108.07 111.83,108.07 107.75,112.14 107.75,112.67 105.8,114.62 100.98,114.62 100.44,115.16 87.6,115.16 85.06,117.71 81.07,117.71 80.23,116.87 74.5,116.87 72.99,115.36 67.23,115.36 66.41,114.55 65.61,114.55 63.95,116.2 58.56,116.2 57.46,115.1 50.28,115.1 49.08,113.89 48.8,113.89 46.43,111.53 46.43,105.19 46.92,104.69 46.92,94.51 45.94,93.53 45.94,86.52 46.69,85.77 46.69,82.83 47,82.52 47,81.43 46.22,80.65 45.03,80.65 44.75,80.37 44.75,76.29 46.48,74.56 46.48,73.95 47.05,73.38 47.05,71.19 46.47,70.61 46.47,68.34 48.6,66.22 48.6,58.54 52.9,54.24 52.9,49.45 58.16,44.19 58.16,42.71 58.53,42.34 58.53,42.28 61.71,39.1 64.19,39.1 66.32,36.97 79.37,36.97 79.87,36.47 81.81,36.47 82.11,36.17 94.12,36.17 94.82,36.88 97.13,36.88 97.36,37.11 98.7,37.11 98.78,37.2 104.84,37.2 105.21,37.57 106.63,37.57 106.89,37.82 107.67,37.82 108.53,36.96 109.11,36.96 110.94,35.67 112.2,35.19 113.79,35.19 115.57,36.03 118.09,38.55 118.09,38.75 118.37,39.03 120.68,39.03 122.32,40.67 122.32,41.11 125.15,43.94 126.33,43.94 127,44.61 127,46.71 124.8,48.91 124.8,50.6 124.4,51 124.18,51 123.2,51.98 v1(123.2,52.62)
  BOTTOM w0.089: v1(116.55,108.54) 116.49,108.6 116.49,111.46 115.64,112.3 114.82,112.3 113.84,113.28 113.84,116.24 112.6,117.48 112.6,118.5 112.04,119.06 112.04,119.73 111.91,119.86 110.88,119.86 109.9,120.84 109.9,121.61 109.4,122.11 UV2.1 ; UC1.BB19 123.23,54.46 123.57,54.12 123.57,52.98 v1(123.2,52.62)
REGOUT:
  vias: v1(20.93,85.91) v1(20.93,85.28) v1(21.56,85.15) v3(20.35,86.01)
RING2:
  vias: v1(18.27,15.24) v1(18.96,15.24) v1(28.29,18.09) v1(28.29,17.46)
RING2_R: length 27.5
  IN1 w0.508: JHP1.4 6.35,7.9 7.27,6.98 13.56,6.98 16.16,9.58 16.73,9.58
  IN2 w0.508: v1(17.32,10.09) 16.67,10.09 13.56,6.98 7.29,6.98 6.37,7.9 JHP1.4
  vias: v1(17.32,9.39) v1(18.07,12.7) v1(18.7,12.7) v3(18,12)
RJ45_MDIN0: length 14.2
  IN1 w0.203: JRJ45.2 14.13,76.7 14.44,77.02 14.44,77.3 13.88,77.87 13.88,78.18 14.05,78.35 15.31,78.35 15.79,77.88 15.79,76.73 15.01,75.95 15.01,74.57 15.54,74.04 v1(16.37,74.04)
  BOTTOM w0.267: TL1.8 16.37,73.13 16.1,72.86 16.1,72.51 15.83,72.24 15.64,72.24 15.38,72.51 15.38,73.87 15.74,74.23 16.07,74.23 16.27,74.04 v1(16.37,74.04)
RJ45_MDIN1: length 16.8
  IN3 w0.203: JRJ45.6 14.27,72.4 14.55,72.4 14.91,72.75 14.91,73.07 14.48,73.5 14.48,73.79 14.72,74.03 15.09,74.03 15.39,73.74 15.39,70.05 14.58,69.24 14.58,66.63 15.36,65.85 15.36,65.07 15.16,64.86 14.98,64.86 14.73,65.12 v1(14.66,65.12)
  BOTTOM w0.267: TL1.2 16.23,65.51 15.97,65.24 15.97,64.89 15.7,64.62 15.42,64.62 15.13,64.91 14.97,64.91 14.77,65.12 v1(14.66,65.12)
RJ45_MDIN2: length 5.1
  TOP w0.267: JRJ45.5 13.6,73.64 13.71,73.53 14.46,73.53 15.07,72.91 15.07,72.41 15.45,72.03 16.26,72.03 16.43,71.86 TL2.2
RJ45_MDIN3: length 10.1
  TOP w0.267: JRJ45.8 14.05,70.89 14.32,71.15 14.69,71.15 15.13,70.71 15.13,69.93 14.58,69.37 v2(14.58,66.92) 14.58,65.9 15.34,65.13 15.4,65.13 15.67,64.86 15.67,64.36 15.79,64.24 TL2.8
RJ45_MDIP0: length 14.2
  IN1 w0.203: v1(16.37,74.62) 16.3,74.62 16.05,74.37 15.68,74.37 15.34,74.71 15.34,75.81 16.12,76.59 16.12,78.02 15.45,78.68 13.91,78.68 JRJ45.1
  BOTTOM w0.267: TL1.7 15.48,71.86 14.99,72.35 14.99,74.03 15.59,74.62 v1(16.37,74.62)
RJ45_MDIP1: length 16.8
  IN3 w0.203: v1(14.66,64.53) 15.3,64.53 15.69,64.93 15.69,65.98 14.91,66.77 14.91,69.1 15.72,69.91 15.72,73.83 15.12,74.83 14.51,75.44 13.72,75.68 JRJ45.3
  BOTTOM w0.267: v1(14.66,64.53) 14.97,64.53 15.26,64.24 TL1.1
RJ45_MDIP2: length 5
  TOP w0.267: TL2.1 16.53,73.13 16.26,72.86 16.26,72.68 15.99,72.41 15.62,72.41 15.45,72.58 15.45,73.07 14.61,73.91 14.21,73.91 13.94,74.18 13.94,74.55 JRJ45.4
RJ45_MDIP3: length 10.2
  TOP w0.267: JRJ45.7 14.37,71.6 14.79,71.6 15.52,70.87 15.52,69.77 14.96,69.21 v2(14.96,68.59) 14.96,66.05 15.5,65.51 TL2.7
RTC_CLK: length 1.9
  TOP w0.099: v1(127.73,56.31) 127.54,56.12 RC1689.1
  BOTTOM w0.1: v1(127.73,56.31) 127.43,56.61 UC1.AW14
RTC_DET#: length 33
  IN2 w0.089: v1(142.05,36.81) 141.96,36.9 141.96,42.17 141.18,42.94 138.85,42.94 137.04,44.76 137.04,47.95 137.22,48.14 137.22,51.2 136.29,52.13 136.29,52.53 134.97,53.85 134.97,54.97 134.22,55.72 v1(134.22,56.79)
  BOTTOM w0.089: v3(138.73,33.71) QC27.1 140.65,35.16 RC6130.2 142.05,36.56 v1(142.05,36.81) ; v1(134.22,56.79) 134.3,56.87 134.3,58.94 UC1.AR6
RTC_DIS: length 10.1
  TOP w0.089: v1(50,70.82) 50.12,70.82 50.34,70.61 UE1.36 ; v3(53.87,67.1) R30.1 52.43,66.61 v1(52.43,66.43) Q9.2
  IN2 w0.089: v1(52.43,66.43) 51.09,67.78 51.09,70.14 50.4,70.82 v1(50,70.82)
S0A3: length 37.7
  TOP w0.089: v1(143.2,62.74) 143.24,62.7 144.32,62.7 RC619.1
  IN2 w0.089: v1(141.4,43.94) 141.4,44.88 140.56,45.72 140.56,49.98 135.58,54.96 135.58,57.46 133.84,59.2 133.34,59.2 v1(132.94,58.8) 132.76,58.98 132.76,59.77 133.8,60.81 133.8,60.94 134.02,61.16 136.13,61.16 136.32,61.35 138.82,61.35 139.44,61.97 139.44,62.47 140,63.02 140.66,63.02 141.23,62.45 142.91,62.45 v1(143.2,62.74)
  BOTTOM w0.089: UC9.1 143,43.73 CC94.1 142.48,43.76 142.3,43.94 v1(141.4,43.94)
  BOTTOM w0.1: UC1.AR8 v1(132.94,58.8)
S0A3_GPIO: length 367.3
  TOP w0.089: v1(42.63,95.21) 41.93,95.21 41.46,94.74 38.06,94.74 R705.1 ; UE1.15 42.95,67.05 42.44,66.54 42.11,66.54 41.81,66.24 v1(41.81,66.01) 41.93,66.01 42,65.94 42.82,65.94 43.21,65.54 RC630.2 ; v1(36.7,45.6) 36.27,46.03 v4(34.6,46.03) 32.42,46.03 32.09,46.36 R703.1 31.28,46.6 30.9,46.99 30.9,47.71 v1(31.47,48.28) 31.47,48.99 31.56,49.08 R704.1 ; v1(80.12,133.42) 79.78,133.08 RW15.1 ; R702.1 146.22,34.93 146.2,34.95 146.2,36.27 v1(145.97,36.5) 145.97,37.05 145.17,37.86 145.17,39.14 144.73,39.58 v1(144.06,39.58)
  TOP w0.254: v1(31.17,32.35) 31.17,32.33 31.36,32.14 PRM13.1 ; PRZ47.1 v1(151.12,93.18)
  IN1 w0.089: v1(31.47,48.28) 32.26,47.49 38.37,47.49 39.55,46.3 41.03,46.3 41.94,45.39 42.95,45.39 43.21,45.13 46.54,45.13 46.78,44.89 48.01,44.89 v1(48.16,45.04) ; v1(80.12,133.42) 79.85,133.69 78.35,133.69 78.23,133.82 74.92,133.82 74.58,133.47 71.96,133.47 71.1,132.61 62.38,132.61 56.85,127.08 v1(53.77,127.08) ; v1(151.61,49.51) 152.93,50.84 152.93,68.81 153.12,69 153.12,76.45 151.32,78.25 151.32,81.76 149.09,83.98 149.09,86.48 148.56,87.02 148.56,88.84 149.01,89.29 149.01,91.67 150.52,93.18 v1(151.12,93.18)
  IN2 w0.089: v1(36.7,45.6) 36.41,45.31 36.41,42.55 36.67,42.3 36.67,41.68 35.38,40.39 34.98,40.39 34.51,39.91 34.51,39.14 35.04,38.6 35.04,37.5 31.78,34.23 31.78,32.62 31.5,32.35 v1(31.17,32.35) ; v1(53.77,127.08) 52.98,126.3 52.98,122.57 53.59,121.96 53.59,117.74 53.15,117.29 49.65,117.29 48.26,115.9 46.84,115.9 43.3,112.36 43.3,111.36 42.82,110.88 42.82,96.72 42.63,96.53 v1(42.63,95.21) 42.82,95.02 42.82,89.5 42.11,88.79 42.11,86.81 41.15,85.86 38.98,85.86 38.81,85.69 38.81,83.83 39.07,83.57 39.9,83.57 41.59,81.88 41.59,81.31 42.12,80.78 42.12,77.65 41.72,77.24 41.72,76.83 41.92,76.62 41.92,72.74 41.68,72.5 41.68,71.74 41.86,71.57 41.86,70.08 41.47,69.7 41.47,67.65 42,67.13 42,66.41 41.81,66.22 v1(41.81,66.01) 41.81,65.79 41.44,65.43 41.44,64.05 40.1,62.71 40.1,59.67 40.41,59.36 40.41,58.56 44.59,54.38 44.59,53.34 46.63,51.3 46.63,46.37 47.96,45.04 v1(48.16,45.04) 48.76,44.44 48.76,40.67 51.22,38.21 54.62,38.21 59.14,33.69 60.05,33.69 62.17,31.58 67.3,31.58 67.85,31.02 79.92,31.02 80.02,30.93 96.73,30.93 97.46,30.2 98.61,30.2 99.18,30.77 101.3,30.77 102.07,30 109.2,30 109.76,30.55 116.01,30.55 116.49,31.03 121.18,31.03 121.47,30.73 125.07,30.73 129.34,34.99 129.97,34.99 131.43,36.45 131.97,36.45 132.58,35.84 132.89,35.84 132.97,35.92 135.11,35.92 135.39,35.65 144.96,35.65 145.81,36.5 v1(145.97,36.5)
  BOTTOM w0.089: v1(144.06,39.58) 144.57,40.09 144.57,42.48 144.86,42.76 144.86,44.49 145.4,45.03 UC9.4 146.39,45.03 147.3,44.12 150.69,44.12 150.92,44.34 150.92,48.83 v1(151.61,49.51)
SATA_ACT#: length 182.6
  TOP w0.089: RS62.2 43.25,90.51 ; 43.25,90.51 R800.1 43.16,91.4 Q26.2 ; 43.25,90.51 43.33,90.43 44.33,90.43 v1(44.47,90.57) ; RE41.2 32.28,73.78 v1(32.1,73.96)
  TOP w0.099: v1(126.82,56.95) 126.82,56.94 126.65,56.94 v3(126.13,56.42) 125.85,56.14 125.85,55.2 126.2,54.86 126.2,50.56 127.47,49.29 RC621.2
  IN1 w0.089: v1(32.1,73.96) 32.28,73.78 36.83,73.78 36.99,73.95 38.34,73.95 38.77,73.52 43.14,73.52 v1(43.7,72.95)
  IN2 w0.099: v1(44.47,90.57) 44.47,88.66 44.01,88.2 44.01,85.83 43.25,85.07 43.25,82.04 43.4,81.89 43.4,79.17 43.65,78.92 43.65,76 43.4,75.75 43.4,73.26 v1(43.7,72.95) 44.72,71.93 44.72,71.37 44.71,71.36 44.71,70.63 44.05,69.97 44.05,68.25 44.69,67.61 44.69,65.8 43.6,64.7 43.6,61.13 44.47,60.26 44.47,59.23 45.05,58.65 45.86,58.65 51.17,53.34 51.17,49.29 56.85,43.61 56.85,41.59 61.36,37.08 64.12,37.08 65.52,35.68 78.76,35.68 79.26,35.18 80.48,35.18 81.4,34.26 96.35,34.26 97.34,35.25 99.93,35.25 100.15,35.47 103.33,35.47 103.54,35.26 107.4,35.26 107.7,34.96 108.69,34.96 109.58,34.07 110.22,34.07 110.4,33.89 114.64,33.89 115.11,34.36 116.02,34.36 116.69,35.03 117.36,35.03 118.11,35.78 120.34,35.78 120.7,36.14 123.06,36.14 127.95,41.03 128.8,41.03 129.11,41.34 129.11,41.66 128.89,41.88 128.89,42.39 130.04,43.54 131.29,43.54 131.82,44.08 131.82,46.62 131.57,46.87 131.57,48.75 128.56,51.76 128.56,53.81 127.29,55.08 127.29,55.92 127.16,56.06 127.16,56.58 126.82,56.91 v1(126.82,56.95)
  BOTTOM w0.1: UC1.AV15 126.33,57.31 126.68,56.95 v1(126.82,56.95)
SATA_ACT#_R: length 4.4
  TOP w0.089: Q26.3 43.08,92.05 R800.2 R83.2 43.4,93.26 Q17.3 v3(44.45,92.17)
SATA_ACT#_RR: length 2.9
  TOP w0.089: RE39.2 RE41.1 33.66,73.81 UE1.117
SATA_ARX_C_DTX_N0: length 7.3
  TOP w0.112: 189.71,32.27 v1(189.71,32.27) ; 189.71,32.27 190,31.99 190.15,31.99 190.39,32.23 CS17.2 ; 189.71,32.27 189.61,32.16 189.24,32.16 CS10.2
  BOTTOM w0.112: JHDD1.5 188.2,35.04 188.15,35 188.04,35 187.96,34.92 187.96,32.41 188.42,31.95 189.38,31.95 189.49,32.06 189.49,32.15 189.6,32.27 v1(189.71,32.27)
SATA_ARX_C_DTX_N1: length 7.9
  TOP w0.112: CS23.2 190.14,64.96 190.14,65.54 189.57,66.11 189.57,67.93 v1(189.41,68.1)
  BOTTOM w0.112: JODD1.9 JODD1.10 189.2,67.44 189.55,67.79 189.55,67.95 v1(189.41,68.1)
SATA_ARX_C_DTX_P0: length 7.3
  TOP w0.112: CS9.2 189.45,31.8 189.6,31.8 189.71,31.69 ; CS16.2 190.14,31.69 189.72,31.69 189.71,31.69 ; 189.71,31.69 v1(189.71,31.68)
  BOTTOM w0.112: JHDD1.6 187.7,32.3 188.31,31.68 v1(189.71,31.68)
SATA_ARX_C_DTX_P1: length 7.8
  TOP w0.112: CS22.2 190.41,64.97 190.41,65.65 v2(190.1,65.96) 189.84,66.22 189.84,67.94 v1(189.99,68.1)
  BOTTOM w0.112: JODD1.11 JODD1.12 190.2,67.45 189.9,67.75 189.9,68 v1(189.99,68.1)
SATA_ARX_C_RD_DTX_N0: length 2.3
  TOP w0.112: US1.4 181.47,33.15 181.36,33.03 180.69,33.03 CS6.2
SATA_ARX_C_RD_DTX_P0: length 2.5
  TOP w0.112: CS5.2 180.97,32.77 181.36,32.77 181.47,32.65 US1.5
SATA_ARX_DTX_N0: length 100.1
  TOP w0.099: v1(133.57,75.84) 133.72,75.99 133.72,76.18 133.97,76.42 134.93,76.42 135.83,77.32 135.83,78.12 136.12,78.41 136.78,78.41 136.83,78.46 136.88,78.46 136.9,78.44 136.9,78.44 136.91,78.44 136.93,78.44
  TOP w0.112: RS27.1 178.56,32.87 178.72,32.87 v1(178.9,33.05) 179.08,32.88 179.27,32.88 CS6.1 ; 136.93,78.44 137.97,78.44 138.7,77.72 139.72,77.72 141.02,79.02 145.25,79.02 v1(145.38,79.15)
  IN1 w0.119: v1(178.9,33.05) 178.28,33.05 177.57,33.76 175.79,33.76 175.03,33.01 167.14,33.01 166.03,31.89 164.74,31.89 163.49,33.15 161.24,33.15 161.11,33.28 160.21,33.28 158.8,34.69 154.92,34.69 153.07,36.55 152.15,36.55 146.82,41.88 146.82,44.67 146.19,45.31 145.35,45.31 145.01,44.97 143.74,44.97 142.65,46.06 142.65,52.61 143.21,53.16 143.21,55.81 144.46,57.07 146.43,57.07 147.34,57.98 147.34,61.26 147.25,61.35 147.25,66.39 147.38,66.53 147.38,72.44 147.07,72.75 147.07,74.63 147.48,75.04 147.48,78.46 146.79,79.15 v1(145.38,79.15)
  BOTTOM w0.089: v1(133.57,75.84) 133.57,75.84 133.23,76.18 UC1.R7
SATA_ARX_DTX_N1: length 143
  TOP w0.099: v1(131.31,75.84) 131.98,75.17 134.84,75.17 136.48,76.81 136.63,76.81 136.67,76.77 136.78,76.77
  TOP w0.112: v1(148.14,76.63) 148,76.77 136.78,76.77 ; v1(199.17,38.22) 199.33,38.38 199.33,38.98 199.76,39.41 200.11,39.41 201.01,40.31 201.01,43.28 197.71,46.58 197.71,49.73 193.29,54.15 193.29,56.53 v2(191.83,57.99) 190.15,59.67 190.15,63.42 CS23.1
  IN1 w0.119: v1(148.14,76.63) 148.24,76.73 149.81,76.73 150.41,76.12 150.41,72.03 151.04,71.41 151.04,68.89 150.92,68.78 150.92,65.02 149.74,63.84 149.74,63.34 150.25,62.84 150.6,62.84 150.88,62.55 150.88,55.09 150.44,54.64 150.44,54.27 150.12,53.95 150.12,49.98 149.79,49.65 149.79,43.72 151.66,41.85 151.66,41.21 153.87,39 154.09,39 154.45,38.64 155.72,38.64 157.18,37.17 160.38,37.17 161.58,35.97 164.14,35.97 164.44,35.67 165.06,35.67 165.91,36.52 169.25,36.52 169.81,37.08 172.12,37.08 172.44,37.4 175.22,37.4 176.44,38.62 180.77,38.62 182.33,37.06 187.93,37.06 188.32,37.45 190.06,37.45 190.46,37.85 191.86,37.85 192.8,38.78 199.23,38.78 199.35,38.66 199.35,38.4 v1(199.17,38.22)
  BOTTOM w0.1: UC1.R10 131.31,75.82 v1(131.31,75.84)
SATA_ARX_DTX_P0: length 100.1
  TOP w0.099: v1(134.15,75.79) 134.11,75.79 133.92,75.98 133.92,76.1 134.05,76.23 135.01,76.23 136.03,77.24 136.03,78.04 136.2,78.21 136.88,78.21 136.91,78.18 136.93,78.18
  TOP w0.112: 136.93,78.18 137.86,78.18 138.59,77.46 139.83,77.46 141.13,78.76 145.19,78.76 v1(145.38,78.57) ; RS26.1 178.29,32.33 178.56,32.61 178.77,32.61 v1(178.9,32.47) 179.05,32.61 179.3,32.61 CS5.1
  IN1 w0.119: v1(145.38,78.57) 145.38,78.57 145.71,78.9 146.69,78.9 147.23,78.35 147.23,75.14 146.82,74.73 146.82,72.64 147.13,72.33 147.13,66.63 147,66.5 147,61.25 147.09,61.16 147.09,58.08 146.32,57.32 144.35,57.32 142.95,55.92 142.95,53.27 142.4,52.72 142.4,45.95 143.63,44.72 145.12,44.72 145.45,45.05 146.08,45.05 146.57,44.56 146.57,41.77 152.05,36.29 152.96,36.29 154.81,34.44 158.69,34.44 160.1,33.03 161.01,33.03 161.14,32.9 163.38,32.9 164.64,31.64 166.14,31.64 167.25,32.75 175.14,32.75 175.89,33.51 177.47,33.51 178.18,32.8 178.57,32.8 178.9,32.47 v1(178.9,32.47)
  BOTTOM w0.089: UC1.R6 133.93,76.05 134.15,75.84 134.15,75.79 v1(134.15,75.79)
SATA_ARX_DTX_P1: length 142.9
  TOP w0.099: v1(132.01,75.84) 131.88,75.7 131.88,75.56 132.08,75.37 134.75,75.37 136.39,77.01 136.72,77.01 136.75,77.04 136.78,77.04
  TOP w0.112: v1(199.75,38.22) 199.59,38.38 199.59,38.87 199.87,39.15 200.22,39.15 201.28,40.2 201.28,43.39 197.98,46.69 197.98,49.84 193.56,54.26 193.56,56.64 190.41,59.78 190.41,63.42 CS22.1 ; v1(148.14,77.21) 147.96,77.04 136.78,77.04 136.78,77.04
  IN1 w0.119: v1(148.14,77.21) 148.37,76.98 149.91,76.98 150.67,76.23 150.67,72.14 151.29,71.51 151.29,68.79 151.18,68.67 151.18,64.91 150,63.73 150,63.44 150.35,63.09 150.7,63.09 151.13,62.66 151.13,54.98 150.69,54.54 150.69,54.16 150.37,53.84 150.37,49.88 150.04,49.55 150.04,43.83 151.91,41.95 151.91,41.32 153.97,39.26 154.19,39.26 154.56,38.89 155.82,38.89 157.29,37.42 160.48,37.42 161.68,36.23 164.25,36.23 164.55,35.93 164.95,35.93 165.8,36.77 169.14,36.77 169.7,37.34 172.01,37.34 172.33,37.66 175.12,37.66 176.34,38.88 180.88,38.88 182.44,37.32 187.83,37.32 188.21,37.7 189.95,37.7 190.35,38.1 191.76,38.1 192.7,39.04 199.33,39.04 199.6,38.77 199.6,38.38 v1(199.75,38.22)
  BOTTOM w0.1: UC1.R9 132.01,75.93 v1(132.01,75.84)
SATA_ARX_RD_DTX_N0: length 2.2
  TOP w0.112: CS10.1 188.01,32.15 187.85,32.15 187.31,32.69 187.31,32.78 186.94,33.15 US1.12
SATA_ARX_RD_DTX_P0: length 2.2
  TOP w0.112: CS9.1 188.17,31.45 186.97,32.65 US1.11
SATA_ATX_C_DRX_N0: length 4.8
  TOP w0.112: CS15.2 190.39,33.43 190.23,33.59 189.92,33.59 v1(189.77,33.44) 189.63,33.58 189.39,33.58 CS8.2
  BOTTOM w0.112: v1(189.77,33.44) 189.19,33.44 188.92,33.7 188.92,34.4 189.2,34.68 JHDD1.3
SATA_ATX_C_DRX_N1: length 9.1
  TOP w0.112: v1(188.12,68.13) 187.86,67.87 187.86,67.69 v2(188.54,67.01) 189.01,66.54 189.01,65.99 188.42,65.4 188.42,65.2 188.51,65.11 188.79,65.11 188.95,64.96 CS19.2
  BOTTOM w0.112: JODD1.5 JODD1.6 187.2,67.61 187.31,67.72 187.71,67.72 v1(188.12,68.13)
SATA_ATX_C_DRX_P0: length 4.8
  TOP w0.112: CS11.2 190.39,33.96 190.28,33.85 189.94,33.85 v1(189.77,34.02) 189.59,33.84 189.4,33.84 CS7.2
  BOTTOM w0.112: v1(189.77,34.02) 189.68,34.02 189.57,33.91 189.57,33.82 189.45,33.7 189.3,33.7 189.19,33.81 189.19,34.29 189.46,34.57 189.46,34.89 189.54,34.96 189.63,34.96 189.7,35.03 JHDD1.2
SATA_ATX_C_DRX_P1: length 9.2
  TOP w0.112: v1(187.49,68.13) 187.6,68.02 187.6,67.58 188.75,66.43 188.75,66.1 188.16,65.51 188.16,64.75 CS18.2
  BOTTOM w0.112: v1(187.49,68.13) 186.53,68.13 186.2,67.8 JODD1.4 JODD1.3
SATA_ATX_C_RD_DRX_N0: length 2.4
  TOP w0.112: US1.2 181.47,34.15 181.36,34.27 181.1,34.27 181.02,34.35 180.77,34.35 CS4.2
SATA_ATX_C_RD_DRX_P0: length 2.5
  TOP w0.112: US1.1 181.47,34.65 181.36,34.53 181.21,34.53 181.13,34.61 180.88,34.61 CS3.2
SATA_ATX_DRX_N0: length 82.1
  TOP w0.112: CS4.1 179.6,34.12 179.38,34.35 179.07,34.35 v1(178.94,34.22) 178.94,34.23 178.82,34.35 178.48,34.35 RS25.1
  IN3 w0.135: v1(139.47,76.08) 139.4,76.02 138.94,76.02 138.64,75.71 138.64,75.15 139.42,74.37 140.28,74.37 141.86,72.78 141.86,72.36 144.31,69.92 144.31,68.85 144.14,68.68 144.14,65.72 144.31,65.55 144.31,60.65 143.82,60.17 143.82,56.75 142.91,55.84 142.91,46.08 150.53,38.45 154.31,38.45 155.25,37.52 163.22,37.52 163.44,37.73 164.01,37.73 167.89,33.86 170.3,33.86 170.56,33.6 175.57,33.6 176.2,34.22 v1(178.94,34.22)
  BOTTOM w0.102: UC1.V3 136.4,74.6 137.63,74.6 138.4,75.37 138.4,75.81 138.67,76.08 v1(139.47,76.08)
SATA_ATX_DRX_N1: length 128.1
  TOP w0.112: v1(198.17,37.96) 198.17,37.96 198.17,39.33 199.56,40.72 199.56,44.14 197.27,46.44 197.27,49.59 192.88,53.98 192.88,56.36 v2(190.17,59.06) 189.73,59.5 189.73,60.58 188.95,61.36 CS19.1
  IN3 w0.135: v1(143.3,76.36) 143.81,76.36 143.82,76.37 144.6,76.37 146.22,74.74 146.22,72.9 149.22,69.9 149.22,63.63 149.44,63.41 149.44,63.09 149.98,62.55 149.98,59.13 152.09,57.02 152.09,50.95 152.32,50.72 152.32,49.22 151.58,48.48 151.58,43.31 152.66,42.23 152.66,42.03 152.96,41.74 163.28,41.74 164.23,40.78 165.49,40.78 166.5,39.78 172.81,39.78 173.8,38.78 175.87,38.78 176.54,39.46 180.83,39.46 181.16,39.79 189.1,39.79 189.19,39.71 197.07,39.71 198.17,38.61 v1(198.17,37.96)
  BOTTOM w0.102: v1(143.3,76.36) 142.31,76.36 142.26,76.31 140.41,76.31 139.93,76.79 138.7,76.79 137.92,76.01 137.92,75.44 137.47,74.99 136.46,74.99 136.27,75.11 136.01,75.11 UC1.U4
SATA_ATX_DRX_P0: length 82.3
  TOP w0.112: RS22.1 178.29,34.92 178.56,34.65 178.78,34.65 v1(178.94,34.81) 179.14,34.61 179.42,34.61 179.6,34.79 CS3.1
  IN3 w0.135: v1(139.47,75.5) 139.24,75.73 139.06,75.73 138.92,75.59 138.92,75.27 139.53,74.65 140.39,74.65 142.15,72.9 142.15,72.48 144.59,70.04 144.59,68.73 144.42,68.56 144.42,65.84 144.59,65.67 144.59,60.53 144.11,60.05 144.11,56.64 143.19,55.72 143.19,46.2 150.65,38.74 154.43,38.74 155.37,37.8 163.1,37.8 163.32,38.02 164.13,38.02 168.01,34.14 170.42,34.14 170.68,33.88 175.46,33.88 176.08,34.51 178.63,34.51 178.7,34.58 178.71,34.58 v1(178.94,34.81)
  BOTTOM w0.102: UC1.V1 136.61,74.39 136.62,74.4 137.71,74.4 138.6,75.29 138.6,75.73 138.76,75.88 138.92,75.88 139.02,75.78 139.02,74.98 139.12,74.87 139.36,74.87 139.47,74.98 v1(139.47,75.5)
