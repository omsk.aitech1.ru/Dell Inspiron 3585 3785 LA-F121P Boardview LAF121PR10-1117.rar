# Allegro board LAF121PR10-1117.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SY8286BRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8288CRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
TAI-T_HCB2012KF-121T50_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
TAI-T_HCB2012KF-221T30_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
TC7SH32FU_SSOP5
  oval 0.381x1.422 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.7) 5(0,1.7)
TPC12
  round 0.305 smd: 1(0,0)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS22966DPUR_SON14_2X3-S
  oval 0.254x0.813 smd: 1(0,0) 2(0.4,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 13(0.4,2.05) 14(0,2.05)
  oval 0.203x0.762 smd: 3(0.8,0) 4(1.2,0) 5(1.6,0) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TUSB544RNQ_QFN40_4X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 21(6.1,-2.8) 22(6.1,-2.4) 23(6.1,-2) 24(6.1,-1.6) 25(6.1,-1.2) 26(6.1,-0.8) 27(6.1,-0.4) 28(6.1,0)
  oval 0.203x0.889 smd: 9(0.85,-3.45) 10(1.25,-3.45) 11(1.65,-3.45) 12(2.05,-3.45) 13(2.45,-3.45) 14(2.85,-3.45) 15(3.25,-3.45) 16(3.65,-3.45) 17(4.05,-3.45) 18(4.45,-3.45) 19(4.85,-3.45) 20(5.25,-3.45) 29(5.25,0.65) 30(4.85,0.65) 31(4.45,0.65) 32(4.05,0.65) 33(3.65,0.65) 34(3.25,0.65) 35(2.85,0.65) 36(2.45,0.65) 37(2.05,0.65) 38(1.65,0.65) 39(1.25,0.65) 40(0.85,0.65)
  rect 4.699x2.692 smd: 41(3.05,-1.4)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
Y_5YEA12000122IFA2Q3_4P
  rect 1.295x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_7V25000014_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_7V27000011_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_CM31532768DZFT_2P
  rect 1.092x1.905 smd: 1(0,0) 2(2.5,0)
Y_X3S048000D81H-W_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
YUQIU_PJ753-F07J1BE-B_7P-T
  oval 0.991x1.803 hole 0.61x1.397: 1(0,0) 2(9.5,-5.5) 3(9.5,-8.6) 4(0,-7.8) 5(9.5,0) 6(9.5,-2.75) 7(0,-2.65)

## Nets
0.9VS_GATE: C52.1 Q7.1 R28.2 U7.4
0.9VS_PWR_EN#: Q7.2 R702.2 RE31.1 UE1.99
0.95V_VIN: PCF01.1 PJPF01.2 PUF01.3
1.8VALW_VIN: PC1801.1 PC1808.1 PC1809.1 PC1810.1 PJP1801.2 PL1811.2 PU1801.8 PU1801.9 PU1801.10
1.8VSDGPU_ON: C31.2 R23.2 U3.5
2.5V_VIN: PC2501.1 PJP2501.2 PU2501.3
3.3V_TS_EN: U5.4 UC1.AW13
3V_FB: PC315.1 PR307.2 PR308.1 PU301.13
3V_SN: PC309.1 PR305.2
3V_VIN: PC301.1 PC302.1 PC303.1 PC304.1 PC305.1 PC306.1 PC316.1 PJP301.2 PL311.2 PU301.2 PU301.3 PU301.4 PU301.5
3VS: J4.2 U6.13 U6.14
3VS_GATE: C35.2 R26.2 R704.2 U6.3
3VSDGPU_ON: C26.2 R438.2 U3.3
5V_FB: PC517.1 PR510.2 PR511.1 PU501.13
5V_SN: PC509.1 PR505.2
5V_VIN: PC501.1 PC502.1 PC503.1 PC504.1 PC505.1 PC506.1 PC518.1 PJP501.2 PL511.2 PU501.2 PU501.3 PU501.4 PU501.5
5VS: J1.2 J3.2 U4.13 U4.14
5VS_GATE: C23.2 R24.2 R705.2 U4.3
+0.6V_DDR_VTT: CD16.1 CD17.1 CD18.1 CD22.1 CD23.1 CD30.1 CD31.1 CD55.1 CD56.1 CD57.1 JDIMM1.258 JDIMM2.258 PJPM03.2
+0.6VSP: PCM20.1 PCM21.1 PJPM03.1 PUM01.2 PUM01.20
+0.9VALW: C45.1 CC75.1 CC76.1 CC77.1 CC78.1 PJPH02.2 RC6128.2 U7.5
+0.9VALW_APU: RC6128.1 UC1.AL14 UC1.AL15 UC1.AM14
+0.9VS: C46.1 C47.1 CC79.1 CC80.1 CC81.1 CC82.1 CC83.1 CC84.1 CC85.1 CC86.1 CC87.1 CC88.1 CC89.1 RC13.2 U7.1 U7.2 U7.3 UC1.AL13 UC1.AM12 UC1.AM13 UC1.AN12 UC1.AN13
+0.95VSDGPU: LV8.1 PJPF02.2 RV1.2 RV3.2 RV30.1 RV31.1 RV364.2
+0.95VSDGPUP: PCF02.1 PCF05.1 PCF06.1 PJPF02.1 PRF02.1 PUF01.6
+1.2V_DDR: CC21.1 CC22.1 CC23.1 CC24.1 CC25.1 CC26.1 CC27.1 CC28.1 CC29.1 CC30.1 CC31.1 CC32.1 CC33.1 CC34.1 CC35.1 CC36.1 CC37.1 CC38.1 CD2.1 CD3.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD19.1 CD20.1 CD21.1 CD27.1 CD28.1 CD29.1 CD35.1 CD41.1 CD42.1 CD43.1 CD44.1 CD45.1 CD46.1 CD47.1 CD48.1 CD49.1 CD50.1 CD51.1 CD52.1 CD53.1 CD54.1 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 PJPF01.1 PJPM02.2 RC1.1 RC2.1 RD1.2 RD3.2 UC1.AA20 UC1.AA23 UC1.AA26 UC1.AA28 UC1.AA32 UC1.AC20 UC1.AC22 UC1.AC25 UC1.AC28 UC1.AD23 UC1.AD26 UC1.AD28 UC1.AD32 UC1.AE20 UC1.AE22 UC1.AE25 UC1.AE28 UC1.AF23 UC1.AF26 UC1.AF28 UC1.AF32 UC1.AG20 UC1.AG22 UC1.AG25 UC1.AG28 UC1.AJ20 UC1.AJ23 UC1.AJ26 UC1.AJ28 UC1.AJ32 UC1.AK28 UC1.AL28 UC1.AL32 UC1.T32 UC1.V28 UC1.W28 UC1.W32 UC1.Y22 UC1.Y25 UC1.Y28
+1.2VP: PCM05.1 PCM06.1 PCM07.1 PCM08.1 PCM09.1 PCM10.1 PCM17.2 PCM18.1 PJPM02.1 PLM01.1 PRM10.2 PUM01.5 PUM01.19
+1.8V_ALW: C32.1 C43.2 CC69.1 CC70.1 CC71.1 PJP1802.2 QC3.2 QC3.5 RC47.1 RC54.1 RC94.1 RC95.1 RC1672.1 RC6125.1 RC6129.1 RE40.1 RH26.2 RPH1.5 RPH1.6 RPH1.7 RPH1.8 U3.6 U3.7 U6.6 U6.7
+1.8V_ALW_APU: RC6129.2 UC1.AL19 UC1.AM18
+1.8V_AVDD: CA53.1 RA53.1 UA1.40
+1.8VALWP: PC1802.1 PC1803.1 PC1804.1 PC1807.1 PJP1802.1 PL1801.2 PR1807.1
+1.8VGS: C33.1 CV38.1 CV39.1 CV46.1 CV179.1 LV2.1 LV3.1 LV6.1 LV7.1 PRV12.1 RV8.1 RV11.1 RV15.1 RV27.1 RV28.1 RV71.1 RV81.2 RV82.2 RV152.2 U3.8 U3.9 UV1.AM30
+1.8VS: CC72.1 CC73.1 CC74.1 J5.2 PRZ16.1 QA1.1 QC1.2 RA56.2 RC6.1 RC7.1 RC8.1 RC10.2 RC12.1 RC15.1 RC97.1 RC622.1 RC1700.1 RPC30.1 RPC30.2 RPC30.3 RPC30.4 RX27.1 UC1.AL20 UC1.AM19 UC2.5 UC5.5
+1.8VS_GATE: C42.2 R27.2 R703.2 U6.5
+1.8VS_LS: C44.2 J5.1 U6.8 U6.9
+1.35V_MEM_GFX: CV40.1 CV41.1 CV42.1 CV43.1 CV44.1 CV45.1 CV47.1 CV48.1 CV49.1 CV50.1 CV51.1 CV52.1 CV53.1 CV153.1 CV155.1 CV157.1 CV158.1 CV160.1 CV161.1 CV162.1 CV164.1 CV165.1 CV166.1 CV169.1 CV170.1 CV173.1 CV174.1 CV175.1 CV176.1 CV177.1 CV178.1 CV198.1 CV210.1 CV211.1 CV213.1 CV216.1 CV219.1 CV221.1 CV225.1 CV227.1 CV230.1 CV233.1 CV235.1 CV238.1 CV242.1 CV243.1 CV247.1 CV248.1 CV333.1 CV334.1 CV335.1 CV336.1 CV341.1 CV342.1 CV343.1 CV344.1 PJPW02.2 RV32.1 RV33.1 RV48.1 RV50.1 RV52.1 RV54.1 RV79.1 RV80.1 RV85.1 RV86.1 RV117.2 RV131.2 UV1.H13 UV1.H16 UV1.H19 UV1.J9 UV1.J10 UV1.J23 UV1.J24 UV1.K9 UV1.K10 UV1.K23 UV1.K24 UV1.L11 UV1.L12 UV1.L13 UV1.L20 UV1.L21 UV1.L22 UV12.B1 UV12.B3 UV12.B12 UV12.B14 UV12.C5 UV12.C10 UV12.D1 UV12.D3 UV12.D11 UV12.D12 UV12.D13 UV12.D14 UV12.E5 UV12.E10 UV12.F1 UV12.F3 UV12.F12 UV12.F14 UV12.G1 UV12.G2 UV12.G4 UV12.G11 UV12.G13 UV12.G14 UV12.H3 UV12.H12 UV12.K3 UV12.K12 UV12.L1 UV12.L2 UV12.L4 UV12.L11 UV12.L13 UV12.L14 UV12.M1 UV12.M3 UV12.M12 UV12.M14 UV12.N5 UV12.N10 UV12.P1 UV12.P2 UV12.P3 UV12.P11 UV12.P12 UV12.P14 UV12.R5 UV12.R10 UV12.T1 UV12.T3 UV12.T12 UV12.T14 UV13.B1 UV13.B3 UV13.B12 UV13.B14 UV13.C5 UV13.C10 UV13.D1 UV13.D3 UV13.D11 UV13.D12 UV13.D13 UV13.D14 UV13.E5 UV13.E10 UV13.F1 UV13.F3 UV13.F12 UV13.F14 UV13.G1 UV13.G2 UV13.G4 UV13.G11 UV13.G13 UV13.G14 UV13.H3 UV13.H12 UV13.K3 UV13.K12 UV13.L1 UV13.L2 UV13.L4 UV13.L11 UV13.L13 UV13.L14 UV13.M1 UV13.M3 UV13.M12 UV13.M14 UV13.N5 UV13.N10 UV13.P1 UV13.P2 UV13.P3 UV13.P11 UV13.P12 UV13.P14 UV13.R5 UV13.R10 UV13.T1 UV13.T3 UV13.T12 UV13.T14 UV14.B1 UV14.B3 UV14.B12 UV14.B14 UV14.C5 UV14.C10 UV14.D1 UV14.D3 UV14.D11 UV14.D12 UV14.D13 UV14.D14 UV14.E5 UV14.E10 UV14.F1 UV14.F3 UV14.F12 UV14.F14 UV14.G1 UV14.G2 UV14.G4 UV14.G11 UV14.G13 UV14.G14 UV14.H3 UV14.H12 UV14.K3 UV14.K12 UV14.L1 UV14.L2 UV14.L4 UV14.L11 UV14.L13 UV14.L14 UV14.M1 UV14.M3 UV14.M12 UV14.M14 UV14.N5 UV14.N10 UV14.P1 UV14.P2 UV14.P3 UV14.P11 UV14.P12 UV14.P14 UV14.R5 UV14.R10 UV14.T1 UV14.T3 UV14.T12 UV14.T14 UV15.B1 UV15.B3 UV15.B12 UV15.B14 UV15.C5 UV15.C10 UV15.D1 UV15.D3 UV15.D11 UV15.D12 UV15.D13 UV15.D14 UV15.E5 UV15.E10 UV15.F1 UV15.F3 UV15.F12 UV15.F14 UV15.G1 UV15.G2 UV15.G4 UV15.G11 UV15.G13 UV15.G14 UV15.H3 UV15.H12 UV15.K3 UV15.K12 UV15.L1 UV15.L2 UV15.L4 UV15.L11 UV15.L13 UV15.L14 UV15.M1 UV15.M3 UV15.M12 UV15.M14 UV15.N5 UV15.N10 UV15.P1 UV15.P2 UV15.P3 UV15.P11 UV15.P12 UV15.P14 UV15.R5 UV15.R10 UV15.T1 UV15.T3 UV15.T12 UV15.T14
+1.35VGPUP: PCW05.1 PCW06.1 PCW07.1 PCW08.1 PCW14.1 PJPW02.1 PLW01.2 PRW09.2
+2.5V_MEM: CD34.1 CD36.1 CD37.1 CD39.1 CD64.1 CD65.1 CD66.1 CD68.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 PJP2502.2
+2.5VP: PC2502.1 PC2505.1 PJP2502.1 PR2502.1 PU2501.6
+3.3V_ADP_DCIN: PC9.1 PD11.2 PDS01.2 PR14.1 PR22.1 PR60.1 PRS04.1 PRS32.1 PRS34.1 PRS44.2 PRS65.1 PU1.5
+3.3V_VBUS_IN: PCS13.1 PCS14.1 PCS16.1 PD11.3 PDS01.3 PRB38.1 PRS12.1 PRS13.1 PUS02.5 PUS03.5 PUS04.3
+3.3V_VDD_PIC: CT5.1 CT6.1 CT7.1 CT49.1 CT50.1 DT1.1 DT2.1 JCCG4_T.1 RE508.2 RT2.1 RT4.1 RT6.1 RT64.1 RT70.1 RT71.1 RT130.2 UT1.31 UT1.32
+3V_1.8V_CPVDD: CA12.1 CA14.1 RA7.2 RA58.2 UA1.36
+3V_DVDD: CA7.1 CA9.1 CA16.1 CA46.1 RA2.1 RA7.1 RA8.2 RA10.2 UA1.1
+3V_HUB: C60.1 R56.1 R58.1 R59.1 R61.1 R63.1 R801.1 U58.13 U58.21
+3VALW: C48.1 C49.1 CC13.1 CL3.1 CT32.1 CX2.1 CX8.1 DT1.2 JP3.2 JPWR1.4 PJP302.2 PJP1801.1 PJP2501.1 PL1811.1 PR5.2 PR33.1 PR41.2 PR1803.1 PRB27.1 PRH03.1 PRH05.1 PRH18.1 PRM06.1 PRS28.1 PRW03.1 QT6.2 QT6.5 R15.1 R801.2 RA54.1 RC17.2 RC33.1 RC40.1 RC41.2 RC48.2 RC53.1 RC56.1 RC619.2 RC905.1 RC906.1 RC6121.1 RC6122.1 RC6126.1 RC6127.2 RC6130.1 RE5.2 RE6.2 RE8.2 RE17.1 RE19.1 RE23.1 RE24.1 RE509.1 RE510.1 RL1.1 RT17.1 RT18.1 RT19.1 RT20.1 RT21.1 RT22.1 RT23.1 RT24.1 RT25.1 RT26.1 RT27.1 RT28.1 RT29.1 RT30.1 RT31.2 RT35.1 RT36.1 RT37.1 RT72.1 RT73.1 RT131.1 RV165.2 RW13.1 U6.1 U6.2 UC4.5 UC9.5 UC20.5 UC21.5 UL2.5 UW1.5 UX1.1
+3VALW_APU: CC66.1 CC67.1 CC68.1 RC6126.2 UC1.AL17 UC1.AM16 UC20.1
+3VALW_EC: CE2.1 CE3.2 CE4.1 CE5.1 CE6.1 CE7.2 LE1.1 PR64.1 RE6.1 RE31.2 RE42.1 RE506.2 RE507.2 RE508.1 UC3.5 UE1.9 UE1.22 UE1.33 UE1.96 UE1.125
+3VALW_TYPEC: CT33.1 CT34.1 CT35.1 CT36.1 RT131.2 UT9.1 UT9.6 UT9.20 UT9.28
+3VALWP: PC310.1 PC311.1 PC312.1 PC313.1 PC314.1 PJP302.1 PL301.2 PR304.1 PR306.2 PR307.1 PR504.1 PU301.14
+3VGS: C25.1 LV4.1 PRV14.1 QV1.2 QV1.5 RPV34.1 RPV34.2 RPV34.3 RPV34.4 RV5.1 RV6.1 RV154.1 RV162.1 RV164.1 RV260.1 U3.13 U3.14 UV2.5
+3VLP: JP2.1 PC308.1 PU301.16 PU301.17 RE12.1 RE44.1
+3VS: C5.1 C34.1 C39.1 C40.1 C53.1 C54.1 CD38.1 CD67.1 CS1.1 CS2.1 CS20.1 CS21.1 CW5.1 CX3.1 J4.1 JCRT.14 JCRT.15 JDIMM1.255 JDIMM2.255 JDIMM2.256 JIOB1.12 JP10.2 PRV17.1 PRW05.1 PRZ15.1 PRZ24.1 Q5.2 Q11.2 Q11.5 QA1.2 QI1.2 QI2.1 QI3.2 QI3.5 QW1.2 R9.1 R18.1 R31.1 R32.1 R33.1 R34.1 R36.2 R56.2 R82.1 R83.1 R700.1 RA2.2 RC3.2 RC4.2 RC5.2 RC24.1 RC25.1 RC26.1 RC34.1 RC46.1 RC96.1 RC615.1 RC620.1 RC621.1 RC663.1 RC664.1 RC712.2 RC938.1 RC1695.1 RC1696.1 RC1697.1 RC1707.1 RC6123.2 RC6124.2 RE2.2 RE25.1 RF1.2 RF2.2 RI20.1 RL12.1 RL15.2 RM1.1 RPC3.6 RPC3.7 RPC3.8 RPC64.7 RPC64.8 RPI3.7 RPI3.8 RS3.2 RS4.2 RS5.1 RS6.1 RS7.1 RS8.1 RS9.1 RS10.1 RS11.1 RS12.1 RS15.2 RS29.1 RW2.2 RX7.1 RX26.1 U2.5 U3.1 U3.2 U8.1 US4.2 US4.3 US4.9 US4.10
+3VS_APU: CC65.1 CC1189.1 CC1190.1 RC96.2 UC1.AL18 UC1.AM17
+3VS_CAM: C14.1 JEDP1.29 RW2.1
+3VS_SSD: CS29.1 CS31.1 CS32.1 CS33.1 CS70.1 CS71.1 CS72.1 CS73.1 JP10.1 JSSD1.2 JSSD1.4 JSSD1.12 JSSD1.14 JSSD1.16 JSSD1.18 JSSD1.70 JSSD1.72 JSSD1.74
+3VS_TOUCH: C18.1 JTP1.8 Q1.2 Q2.1 R11.1 R13.2 R14.2 R16.2 RP4.6 RP4.7 RP4.8
+3VS_WLAN_NGFF: CW7.1 CW8.2 CW9.1 CW10.1 CW11.1 CW12.2 CW13.1 CW14.1 CW15.1 CW16.1 JWLAN1.2 JWLAN1.4 JWLAN1.72 JWLAN1.74 RM1.2 RW8.1 UW1.1
+5V_AVDD: CA6.1 CA10.1 RA52.2 UA1.26
+5V_CONN_P1: CT3.1 CT4.1 UT1.8 UT3.3
+5V_HDD: CS12.1 CS13.1 CS14.1 JHDD1.10 JHDD1.11 JHDD1.12 JP4.2 RS28.1 US5.1
+5V_HDMI: CI3.1 FI1.1 JHDMI1.18 RPI3.5 RPI3.6
+5V_PVDD: CA1.1 CA2.1 CA3.1 CA4.1 RA38.1 UA1.41 UA1.46
+5V_USB_PWR1: CU1.1 CU2.1 CU3.1 CU4.1 CU11.1 CU12.1 CU13.1 CU14.1 JUSB1.1 JUSB2.1 UI1.1
+5V_USB_PWR2: JIOB1.13 JIOB1.14 JIOB1.15 JIOB1.16 UU1.1
+5VALW: C50.1 C51.1 CS40.1 CT12.1 CT62.2 CU5.1 CU6.1 CU17.1 CU18.1 PCV12.1 PD2.3 PD3.3 PJP502.2 PJP503.2 PR4.1 PR2504.1 PRF04.1 PRH11.2 PRM04.1 PRM05.2 PRV13.1 PRW11.2 PUV01.26 PUV01.31 Q14.2 Q14.5 Q15.3 Q16.3 R28.1 RE18.2 U3.4 U4.1 U4.2 U4.4 U6.4 UI1.5 US5.5 UT3.1 UT8.5 UU1.5
+5VALWP: PC510.1 PC511.1 PC512.1 PC513.1 PC514.1 PC519.1 PJP502.1 PJP503.1 PL501.2 PR509.2 PR510.1 PU501.14
+5VS: C29.1 C30.1 CE1.1 CF1.1 F3.1 FI1.2 J1.1 J3.1 JCRT.16 JFAN1.1 JP4.1 JP5.1 PCZ23.1 PRZ17.2 PUZ01.26 Q6.3 R701.1 RA38.2 RA52.1 RE1.1 RE4.1 RF3.2 RS60.2 RW3.1
+5VS_KBL: C19.1 F3.2 JKBBL1.1 RE1.2
+5VS_ODD: CS24.1 CS25.1 CS26.1 JODD1.17 JODD1.18 JODD1.19 JODD1.20 JODD1.21 JODD1.22 JP5.2
+17.4V_BATT+: PC11.1 PJP3.1 PL4.1 PQB03.5 PRB39.1
+17.4V_BATT++: PBATT1.8 PBATT1.9 PBATT1.10 PC12.1 PC17.1 PC18.1 PJP3.2 PL4.2
+19V_ADPIN: PC1.1 PC2.1 PC15.1 PJP1.1 PJPDC1.5 PJPDC1.6 PL1.1
+19VB: F1.1 PCB10.1 PCB11.1 PCB12.1 PCB13.1 PCB14.1 PCB15.1 PCB16.1 PCB17.1 PCB21.1 PCB22.1 PCB23.1 PCB24.1 PCB46.1 PDB01.2 PJP301.1 PJP501.1 PJPA01.1 PJPH01.1 PJPM01.1 PJPV01.1 PJPW01.1 PJPZ01.1 PL311.1 PL511.1 PLH11.1 PLM11.1 PLV11.1 PLW11.1 PLZ01.2 PQB02.2 PR302.2 PRB12.1 PRB21.2 PRH16.1 R5.1
+19VB_1.2V: PCM01.1 PCM02.1 PCM03.1 PCM04.1 PCM22.1 PCM23.1 PCM24.1 PJPM01.2 PLM11.2 PQM01.2 PQM01.3 PQM01.4 PQM01.10 PRM07.1
+19VB_+1.35VGPU: PCW01.1 PCW02.1 PCW03.1 PCW04.1 PCW15.1 PCW16.1 PCW17.1 PJPW01.2 PLW11.2 PUW01.5
+19VB_+VDDP: PCH01.1 PCH02.1 PCH03.1 PCH04.1 PCH15.1 PCH16.1 PCH17.1 PJPH01.2 PLH11.2 PUH01.5
+19VB_APU: PCZ10.1 PCZ12.1 PCZ13.1 PCZ14.1 PCZ15.1 PCZ16.1 PCZ17.1 PCZ18.1 PCZ19.1 PCZ20.1 PCZ35.1 PCZ36.1 PCZ37.1 PCZ38.1 PCZ39.1 PCZ40.1 PCZ41.1 PCZ43.1 PCZ44.1 PCZ45.1 PJPZ01.2 PLZ01.1 PQZ01.2 PQZ02.2 PQZ03.2 PQZ04.2
+19VB_NB: PCA01.1 PCA02.1 PCA03.1 PCA04.1 PCA05.1 PCA06.1 PJPA01.2 PQA01.2
+19VB_VGA: PCV01.1 PCV02.1 PCV03.1 PCV04.1 PCV05.1 PCV06.1 PCV07.1 PCV13.1 PCV14.1 PCV15.1 PCV16.1 PCV17.1 PCV18.1 PCV19.1 PCV35.1 PCV36.1 PJPV01.2 PLV11.2 PQV01.2 PQV02.2 PQV03.2 PQV04.2
+V18R: RE40.2 RE42.2 UE1.124
+VBUS_DC_SS: PCS63.1 PDB02.2 PDS02.2 PDS02.3 PQS01.5 PQS02.5
+VCC_TPM: CX9.1 CX10.1 CX11.1 CX12.1 CX13.1 RX26.2 RX27.2 RX28.1 RX38.1 RX39.1 UX1.8 UX1.14 UX1.22
+VDD_CT: CV61.1 CV62.1 CV63.1 LV3.2 UV1.AA20 UV1.AA21 UV1.AB20 UV1.AB21
+VDD_TOUCH: F2.2 JEDP1.40 R300.2 RW4.2 U5.1
+VDDP_ALWP: PCH05.1 PCH06.1 PCH07.1 PCH08.1 PCH14.1 PJPH02.1 PLH01.2 PRH10.1
+VDDR3: CV64.1 CV65.1 CV66.1 CV123.1 LV4.2 UV1.AA17 UV1.AA18 UV1.AB17 UV1.AB18
GND: C1.2 C5.2 C12.2 C13.2 C14.2 C15.2 C16.2 C18.2 C19.2 C20.2 C21.2 C23.1 C24.2 C25.2 C26.1 C27.2 C28.2 C29.2 C30.2 C31.1 C32.2 C33.2 C34.2 C35.1 C38.2 C39.2 C40.2 C41.1 C42.1 C43.1 C44.1 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C57.2 C58.2 C60.2 C61.2 C65.2 C66.2 C310.2 C636.2 C796.2 C797.2 CA1.2 CA2.2 CA3.2 CA4.2 CA7.2 CA9.2 CA12.2 CA14.2 CA16.2 CA17.2 CA21.1 CA25.1 CA26.1 CA27.1 CA28.1 CA29.1 CA30.2 CA31.2 CA46.2 CA49.2 CA50.2 CA51.2 CA52.2 CA54.1 CA55.2 CA66.2 CC5.1 CC6.1 CC7.2 CC8.2 CC9.1 CC10.1 CC11.2 CC12.2 CC13.2 CC14.2 CC15.2 CC16.2 CC21.2 CC22.2 CC23.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CC53.2 CC54.2 CC55.2 CC56.2 CC57.2 CC58.2 CC59.2 CC60.2 CC61.2 CC62.2 CC63.2 CC64.2 CC65.2 CC66.2 CC67.2 CC68.2 CC69.2 CC70.2 CC71.2 CC72.2 CC73.2 CC74.2 CC75.2 CC76.2 CC77.2 CC78.2 CC79.2 CC80.2 CC81.2 CC82.2 CC83.2 CC84.2 CC85.2 CC86.2 CC87.2 CC88.2 CC89.2 CC90.2 CC91.2 CC92.2 CC93.2 CC94.2 CC95.2 CC100.1 CC250.1 CC251.2 CC615.1 CC635.2 CC682.2 CC686.2 CC1189.2 CC1190.2 CC1191.2 CC1192.2 CC1193.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CE1.2 CE2.2 CE3.1 CE4.2 CE5.2 CE6.2 CE7.1 CE9.2 CE12.2 CE13.2 CE14.1 CE16.2 CE17.2 CE18.2 CE19.2 CF1.2 CH2.2 CH3.2 CH4.2 CI3.2 CI10.2 CL3.2 CL4.2 CL5.2 CL6.2 CL9.1 CL10.2 CL11.2 CL12.2 CL15.2 CL18.2 CL19.2 CL20.2 CL21.2 CL22.2 CL23.2 CL24.2 CL25.2 CLIP2.1(TP-1) CLRP1.2 CS1.2 CS2.2 CS12.2 CS13.2 CS14.2 CS20.2 CS21.2 CS24.2 CS25.2 CS26.2 CS29.2 CS31.2 CS32.2 CS33.2 CS40.2 CS70.2 CS71.2 CS72.2 CS73.2 CT3.2 CT4.2 CT5.2 CT6.2 CT7.2 CT8.2 CT9.2 CT10.2 CT11.2 CT12.2 CT13.2 CT17.2 CT21.2 CT22.2 CT26.2 CT27.2 CT28.2 CT29.2 CT32.2 CT33.2 CT34.2 CT35.2 CT36.2 CT46.2 CT49.2 CT50.2 CT53.2 CT54.2 CT55.2 CT56.2 CT57.2 CT62.1 CU1.2 CU2.2 CU3.2 CU4.2 CU5.2 CU6.2 CU9.2 CU10.2 CU11.2 CU12.2 CU13.2 CU14.2 CU17.2 CU18.2 CU19.2 CU20.2 CU37.2 CV11.2 CV15.2 CV17.2 CV18.2 CV19.2 CV20.2 CV21.2 CV25.2 CV26.2 CV27.2 CV28.2 CV29.2 CV30.2 CV33.2 CV34.2 CV35.2 CV38.2 CV39.2 CV40.2 CV41.2 CV42.2 CV43.2 CV44.2 CV45.2 CV46.2 CV47.2 CV48.2 CV49.2 CV50.2 CV51.2 CV52.2 CV53.2 CV54.2 CV55.2 CV56.2 CV57.2 CV58.2 CV59.2 CV60.2 CV61.2 CV62.2 CV63.2 CV64.2 CV65.2 CV66.2 CV67.2 CV68.2 CV69.2 CV70.2 CV71.2 CV72.2 CV73.2 CV74.2 CV75.2 CV76.2 CV77.2 CV78.2 CV79.2 CV80.2 CV81.2 CV82.2 CV84.2 CV85.2 CV86.2 CV87.2 CV88.2 CV89.2 CV90.2 CV91.2 CV92.2 CV93.2 CV94.2 CV95.2 CV96.2 CV97.2 CV100.2 CV101.2 CV102.2 CV103.2 CV104.2 CV105.2 CV106.2 CV107.2 CV108.2 CV109.2 CV110.2 CV111.2 CV112.2 CV113.2 CV114.2 CV115.2 CV116.2 CV117.2 CV118.2 CV119.2 CV120.2 CV121.2 CV122.2 CV123.2 CV124.2 CV125.2 CV126.2 CV127.2 CV153.2 CV155.2 CV157.2 CV158.2 CV160.2 CV161.2 CV162.2 CV164.2 CV165.2 CV166.2 CV169.2 CV170.2 CV173.2 CV174.2 CV175.2 CV176.2 CV177.2 CV178.2 CV179.2 CV180.1 CV181.1 CV198.2 CV210.2 CV211.2 CV213.2 CV216.2 CV219.2 CV221.2 CV225.2 CV227.2 CV230.2 CV233.2 CV235.2 CV238.2 CV242.2 CV243.2 CV247.2 CV248.2 CV333.2 CV334.2 CV335.2 CV336.2 CV341.2 CV342.2 CV343.2 CV344.2 CV390.2 CV391.2 CV394.2 CV395.2 CW5.2 CW6.2 CW7.2 CW8.1 CW9.2 CW10.2 CW11.2 CW12.1 CW13.2 CW14.2 CW15.2 CW16.2 CX2.2 CX3.2 CX8.2 CX9.2 CX10.2 CX11.2 CX12.2 CX13.2 D2.1 DA1.1 DA2.1 DA5.1 DA6.1 DT3.2 DT4.2 DT5.2 DT6.2 DT7.2 DT8.2 DT9.2 DT10.2 DU2.1 DX3.1 EC1.2 EC2.2 ED2.1 EU2.1 EU3.3 EU4.1 EU5.3 EU7.3 EU8.3 EU4012.1 H1.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) HCPU1.1(TP-1) HCPU2.1(TP-1) HCPU3.1(TP-1) HCPU4.1(TP-1) JCCG4_T.2 JCRT.1 JCRT.4 JCRT.7 JCRT.10 JCRT.17 JCRT.18 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.166 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.256 JDIMM1.260 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.166 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.260 JDIMM2.261 JDIMM2.262 JEDP1.13 JEDP1.17 JEDP1.20 JEDP1.23 JEDP1.32 JEDP1.35 JEDP1.38 JEDP1.41 JEDP1.42 JFAN1.4 JFAN1.5 JFAN1.6 JFP.1 JFP.2 JFP.7 JFP.8 JFP1.1 JFP1.3 JFP1.4 JFP1.9 JFP1.10 JH1.4 JHDD1.1 JHDD1.4 JHDD1.7 JHDD1.13 JHDD1.14 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIOB1.1 JIOB1.2 JIOB1.5 JIOB1.8 JIOB1.9 JIOB1.10 JIOB1.17 JIOB1.18 JKB1.31 JKB1.32 JKBBL1.5 JKBBL1.6 JODD1.1 JODD1.2 JODD1.7 JODD1.8 JODD1.13 JODD1.14 JODD1.25 JODD1.26 JPWR1.1 JPWR1.5 JPWR1.6 JRJ45.9 JRJ45.10 JRJ45.11 JRJ45.12 JSPK1.5 JSPK1.6 JSSD1.1 JSSD1.3 JSSD1.9 JSSD1.15 JSSD1.21 JSSD1.27 JSSD1.33 JSSD1.39 JSSD1.45 JSSD1.51 JSSD1.57 JSSD1.71 JSSD1.73 JSSD1.75 JSSD1.76 JSSD1.77 JTP1.5 JTP1.9 JTP1.10 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JWLAN1.1 JWLAN1.7 JWLAN1.18 JWLAN1.26 JWLAN1.33 JWLAN1.39 JWLAN1.45 JWLAN1.51 JWLAN1.57 JWLAN1.63 JWLAN1.69 JWLAN1.75 JWLAN1.76 JWLAN1.77 LE2.1 LED1.1 LED1.3 PBATT1.1 PBATT1.2 PBATT1.3 PBATT1.4 PBATT1.11 PBATT1.12 PC1.2 PC2.2 PC3.2 PC4.2 PC7.2 PC8.2 PC9.2 PC10.2 PC11.2 PC12.2 PC15.2 PC16.2 PC17.2 PC18.2 PC21.2 PC22.2 PC23.2 PC301.2 PC302.2 PC303.2 PC304.2 PC305.2 PC306.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC314.2 PC316.2 PC501.2 PC502.2 PC503.2 PC504.2 PC505.2 PC506.2 PC508.2 PC509.2 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC516.2 PC518.2 PC519.2 PC1801.2 PC1802.2 PC1803.2 PC1804.2 PC1805.2 PC1806.2 PC1808.2 PC1809.2 PC1810.2 PC2501.2 PC2502.2 PC2503.2 PC2504.2 PCA01.2 PCA02.2 PCA03.2 PCA04.2 PCA05.2 PCA06.2 PCA08.2 PCA101.2 PCA102.2 PCA103.2 PCA104.2 PCA105.2 PCA106.2 PCA107.2 PCA108.2 PCA109.2 PCA110.2 PCA171.2 PCA172.2 PCB01.2 PCB02.2 PCB03.2 PCB04.2 PCB05.2 PCB06.2 PCB07.2 PCB08.2 PCB10.2 PCB11.2 PCB12.2 PCB13.2 PCB14.2 PCB15.2 PCB16.2 PCB17.2 PCB19.2 PCB20.2 PCB21.2 PCB22.2 PCB23.2 PCB24.2 PCB26.2 PCB27.2 PCB28.2 PCB29.2 PCB31.2 PCB32.2 PCB33.2 PCB34.2 PCB35.2 PCB36.2 PCB37.2 PCB38.2 PCB39.2 PCB40.2 PCB42.2 PCB43.2 PCB44.1 PCB45.2 PCB46.2 PCB47.2 PCF01.2 PCF02.2 PCF03.2 PCF04.2 PCF06.2 PCH01.2 PCH02.2 PCH03.2 PCH04.2 PCH05.2 PCH06.2 PCH07.2 PCH08.2 PCH09.2 PCH10.2 PCH11.2 PCH13.2 PCH15.2 PCH16.2 PCH17.2 PCH20.2 PCM01.2 PCM02.2 PCM03.2 PCM04.2 PCM05.2 PCM06.2 PCM07.2 PCM08.2 PCM09.2 PCM10.2 PCM11.2 PCM13.2 PCM14.2 PCM15.2 PCM16.2 PCM18.2 PCM19.2 PCM20.2 PCM21.2 PCM22.2 PCM23.2 PCM24.2 PCS01.1 PCS02.2 PCS03.2 PCS04.2 PCS05.2 PCS06.2 PCS07.2 PCS08.2 PCS11.2 PCS12.2 PCS13.2 PCS14.2 PCS15.2 PCS16.2 PCS17.2 PCS62.2 PCS63.2 PCV01.2 PCV02.2 PCV03.2 PCV04.2 PCV05.2 PCV06.2 PCV07.2 PCV09.2 PCV10.2 PCV11.2 PCV12.2 PCV13.2 PCV14.2 PCV15.2 PCV16.2 PCV17.2 PCV18.2 PCV19.2 PCV20.2 PCV24.2 PCV27.2 PCV31.2 PCV32.2 PCV34.2 PCV35.2 PCV36.2 PCV37.2 PCV171.2 PCV172.2 PCW01.2 PCW02.2 PCW03.2 PCW04.2 PCW05.2 PCW06.2 PCW07.2 PCW08.2 PCW09.2 PCW10.2 PCW11.2 PCW13.2 PCW15.2 PCW16.2 PCW17.2 PCZ01.1 PCZ05.1 PCZ08.2 PCZ10.2 PCZ11.1 PCZ12.2 PCZ13.2 PCZ14.2 PCZ15.2 PCZ16.2 PCZ17.2 PCZ18.2 PCZ19.2 PCZ20.2 PCZ21.2 PCZ22.2 PCZ23.2 PCZ25.1 PCZ26.2 PCZ31.2 PCZ35.2 PCZ36.2 PCZ37.2 PCZ38.2 PCZ39.2 PCZ40.2 PCZ41.2 PCZ42.2 PCZ43.2 PCZ44.2 PCZ45.2 PCZ46.2 PCZ49.2 PCZ50.2 PCZ101.2 PCZ102.2 PCZ103.2 PCZ104.2 PCZ105.2 PCZ106.2 PCZ107.2 PCZ108.2 PCZ109.2 PCZ110.2 PCZ111.2 PCZ112.2 PCZ113.2 PCZ114.2 PCZ115.2 PCZ116.2 PCZ117.2 PCZ118.2 PCZ119.2 PCZ120.2 PCZ171.2 PCZ172.2 PCZ173.2 PCZ174.2 PD1.1 PD2.2 PD3.2 PD5.1 PD6.1 PD12.2 PHA02.1 PHV01.2 PHZ01.1 PJP2.2 PJPDC1.7 PJPDC1.8 PL2.2 PQ2.3 PQ5.3 PQ6.3 PQ11.3 PQ12.1 PQ12.4 PQ13.1 PQ13.4 PQ15.3 PQ16.3 PQ17.3 PQ18.3 PQ20.3 PQA01.3 PQA01.4 PQA01.5 PQB01.3 PQB01.4 PQB01.5 PQB02.3 PQB02.4 PQB02.5 PQB04.3 PQH02.1 PQH02.4 PQM01.5 PQM01.6 PQM01.7 PQS03.1 PQS03.4 PQS04.3 PQS05.1 PQS05.4 PQS07.3 PQS08.3 PQS10.1 PQS10.4 PQS11.3 PQS12.3 PQS14.3 PQS30.1 PQS30.4 PQS62.3 PQS64.3 PQV01.3 PQV01.4 PQV01.5 PQV02.3 PQV02.4 PQV02.5 PQV03.3 PQV03.4 PQV03.5 PQV04.3 PQV04.4 PQV04.5 PQZ01.3 PQZ01.4 PQZ01.5 PQZ02.3 PQZ02.4 PQZ02.5 PQZ03.3 PQZ03.4 PQZ03.5 PQZ04.3 PQZ04.4 PQZ04.5 PR6.2 PR15.2 PR16.2 PR17.2 PR38.2 PR40.2 PR43.2 PR44.1 PR45.2 PR62.2 PR66.2 PR100.2 PR303.2 PR308.2 PR508.2 PR511.2 PR1802.2 PR1805.2 PR2503.2 PRB07.2 PRB10.2 PRB20.2 PRB23.2 PRB24.2 PRB26.2 PRB33.2 PRF03.2 PRH02.2 PRH04.2 PRH09.2 PRH14.1 PRH17.2 PRM11.2 PRS05.2 PRS06.2 PRS07.2 PRS14.2 PRS25.2 PRS27.1 PRS29.2 PRS30.2 PRV02.2 PRV04.2 PRV05.2 PRV09.2 PRV10.2 PRV16.2 PRV18.2 PRV27.2 PRW02.2 PRW04.2 PRW10.2 PRZ05.2 PRZ12.1 PRZ14.1 PRZ20.1 PRZ25.1 PRZ30.2 PRZ43.2 PU1.2 PU2.3 PU301.7 PU301.8 PU301.18 PU301.21 PU501.7 PU501.8 PU501.18 PU501.21 PU1801.11 PU2501.8 PU2501.9 PUB01.33 PUB02.3 PUF01.8 PUF01.9 PUH01.4 PUH01.8 PUM01.1 PUM01.3 PUM01.14 PUM01.21 PUS01.4 PUS02.3 PUS03.3 PUS04.2 PUV01.41 PUW01.4 PUW01.8 PUZ01.41 Q3.3 Q4.3 Q7.3 Q9.3 Q26.1 Q26.4 QC27.3 QE1.3 QI1.3 QS1.1 QS1.4 QT3.3 QT4.3 R6.2 R21.2 R30.2 R64.1 R65.2 RA45.1 RA51.1 RC16.2 RC27.1 RC42.1 RC51.2 RC52.2 RC57.1 RC58.1 RC59.1 RC60.1 RC61.1 RC62.1 RC646.2 RC681.2 RC703.1 RC711.1 RC801.2 RD2.1 RD4.1 RE3.2 RE9.1 RE11.1 RH22.1 RH23.1 RH24.1 RI16.2 RI17.2 RI20.2 RL2.1 RL8.1 RL14.2 RP1.2 RP2.2 RP3.2 RP5.2 RPC1.1 RPC1.2 RPC5.1 RPC5.2 RPC5.3 RPC5.4 RS13.1 RS16.2 RS17.2 RS18.2 RS19.2 RS20.2 RS21.2 RS23.2 RS24.2 RT3.2 RT32.2 RT34.1 RT40.2 RT41.2 RT42.2 RT43.2 RT44.2 RT45.2 RT46.2 RT47.2 RT48.2 RT49.2 RT50.2 RT51.2 RT52.2 RT53.2 RT60.1 RT61.2 RT62.2 RT63.2 RT65.2 RT101.1 RT115.2 RT116.1 RT117.2 RT118.2 RT119.2 RT134.2 RV2.1 RV4.2 RV9.2 RV12.2 RV13.2 RV16.2 RV17.1 RV21.1 RV29.1 RV34.2 RV35.2 RV38.2 RV39.1 RV40.1 RV41.1 RV49.2 RV51.2 RV53.2 RV55.2 RV59.1 RV83.2 RV88.1 RV89.1 RV116.2 RV118.2 RV119.2 RV120.2 RV121.2 RV123.2 RV132.2 RV133.2 RV134.2 RV135.2 RV151.1 RV163.2 RV368.1 RV369.2 RW12.2 RW14.1 RX6.1 SW1.1 SW2.1 U2.2 U3.11 U3.15 U4.11 U4.15 U5.2 U6.11 U6.15 U8.5 U58.1 UA1.49 UC1.A3 UC1.A5 UC1.A7 UC1.A10 UC1.A12 UC1.A14 UC1.A16 UC1.A19 UC1.A21 UC1.A23 UC1.A26 UC1.A30 UC1.AA1 UC1.AA5 UC1.AA13 UC1.AA15 UC1.AA17 UC1.AA19 UC1.AB14 UC1.AB16 UC1.AB18 UC1.AB20 UC1.AC5 UC1.AC8 UC1.AC11 UC1.AC12 UC1.AC13 UC1.AC15 UC1.AC17 UC1.AC19 UC1.AD1 UC1.AD5 UC1.AD14 UC1.AD16 UC1.AD18 UC1.AD20 UC1.AE5 UC1.AE11 UC1.AE12 UC1.AE13 UC1.AE15 UC1.AE17 UC1.AE19 UC1.AF1 UC1.AF5 UC1.AF14 UC1.AF16 UC1.AF18 UC1.AF20 UC1.AG5 UC1.AG8 UC1.AG11 UC1.AG12 UC1.AG13 UC1.AG15 UC1.AG17 UC1.AG19 UC1.AH14 UC1.AH16 UC1.AH18 UC1.AH20 UC1.AJ1 UC1.AJ5 UC1.AJ13 UC1.AJ15 UC1.AJ17 UC1.AJ19 UC1.AK5 UC1.AK8 UC1.AK11 UC1.AK12 UC1.AK14 UC1.AK16 UC1.AK18 UC1.AK20 UC1.AK22 UC1.AK25 UC1.AL1 UC1.AL5 UC1.AL7 UC1.AL10 UC1.AL12 UC1.AL16 UC1.AL23 UC1.AL26 UC1.AM5 UC1.AM8 UC1.AM15 UC1.AM20 UC1.AM22 UC1.AM25 UC1.AM28 UC1.AN1 UC1.AN5 UC1.AN7 UC1.AN10 UC1.AN15 UC1.AN18 UC1.AN21 UC1.AN23 UC1.AN26 UC1.AN28 UC1.AN32 UC1.AP5 UC1.AP8 UC1.AP13 UC1.AP15 UC1.AP18 UC1.AP20 UC1.AP25 UC1.AP28 UC1.AR1 UC1.AR5 UC1.AR7 UC1.AR12 UC1.AR14 UC1.AR16 UC1.AR19 UC1.AR21 UC1.AR26 UC1.AR28 UC1.AR32 UC1.AU5 UC1.AU8 UC1.AU11 UC1.AU13 UC1.AU15 UC1.AU18 UC1.AU20 UC1.AU22 UC1.AU25 UC1.AU28 UC1.AV1 UC1.AV5 UC1.AV7 UC1.AV10 UC1.AV12 UC1.AV14 UC1.AV16 UC1.AV19 UC1.AV21 UC1.AV23 UC1.AV26 UC1.AV28 UC1.AV32 UC1.AW5 UC1.AW28 UC1.AY6 UC1.AY7 UC1.AY8 UC1.AY10 UC1.AY11 UC1.AY12 UC1.AY13 UC1.AY14 UC1.AY15 UC1.AY16 UC1.AY18 UC1.AY19 UC1.AY20 UC1.AY21 UC1.AY22 UC1.AY23 UC1.AY25 UC1.AY26 UC1.AY27 UC1.BB1 UC1.BB20 UC1.BB32 UC1.BD3 UC1.BD7 UC1.BD10 UC1.BD12 UC1.BD14 UC1.BD16 UC1.BD19 UC1.BD21 UC1.BD23 UC1.BD26 UC1.BD30 UC1.C3 UC1.C32 UC1.D16 UC1.D18 UC1.D20 UC1.E7 UC1.E8 UC1.E10 UC1.E11 UC1.E12 UC1.E13 UC1.E14 UC1.E15 UC1.E16 UC1.E18 UC1.E19 UC1.E20 UC1.E21 UC1.E22 UC1.E23 UC1.E25 UC1.E26 UC1.E27 UC1.F5 UC1.F28 UC1.G1 UC1.G5 UC1.G16 UC1.G19 UC1.G21 UC1.G23 UC1.G26 UC1.G28 UC1.G32 UC1.H5 UC1.H13 UC1.H18 UC1.H20 UC1.H22 UC1.H25 UC1.H28 UC1.K1 UC1.K5 UC1.K16 UC1.K19 UC1.K21 UC1.K22 UC1.K26 UC1.K28 UC1.K32 UC1.L5 UC1.L13 UC1.L15 UC1.L18 UC1.L20 UC1.L25 UC1.L28 UC1.M1 UC1.M5 UC1.M12 UC1.M21 UC1.M23 UC1.M26 UC1.M28 UC1.M32 UC1.N4 UC1.N5 UC1.N8 UC1.N11 UC1.N12 UC1.N13 UC1.N15 UC1.N17 UC1.N19 UC1.N22 UC1.N25 UC1.N28 UC1.P1 UC1.P5 UC1.P14 UC1.P16 UC1.P18 UC1.P20 UC1.P23 UC1.P26 UC1.P28 UC1.P32 UC1.R5 UC1.R11 UC1.R12 UC1.R13 UC1.R15 UC1.R17 UC1.R19 UC1.R22 UC1.R25 UC1.R28 UC1.R30 UC1.T1 UC1.T5 UC1.T14 UC1.T16 UC1.T18 UC1.T20 UC1.T23 UC1.T26 UC1.T28 UC1.U13 UC1.U15 UC1.U17 UC1.U19 UC1.V5 UC1.V8 UC1.V11 UC1.V12 UC1.V14 UC1.V16 UC1.V18 UC1.V20 UC1.V22 UC1.V25 UC1.W1 UC1.W5 UC1.W13 UC1.W15 UC1.W17 UC1.W19 UC1.W23 UC1.W26 UC1.Y5 UC1.Y11 UC1.Y12 UC1.Y14 UC1.Y16 UC1.Y18 UC1.Y20 UC2.3 UC3.3 UC4.3 UC5.3 UC7.4 UC8.2 UC9.3 UC20.2 UC21.3 UE1.11 UE1.24 UE1.35 UE1.94 UE1.113 UI1.2 UL1.33 UL2.2 US1.3 US1.21 US4.5 US4.6 US4.7 US4.8 US5.2 UT1.41 UT3.2 UT4.2 UT8.2 UT9.41 UT10.5 UU1.2 UV1.A3 UV1.A30 UV1.AA11 UV1.AA13 UV1.AA16 UV1.AA27 UV1.AB6 UV1.AB10 UV1.AB15 UV1.AB24 UV1.AB32 UV1.AC9 UV1.AC17 UV1.AC24 UV1.AC26 UV1.AC27 UV1.AD6 UV1.AD8 UV1.AD25 UV1.AD32 UV1.AE7 UV1.AE14 UV1.AE27 UV1.AF32 UV1.AG12 UV1.AG27 UV1.AH10 UV1.AH28 UV1.AH32 UV1.B6 UV1.B8 UV1.B10 UV1.B12 UV1.B14 UV1.B16 UV1.B18 UV1.B20 UV1.B22 UV1.B24 UV1.B26 UV1.C1 UV1.C32 UV1.E28 UV1.F2 UV1.F6 UV1.F8 UV1.F10 UV1.F12 UV1.F14 UV1.F16 UV1.F18 UV1.F20 UV1.F22 UV1.F24 UV1.F26 UV1.G8 UV1.G10 UV1.G27 UV1.G31 UV1.H2 UV1.H6 UV1.H14 UV1.H17 UV1.H20 UV1.J7 UV1.J27 UV1.J31 UV1.K2 UV1.K6 UV1.K11 UV1.K22 UV1.K28 UV1.K32 UV1.L27 UV1.M6 UV1.M12 UV1.M32 UV1.N11 UV1.N13 UV1.N16 UV1.N18 UV1.N21 UV1.N25 UV1.N27 UV1.P6 UV1.P9 UV1.P25 UV1.P32 UV1.R11 UV1.R12 UV1.R15 UV1.R17 UV1.R20 UV1.R27 UV1.T6 UV1.T11 UV1.T13 UV1.T16 UV1.T18 UV1.T21 UV1.T25 UV1.T32 UV1.U9 UV1.U15 UV1.U17 UV1.U20 UV1.U25 UV1.U27 UV1.V11 UV1.V13 UV1.V16 UV1.V18 UV1.V32 UV1.W25 UV1.W26 UV1.W27 UV1.Y10 UV1.Y15 UV1.Y17 UV1.Y20 UV1.Y25 UV1.Y32 UV2.3 UV8.3 UV12.A1 UV12.A3 UV12.A12 UV12.A14 UV12.B5 UV12.B10 UV12.C1 UV12.C3 UV12.C4 UV12.C11 UV12.C12 UV12.C13 UV12.C14 UV12.D10 UV12.E1 UV12.E3 UV12.E12 UV12.E14 UV12.F5 UV12.F10 UV12.G5 UV12.G10 UV12.H1 UV12.H2 UV12.H13 UV12.H14 UV12.K1 UV12.K2 UV12.K13 UV12.K14 UV12.L5 UV12.L10 UV12.M5 UV12.M10 UV12.N1 UV12.N3 UV12.N12 UV12.N14 UV12.P10 UV12.R1 UV12.R3 UV12.R4 UV12.R11 UV12.R12 UV12.R14 UV12.T5 UV12.T10 UV12.U1 UV12.U3 UV12.U12 UV12.U14 UV13.A1 UV13.A3 UV13.A12 UV13.A14 UV13.B5 UV13.B10 UV13.C1 UV13.C3 UV13.C4 UV13.C11 UV13.C12 UV13.C13 UV13.C14 UV13.D10 UV13.E1 UV13.E3 UV13.E12 UV13.E14 UV13.F5 UV13.F10 UV13.G5 UV13.G10 UV13.H1 UV13.H2 UV13.H13 UV13.H14 UV13.K1 UV13.K2 UV13.K13 UV13.K14 UV13.L5 UV13.L10 UV13.M5 UV13.M10 UV13.N1 UV13.N3 UV13.N12 UV13.N14 UV13.P10 UV13.R1 UV13.R3 UV13.R4 UV13.R11 UV13.R12 UV13.R14 UV13.T5 UV13.T10 UV13.U1 UV13.U3 UV13.U12 UV13.U14 UV14.A1 UV14.A3 UV14.A12 UV14.A14 UV14.B5 UV14.B10 UV14.C1 UV14.C3 UV14.C4 UV14.C11 UV14.C12 UV14.C13 UV14.C14 UV14.D10 UV14.E1 UV14.E3 UV14.E12 UV14.E14 UV14.F5 UV14.F10 UV14.G5 UV14.G10 UV14.H1 UV14.H2 UV14.H13 UV14.H14 UV14.K1 UV14.K2 UV14.K13 UV14.K14 UV14.L5 UV14.L10 UV14.M5 UV14.M10 UV14.N1 UV14.N3 UV14.N12 UV14.N14 UV14.P10 UV14.R1 UV14.R3 UV14.R4 UV14.R11 UV14.R12 UV14.R14 UV14.T5 UV14.T10 UV14.U1 UV14.U3 UV14.U12 UV14.U14 UV15.A1 UV15.A3 UV15.A12 UV15.A14 UV15.B5 UV15.B10 UV15.C1 UV15.C3 UV15.C4 UV15.C11 UV15.C12 UV15.C13 UV15.C14 UV15.D10 UV15.E1 UV15.E3 UV15.E12 UV15.E14 UV15.F5 UV15.F10 UV15.G5 UV15.G10 UV15.H1 UV15.H2 UV15.H13 UV15.H14 UV15.K1 UV15.K2 UV15.K13 UV15.K14 UV15.L5 UV15.L10 UV15.M5 UV15.M10 UV15.N1 UV15.N3 UV15.N12 UV15.N14 UV15.P10 UV15.R1 UV15.R3 UV15.R4 UV15.R11 UV15.R12 UV15.R14 UV15.T5 UV15.T10 UV15.U1 UV15.U3 UV15.U12 UV15.U14 UW1.2 UX1.9 UX1.16 UX1.23 UX1.32 UX1.33 YL1.2 YL1.4 YV1.2 YV1.4
GNDA: CA6.2 CA10.2 CA19.1 CA20.1 CA23.2 CA25.2 CA26.2 CA27.2 CA28.2 CA29.2 CA39.2 CA40.2 CA41.2 CA42.2 CA48.2 CA53.2 CA56.2 CA67.2 CA68.2 JHP1.7 RA13.2 RA30.2 RA31.2 RA32.2 RA51.2 UA1.25 UA1.38
V3D3_STB: RA12.1 RA54.2 UA1.20
VBAT_CHG: PCB45.1 PRB39.2 PUB01.31
VBUS_C_CTRL_P1: PRS35.2 PUS02.1 RT118.1 UT1.12
VBUS_DISCHARGE: QT3.2 RT32.1 UT1.20
VBUS_MON_P1: CT9.1 RT1.2 RT3.1 UT1.13
VBUS_P_CTRL_P1: PRS38.1 PUS03.1 QT5.1 RT117.1 UT1.11
VCCSENSE_VGA: PRV34.1 RV159.1
VDD_1.2V: PCM14.1 PRM03.2 PRM04.2 PUM01.11
VDD_CHG: PCB28.1 PRB09.2 PRB11.1 PRB13.2 PUB01.18
VDDIO_APU: PCZ21.1 PRZ16.2 PUZ01.6
VDDIO_AUDIO: CC1191.1 CC1192.1 RC97.2 RC6125.2 UC1.AP12
VDDIO_VGA: PCV10.1 PRV12.2 PRV14.2 PUV01.6
VDDP_CHG: PCB29.1 PRB09.1 PUB01.8
VDDP_SENSE_H: PCH19.1 PQH01.3 UC1.AN11
VDDP_SENSE_L: PRH14.2 UC1.AM11
VDDR4: UV1.U12 UV1.V12 UV1.Y12
VSS_MECH: UV1.A32 UV1.AM1 UV1.AM32
VSS_SENSEA: RC19.2 UC1.J18
VSSSENSE_VGA: PRV36.1 RV158.1
0.9_1.8VALW_PWREN: PR1801.1 PRH01.1 UE1.127
32K_X1: CC686.1 RC914.2 UC1.AY1 YC3.1
32K_X2: CC682.1 RC914.1 UC1.AY4 YC3.2
48M_X1: C797.1 RC939.2 UC1.BB3 YC2.1
48M_X2: C796.1 RC939.1 UC1.BA5 YC2.3
+APU_VDDCORE: CC39.1 CC40.1 CC41.1 CC42.1 CC43.1 CC44.1 CC45.1 CC46.1 CC47.1 CC48.1 CC49.1 CC50.1 CC51.1 CC52.1 CC53.1 CC54.1 CC55.1 PCZ101.1 PCZ102.1 PCZ103.1 PCZ104.1 PCZ105.1 PCZ106.1 PCZ107.1 PCZ108.1 PCZ109.1 PCZ110.1 PCZ111.1 PCZ112.1 PCZ113.1 PCZ114.1 PCZ115.1 PCZ116.1 PCZ117.1 PCZ118.1 PCZ119.1 PCZ120.1 PCZ171.1 PCZ172.1 PCZ173.1 PCZ174.1 PLZ02.4 PLZ03.4 PRZ37.2 UC1.AA7 UC1.AA10 UC1.AA14 UC1.AA16 UC1.AA18 UC1.AB13 UC1.AB15 UC1.AB17 UC1.AB19 UC1.AC14 UC1.AC16 UC1.AC18 UC1.AD7 UC1.AD10 UC1.AD13 UC1.AD15 UC1.AD17 UC1.AD19 UC1.AE8 UC1.AE14 UC1.AE16 UC1.AE18 UC1.AF7 UC1.AF10 UC1.AF13 UC1.AF15 UC1.AF17 UC1.AF19 UC1.AG14 UC1.AG16 UC1.AG18 UC1.AH13 UC1.AH15 UC1.AH17 UC1.AH19 UC1.AJ7 UC1.AJ10 UC1.AJ14 UC1.AJ16 UC1.AJ18 UC1.AK13 UC1.AK15 UC1.AK17 UC1.AK19 UC1.G7 UC1.G10 UC1.G12 UC1.G14 UC1.H8 UC1.H11 UC1.H15 UC1.K7 UC1.K12 UC1.K14 UC1.L8 UC1.M7 UC1.M10 UC1.N14 UC1.P7 UC1.P10 UC1.P13 UC1.P15 UC1.R8 UC1.R14 UC1.R16 UC1.T7 UC1.T10 UC1.T13 UC1.T15 UC1.T17 UC1.U14 UC1.U16 UC1.V13 UC1.V15 UC1.V17 UC1.W7 UC1.W10 UC1.W14 UC1.W16 UC1.Y8 UC1.Y13 UC1.Y15 UC1.Y17
+APU_VDDSOC: CC56.1 CC57.1 CC58.1 CC59.1 CC60.1 CC61.1 CC62.1 CC63.1 CC64.1 PCA101.1 PCA102.1 PCA103.1 PCA104.1 PCA105.1 PCA106.1 PCA107.1 PCA108.1 PCA109.1 PCA110.1 PCA171.1 PCA172.1 PLA01.4 PRZ02.1 UC1.M15 UC1.M18 UC1.M19 UC1.N16 UC1.N18 UC1.N20 UC1.P17 UC1.P19 UC1.R18 UC1.R20 UC1.T19 UC1.U18 UC1.U20 UC1.V19 UC1.W18 UC1.W20 UC1.Y19
+BIF_VDDC: CV122.1 CV180.2 CV181.2 RV31.2 UV1.R21 UV1.U21
+CCG_VBUS: CT21.1 CT22.1 CT26.1 CT27.1 CT28.1 CT29.1 CT57.1 D2.2 D2.3 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 PCS05.1 PCS06.1 PCS15.1 PLS11.1 PLS12.1 PRS26.1 PUS04.1 RT1.1 RT33.1 UT8.1
+CCG_VBUS_1: CT55.1 CT56.1 PCS07.1 PCS08.1 PJPS01.1 PLS11.2 PLS12.2 PQS61.5 PRS07.1 RT112.1 UT4.1
+CHARGER_SRC: PCB01.1 PCB02.1 PCB03.1 PCB04.1 PCB05.1 PCB06.1 PCB07.1 PCB08.1 PCB47.1 PJPB01.2 PLB11.2 PQB01.2
+CHGRTC: DC1.2 JP2.2
+DC_IN: PC3.1 PC4.1 PC5.1 PC8.1 PC16.1 PD12.1 PJP1.2 PL1.2 PQ3.1 PQ3.2 PQ3.3 PR8.1 PR13.1 PR32.1 PR34.1 PR36.1 PR61.1 PRS03.1 PU1.1
+DC_IN_SS: PD4.2 PD4.3 PDB03.2 PQ3.5 PQ4.5 PR11.1
+DP_VDDC: CV30.1 CV33.1 CV34.1 RV30.2 UV1.AD14
+DP_VDDR: CV26.1 CV27.1 CV35.1 RV27.2 UV1.AF14
+EC_VCCA: CE8.1 LE1.2 PR52.2 UE1.67
+FB0_VREFCL: CV395.1 RV54.2 RV55.1 UV12.J14 UV13.J14
+FB0_VREFDL: CV394.1 RV52.2 RV53.1 UV12.A10 UV12.U10 UV13.A10 UV13.U10
+FB1_VREFCL: CV391.1 RV50.2 RV51.1 UV14.J14 UV15.J14
+FB1_VREFDL: CV390.1 RV48.2 RV49.1 UV14.A10 UV14.U10 UV15.A10 UV15.U10
+FP_VCC: CU37.1 JFP.5 JFP.6 JFP1.7 JFP1.8 R700.2 R701.2
+INV_PWR_SRC: C12.1 C13.1 F1.2 JEDP1.1 JEDP1.2 JEDP1.3 JEDP1.4 R5.2
+LAN_VDD10: CL18.1 CL19.1 CL20.1 CL21.1 CL22.1 CL23.1 RL18.2 UL1.3 UL1.8 UL1.22 UL1.30
+LAN_VDD33: CL4.1 CL5.1 CL24.1 CL25.1 JP3.1 RL3.2 RL6.1 RL10.1 RL16.2 UL1.11 UL1.32 UL2.1
+LAN_VDDREG: CL6.1 RL3.1 UL1.23
+LCDVDD: LX1.1 U2.1
+LCDVDD_CONN: C15.1 C16.1 CW6.1 JEDP1.7 JEDP1.8 LX1.2
+LINE1-VREFO-L: RA26.1 UA1.31
+LINE1-VREFO-R: RA29.1 UA1.30
+MIC2-VREFO: RA22.1 RA23.1 UA1.29
+MPLL_PVDD: CV81.1 CV82.1 CV124.1 LV6.2 UV1.L8
+MVREFDA: CV94.1 RV33.2 RV34.1 UV1.K26
+MVREFSA: CV95.1 RV32.2 RV35.1 UV1.J26
+PCIE_VDDC: CV54.1 CV55.1 CV56.1 CV57.1 CV58.1 CV59.1 CV60.1 CV120.1 CV121.1 RV364.1 UV1.L23 UV1.L24 UV1.L25 UV1.L26 UV1.M22 UV1.N22 UV1.N23 UV1.N24 UV1.R22 UV1.T22 UV1.U22 UV1.V22
+PWR_SRC_AC: PJPB01.1 PLB11.1 PRB01.4
+RTC_APU: CC92.1 RC98.2 UC8.3
+RTC_APU_R: CC90.1 CC91.1 CLRP1.1 Q9.1 RC98.1 UC1.AT11
+RTCBATT: JIOB1.11 RC99.2
+RTCBATT_R: DC1.3 QC27.2 RC99.1 RC801.1
+RTCVCC: CC93.1 DC1.1 RA12.2 UC8.1
+SDC_IN: PC6.1 PCS10.1 PD4.1 PDS02.1 PQ4.1 PQ4.2 PQ4.3 PQ19.3 PQS02.1 PQS02.2 PQS02.3 PQS06.3 PR9.1 PR47.1 PRB01.1 PRB04.1 PRB05.1 PRS09.1 PRS10.1
+SPI_VCC: CC635.1 JH1.8 RC639.2 RC640.2 RC642.2 RC1672.2 RC1700.2 RC1706.2 RX13.1 RX14.1 RX16.1 UC7.8
+SPLL_PVDD: CV84.1 CV85.1 CV86.1 LV7.2 UV1.H7
+SPLL_VDDC: CV91.1 CV92.1 CV93.1 LV8.2 UV1.H8
+TPAN_VDD_F: C310.1 F2.1 R9.2 RW3.2 RW4.1 U5.5
+TSVDD: CV19.1 CV20.1 CV21.1 LV2.2 UV1.AD17
+V_DAC: CL9.2 TL1.11 TL1.14 TL2.11 TL2.14
+VCHGR: PCB31.1 PCB32.1 PQB03.1 PQB03.2 PQB03.3 PRB12.4
+VGA_CORE: CV67.1 CV68.1 CV69.1 CV70.1 CV71.1 CV72.1 CV73.1 CV74.1 CV75.1 CV76.1 CV77.1 CV78.1 CV79.1 CV80.1 CV87.1 CV88.1 CV89.1 CV90.1 CV100.1 CV101.1 CV102.1 CV103.1 CV104.1 CV105.1 CV106.1 CV107.1 CV108.1 CV109.1 CV110.1 CV111.1 CV112.1 CV113.1 CV114.1 CV115.1 CV116.1 CV117.1 CV118.1 CV119.1 CV125.1 CV126.1 CV127.1 PCV171.1 PCV172.1 PLV01.1 PLV02.1 UV1.AA12 UV1.AA15 UV1.AB11 UV1.AB12 UV1.AB13 UV1.AC11 UV1.AC13 UV1.AC14 UV1.M11 UV1.M13 UV1.M15 UV1.M16 UV1.M17 UV1.M18 UV1.M20 UV1.M21 UV1.N12 UV1.N15 UV1.N17 UV1.N20 UV1.R13 UV1.R16 UV1.R18 UV1.T10 UV1.T12 UV1.T15 UV1.T17 UV1.T20 UV1.U10 UV1.U11 UV1.U13 UV1.U16 UV1.U18 UV1.V15 UV1.V17 UV1.V20 UV1.V21 UV1.W9 UV1.W10 UV1.Y9 UV1.Y13 UV1.Y16 UV1.Y18 UV1.Y21
+VREF_CA: CD24.1 CD25.1 CD26.1 CD32.1 JDIMM1.164 RD1.1 RD2.2
+VREFB_CA: CD58.1 CD59.1 CD60.1 CD61.1 JDIMM2.164 RD3.1 RD4.2
A_MIC_CLK: CA50.1 JEDP1.31 LA10.1
A_MIC_DATA: CA51.1 JEDP1.30 RA55.1
AC_B2B_ACOK: PD10.1 PQ16.1 PQ20.1 PR2.1
AC_B2B_S1: PC22.1 PQ15.1 PQ16.2 PQS11.1 PR22.2
AC_B2B_S1_A: PC7.1 PQ5.2 PR2.2 PR100.1
AC_B2B_S2: PC10.1 PQ6.2 PR11.2 PR17.1 PR51.1
AC_B2B_S2_A: PQ17.2 PQ18.1 PR50.2 PR60.2
AC_B2B_S2_B: PQ19.2 PR47.2 PR48.1
AC_B2B_S2_G: PC6.2 PQ4.4 PQ19.1 PR9.2 PR12.1
AC_B2B_S2_SW: PC23.1 PQ18.2 PR49.2 PR51.2 PR53.2
AC_DIS: PRB43.2 UE1.27
AC_DIS1: PQ20.2 PQB04.2 PRB23.1 PRB43.1
AC_OK: PD10.2 PR13.2 PR15.1 PRB44.1 PRS33.1 PRS41.1
AC_SW_PROCHOT: PC13.1 PQ12.6 PR33.2
ACAV_IN1: PQB04.1 PRB11.2 PRB20.1 PRB22.2 PRB41.1
ACIN_65W: RE36.2 RV150.2 UV8.2
ACIN_CHG: PCB26.1 PRB05.2 PRB07.1 PUB01.19
ACOK_CHG: PRB22.1 PUB01.24
AD_BID0: CE9.1 RE5.1 RE9.2 UE1.66
ADJ_0.95V: PCF05.2 PRF02.2 PRF03.1 PUF01.7
ADJ_2.5V: PC2505.2 PR2502.2 PR2503.1 PU2501.7
ADP_CHG: PRB04.2 PUB01.16
ADP_I: PRB35.2 UE1.65
AGPIO3: RC36.2 RC40.2 UC1.AT15
AGPIO8: RC56.2 RC57.2 UC1.AP6
AGPIO25: RC661.1 UC1.BA11
ALERT#: R33.2 U8.6
APU_ALERT#: RPC3.2 UC1.J15
APU_DBREQ#: CH3.1 RH25.2 RPH1.4 UC1.AW3
APU_DBREQ#_R: RH25.1 T125.1(TP-1)
APU_DP1_CTRL_CLK: QI3.1 RPI3.1 UC1.G11
APU_DP1_CTRL_DATA: QI3.4 RPI3.2 UC1.F11
APU_DP1_HPD: QI2.3 RI17.1 UC1.G13
APU_DP1_N0: CI8.2 UC1.D5
APU_DP1_N1: CI6.2 UC1.C1
APU_DP1_N2: CI4.2 UC1.E4
APU_DP1_N3: CI1.2 UC1.F2
APU_DP1_P0: CI9.2 UC1.E6
APU_DP1_P1: CI7.2 UC1.E1
APU_DP1_P2: CI5.2 UC1.F3
APU_DP1_P3: CI2.2 UC1.F4
APU_DP2_AUXN: C305.1 UC1.H12
APU_DP2_AUXN_C: C305.2 JCRT.9
APU_DP2_AUXP: C304.1 UC1.J12
APU_DP2_AUXP_C: C304.2 JCRT.8
APU_DP2_HPD: JCRT.13 RP5.1 UC1.K13
APU_DP2_N0: C301.1 UC1.AB4
APU_DP2_N0_C: C301.2 JCRT.3
APU_DP2_N1: C303.1 UC1.AC3
APU_DP2_N1_C: C303.2 JCRT.6
APU_DP2_P0: C300.1 UC1.AB2
APU_DP2_P0_C: C300.2 JCRT.2
APU_DP2_P1: C302.1 UC1.AC1
APU_DP2_P1_C: C302.2 JCRT.5
APU_DP3_AUXN: RT133.2 UC1.H10
APU_DP3_AUXP: RT132.2 UC1.J10
APU_DP3_HPD: RT2.2 RT116.2 UC1.K8 UT1.18 UT9.32
APU_FCH_POK: RC30.1 UE1.32
APU_FCH_PWRGD: CC8.1 CC9.2 CC10.2 RC28.2 RC30.2 RC39.2 RC630.1 UC3.2
APU_FCH_PWRGD_R: RC33.2 RC34.2 RC39.1 UC1.AV6 UC3.4
APU_PCIE1_RST#_C: CC100.2 RC701.1 RC704.1
APU_PCIE1_RST#_R: RC704.2 UC1.BB6
APU_PCIE1_RST#_U: RC44.1 RC700.2 RC701.2 RC703.2 UC4.1 UC4.2
APU_PCIE_RST#: D5.1 D6.1 RC44.2 RC49.1 RL5.1 RS63.1 RW11.1 UC4.4 UC21.1 UV2.2
APU_PCIE_RST#_C: CC7.1 RC29.1 RC700.1
APU_PCIE_RST#_R: RC29.2 UC1.BD5
APU_PCIE_RST#_SSD: JSSD1.50 RS63.2 UC21.4
APU_PCIE_WAKE#: JSSD1.54 RE37.1 RL10.2 UC1.AV11 UL1.21
APU_PWRGD: CC6.2 DH1.2 PUZ01.9 RC15.2 RC27.2 UC1.AW2
APU_PWRGD_BUF: DH1.1 T123.1(TP-1)
APU_RST#: CC5.2 CC250.2 DH2.2 RC12.2 UC1.AW4
APU_RST#_BUF: DH2.1 T124.1(TP-1)
APU_SCLK0: JCRT.12 JDIMM1.253 JDIMM2.253 RPC64.1 UC1.BC20 US4.1
APU_SDATA0: JCRT.11 JDIMM1.254 JDIMM2.254 RPC64.2 UC1.BA20 US4.4
APU_SIC: RC616.2 RPC3.3 UC1.H14
APU_SID: RC617.2 RPC3.1 UC1.J14
APU_SPI_CLK: RC74.1 RC680.1 UC1.BB7
APU_SPI_CLK_R: JH1.6 RC47.2 RC51.1 RC74.2 RC622.2 RX4.1 UC7.6
APU_SPI_CS1#: JH1.1 RC639.1 UC1.BC9 UC7.1
APU_SPI_D0: JH1.5 RC1706.1 RX2.1 UC1.BB10 UC7.5
APU_SPI_D1: JH1.2 RX1.1 UC1.BA9 UC7.2
APU_SPI_D2: JH1.3 RC640.1 UC1.BA10 UC7.3
APU_SPI_D3: JH1.7 RC642.1 UC1.BC10 UC7.7
APU_SPI_TPMCS#: RC646.1 RX5.1 UC1.BD8
APU_SPKR: CC11.1 DA3.3 UC1.AU16
APU_SVC: PUZ01.3 RC7.2 RC18.1
APU_SVC_R: RC18.2 UC1.F16
APU_SVD: PUZ01.5 RC8.2 RC20.1
APU_SVD_R: RC20.2 UC1.H16
APU_SVT: PUZ01.7 RC6.2 RC22.1
APU_SVT_R: RC22.2 UC1.J16
APU_TCK: RH27.2 RPH1.1 UC1.AU1
APU_TDI: CH4.1 RH28.2 RPH1.3 UC1.AU2
APU_TDO: RH28.1 UC1.AU4
APU_TEST4: T5.1(TP-1) UC1.AP14
APU_TEST5: T6.1(TP-1) UC1.AN14
APU_TEST6: T7.1(TP-1) UC1.F13
APU_TEST14: RPC30.8 T8.1(TP-1) UC1.G18
APU_TEST15: RPC30.7 T9.1(TP-1) UC1.H19
APU_TEST16: RPC30.6 T10.1(TP-1) UC1.F18
APU_TEST17: RPC30.5 T11.1(TP-1) UC1.F19
APU_TEST31: T12.1(TP-1) UC1.W24
APU_TEST41: T13.1(TP-1) UC1.AR11
APU_TEST470: T14.1(TP-1) UC1.AJ21
APU_TEST471: T15.1(TP-1) UC1.AK21
APU_TMS: RH27.1 RPH1.2 UC1.AU3
APU_TRST#: CC251.1 CH2.1 RH21.1 RH26.1 UC1.AV3
APU_TRST#_R: RH21.2 T100.1(TP-1)
APU_USBC_SCL: QC3.4 RC94.2 UC1.AM6
APU_USBC_SDA: QC3.1 RC95.2 UC1.AM7
APU_VDD_RUN_FB_L: PRZ40.2 PRZ43.1 RC19.1 T17.1(TP-1)
APU_VDDCR_SEN: PRZ37.1 PRZ38.2 T18.1(TP-1) UC1.K18
APU_VDDSOC_SEN: PRZ02.2 PRZ06.1 T16.1(TP-1) UC1.J19
AUD_HP1_JACK_L1: LA7.1 RA24.2 RA25.2 RA26.2
AUD_HP1_JACK_R1: LA8.1 RA27.2 RA28.2 RA29.2
AUD_PORTA_L_R_B: CA40.1 DA6.2 JHP1.1 LA7.2 RA32.1
AUD_PORTA_R_R_B: CA39.1 DA6.3 JHP1.2 LA8.2 RA31.1
AUD_SENSE_A: CA48.1 RA10.1 RA41.1 UA1.13
BATGONE_CHG: PCB34.1 PRB24.1 PRB25.1 PUB01.25
BATT_CHG_LED: Q16.1 R69.2
BATT_CHG_LED#: Q14.4 UE1.21
BATT_CHG_LED_R#: Q14.3 Q16.2 Q17.1
BATT_I: PRB34.2 UE1.75
BATT_LOW_LED: Q15.1 R68.2
BATT_LOW_LED#: Q14.1 UE1.93
BATT_LOW_LED_R#: Q14.6 Q15.2
BATT_TEMP: CE11.2 PC14.1 PD6.2 PR39.2 PR41.1 PRB25.2 UE1.63
BEEP#: DA3.2 UE1.23
BGATE_CHG: PCB33.1 PQB03.4 PUB01.32
BKOFF#: DX1.2 UE1.105
BOOT1_CHG: PRB06.1 PUB01.12
BOOT2_CHG: PCB30.1 PUB01.4
BOT_MUX_N: EU7.4 EU7.7 LT3.3 RT103.1 UT10.2
BOT_MUX_N_R: JUSBC1.B7 LT3.4 RT103.2
BOT_MUX_P: EU7.5 EU7.6 LT3.2 RT102.1 UT10.1
BOT_MUX_P_R: JUSBC1.B6 LT3.1 RT102.2
BP_0: RV82.1 UV1.U1
BP_1: RV81.1 UV1.U3
BST1_APU: PRZ41.1 PUZ01.21
BST1_VGA: PRV21.1 PUV01.21
BST2_APU: PRZ21.1 PUZ01.30
BST2_VGA: PRV01.1 PUV01.30
BST_1.2V: PRM02.1 PUM01.18
BST_1.2V_R: PCM12.1 PRM02.2
BST_3V: PR301.1 PU301.1
BST_5V: PR501.1 PU501.1
BST_+1.35VGPU: PRW06.1 PUW01.1
BST_+1.35VGPU_R: PCW12.1 PRW06.2
BST_+VDDP: PRH06.1 PUH01.1
BST_+VDDP_R: PCH12.1 PRH06.2
BST_NB: PRA01.1 PUZ01.31
BT_ON#: RC902.2 UC1.AW18
BT_ON#_R: JWLAN1.54 RC615.2 RC902.1
CAP_LED: JKB1.4 R19.2
CAP_LED_Q: Q6.1 R19.1
CAP_LED_R#: Q5.1 Q6.2
CAPS_LED: Q5.3 R18.2 R20.1 UE1.91
CCG4_APU_USBC_SCL: QC3.3 QT6.6 RT70.2 UT1.29
CCG4_APU_USBC_SDA: QC3.6 QT6.3 RT71.2 UT1.28
CCG4_CC1_P1: CT11.1 EU8.1 EU8.9 JUSBC1.A5 UT1.9
CCG4_CC2_P1: CT10.1 EU8.5 EU8.6 JUSBC1.B5 UT1.7
CCG4_ID1: RT4.2 RT115.1 UT1.25
CCG4_ID2: RT64.2 RT65.1 UT1.27
CCG4_SWD_CLK: JCCG4_T.4 TP2.1(TP-1) UT1.2
CCG4_SWD_IO: JCCG4_T.5 TP1.1(TP-1) UT1.1
CCG4_XRES: CT13.1 JCCG4_T.3 RT6.2 TP3.1(TP-1) UT1.10
CLK_PCIE_N1: UC1.AM4 UL1.16
CLK_PCIE_N2: JWLAN1.49 UC1.AM3
CLK_PCIE_N3: JSSD1.53 UC1.AL4
CLK_PCIE_P1: UC1.AM2 UL1.15
CLK_PCIE_P2: JWLAN1.47 UC1.AM1
CLK_PCIE_P3: JSSD1.55 UC1.AL2
CLK_PEG_N0: UC1.AK3 UV1.AK32
CLK_PEG_P0: UC1.AK1 UV1.AK30
CLK_SMB: PBATT1.7 PR42.1
CLKREQ_PCIE#1: RL15.1 UC1.AN19 UL1.12
CLKREQ_PCIE#2: JWLAN1.53 RC1696.2 UC1.AP19
CLKREQ_PCIE#3: JSSD1.52 RC1697.2 UC1.AT19
CLKREQ_PEG#0: RC1695.2 RV153.1 UC1.AV18
CLKREQ_PEG#0_R: RV153.2 RV368.2 UV1.N7
CLKRUN#: RE52.1 RX36.1 T111.1(TP-1) UC1.BC13
CLKRUN#_R: RE52.2 UE1.38
CLKRUN#_R_TPM: RX36.2 RX38.2 UX1.13
COMP_CHG: PCB39.1 PRB30.1 PUB01.28
CS_1.2V: PRM03.1 PUM01.13
CSIN_CHG: PCB18.2 PCB20.1 PRB03.2 PUB01.14
CSIP_CHG: PCB18.1 PCB19.1 PRB02.2 PUB01.15
CSON_CHG: PCB41.1 PCB43.1 PRB36.1 PUB01.1
CSOP_CHG: PCB38.1 PCB41.2 PRB32.1 PUB01.2
DAT_SMB: PBATT1.6 PR37.1
DBC_EN: R4.2 UE1.89
DBC_EN_R: JEDP1.11 R4.1 R6.1
DCIN_CHG: PCB27.1 PRB08.2 PUB01.17
DDR_A_ACT#: JDIMM1.114 UC1.AA22
DDR_A_ALERT#: JDIMM1.116 UC1.AA25
DDR_A_BA0: JDIMM1.150 UC1.AF21
DDR_A_BA1: JDIMM1.145 UC1.AF27
DDR_A_BG0: JDIMM1.115 UC1.AA21
DDR_A_BG1: JDIMM1.113 UC1.AA27
DDR_A_CKE0: JDIMM1.109 UC1.Y23
DDR_A_CKE1: JDIMM1.110 UC1.Y26
DDR_A_CLK0: JDIMM1.137 UC1.AD25
DDR_A_CLK0#: JDIMM1.139 UC1.AD24
DDR_A_CLK1: JDIMM1.138 UC1.AE26
DDR_A_CLK1#: JDIMM1.140 UC1.AE27
DDR_A_CS0#: JDIMM1.149 UC1.AG21
DDR_A_CS1#: JDIMM1.157 UC1.AJ27
DDR_A_DM0: JDIMM1.12 UC1.F21
DDR_A_DM1: JDIMM1.33 UC1.G27
DDR_A_DM2: JDIMM1.54 UC1.N24
DDR_A_DM3: JDIMM1.75 UC1.N23
DDR_A_DM4: JDIMM1.178 UC1.AL24
DDR_A_DM5: JDIMM1.199 UC1.AN27
DDR_A_DM6: JDIMM1.220 UC1.AW25
DDR_A_DM7: JDIMM1.241 UC1.AT21
DDR_A_DQ0: JDIMM1.8 UC1.J21
DDR_A_DQ1: JDIMM1.7 UC1.H21
DDR_A_DQ2: JDIMM1.20 UC1.F23
DDR_A_DQ3: JDIMM1.21 UC1.H23
DDR_A_DQ4: JDIMM1.4 UC1.G20
DDR_A_DQ5: JDIMM1.3 UC1.F20
DDR_A_DQ6: JDIMM1.16 UC1.J22
DDR_A_DQ7: JDIMM1.17 UC1.J23
DDR_A_DQ8: JDIMM1.28 UC1.G25
DDR_A_DQ9: JDIMM1.29 UC1.F26
DDR_A_DQ10: JDIMM1.41 UC1.L24
DDR_A_DQ11: JDIMM1.42 UC1.L26
DDR_A_DQ12: JDIMM1.24 UC1.L23
DDR_A_DQ13: JDIMM1.25 UC1.F25
DDR_A_DQ14: JDIMM1.38 UC1.K25
DDR_A_DQ15: JDIMM1.37 UC1.K27
DDR_A_DQ16: JDIMM1.50 UC1.M25
DDR_A_DQ17: JDIMM1.49 UC1.M27
DDR_A_DQ18: JDIMM1.62 UC1.P27
DDR_A_DQ19: JDIMM1.63 UC1.R24
DDR_A_DQ20: JDIMM1.46 UC1.L27
DDR_A_DQ21: JDIMM1.45 UC1.M24
DDR_A_DQ22: JDIMM1.58 UC1.P24
DDR_A_DQ23: JDIMM1.59 UC1.P25
DDR_A_DQ24: JDIMM1.70 UC1.M22
DDR_A_DQ25: JDIMM1.71 UC1.N21
DDR_A_DQ26: JDIMM1.83 UC1.T22
DDR_A_DQ27: JDIMM1.84 UC1.V21
DDR_A_DQ28: JDIMM1.66 UC1.L21
DDR_A_DQ29: JDIMM1.67 UC1.M20
DDR_A_DQ30: JDIMM1.79 UC1.R23
DDR_A_DQ31: JDIMM1.80 UC1.T21
DDR_A_DQ32: JDIMM1.174 UC1.AL27
DDR_A_DQ33: JDIMM1.173 UC1.AL25
DDR_A_DQ34: JDIMM1.187 UC1.AP26
DDR_A_DQ35: JDIMM1.186 UC1.AR27
DDR_A_DQ36: JDIMM1.170 UC1.AK26
DDR_A_DQ37: JDIMM1.169 UC1.AK24
DDR_A_DQ38: JDIMM1.183 UC1.AM24
DDR_A_DQ39: JDIMM1.182 UC1.AP27
DDR_A_DQ40: JDIMM1.195 UC1.AM23
DDR_A_DQ41: JDIMM1.194 UC1.AM21
DDR_A_DQ42: JDIMM1.207 UC1.AR25
DDR_A_DQ43: JDIMM1.208 UC1.AU27
DDR_A_DQ44: JDIMM1.191 UC1.AL22
DDR_A_DQ45: JDIMM1.190 UC1.AL21
DDR_A_DQ46: JDIMM1.203 UC1.AP24
DDR_A_DQ47: JDIMM1.204 UC1.AP23
DDR_A_DQ48: JDIMM1.216 UC1.AW26
DDR_A_DQ49: JDIMM1.215 UC1.AV25
DDR_A_DQ50: JDIMM1.228 UC1.AV22
DDR_A_DQ51: JDIMM1.229 UC1.AW22
DDR_A_DQ52: JDIMM1.211 UC1.AU26
DDR_A_DQ53: JDIMM1.212 UC1.AV27
DDR_A_DQ54: JDIMM1.224 UC1.AW23
DDR_A_DQ55: JDIMM1.225 UC1.AT22
DDR_A_DQ56: JDIMM1.237 UC1.AW21
DDR_A_DQ57: JDIMM1.236 UC1.AU21
DDR_A_DQ58: JDIMM1.249 UC1.AP21
DDR_A_DQ59: JDIMM1.250 UC1.AN20
DDR_A_DQ60: JDIMM1.232 UC1.AR22
DDR_A_DQ61: JDIMM1.233 UC1.AN22
DDR_A_DQ62: JDIMM1.245 UC1.AT20
DDR_A_DQ63: JDIMM1.246 UC1.AR20
DDR_A_DQS0: JDIMM1.13 UC1.F22
DDR_A_DQS0#: JDIMM1.11 UC1.G22
DDR_A_DQS1: JDIMM1.34 UC1.H27
DDR_A_DQS1#: JDIMM1.32 UC1.H26
DDR_A_DQS2: JDIMM1.55 UC1.N27
DDR_A_DQS2#: JDIMM1.53 UC1.N26
DDR_A_DQS3: JDIMM1.76 UC1.R21
DDR_A_DQS3#: JDIMM1.74 UC1.P21
DDR_A_DQS4: JDIMM1.179 UC1.AM26
DDR_A_DQS4#: JDIMM1.177 UC1.AM27
DDR_A_DQS5: JDIMM1.200 UC1.AN24
DDR_A_DQS5#: JDIMM1.198 UC1.AN25
DDR_A_DQS6: JDIMM1.221 UC1.AU23
DDR_A_DQS6#: JDIMM1.219 UC1.AT23
DDR_A_DQS7: JDIMM1.242 UC1.AV20
DDR_A_DQS7#: JDIMM1.240 UC1.AW20
DDR_A_EVENT#: JDIMM1.134 RC2.2 UC1.AE24
DDR_A_MA0: JDIMM1.144 UC1.AF25
DDR_A_MA1: JDIMM1.133 UC1.AE23
DDR_A_MA2: JDIMM1.132 UC1.AD27
DDR_A_MA3: JDIMM1.131 UC1.AE21
DDR_A_MA4: JDIMM1.128 UC1.AC24
DDR_A_MA5: JDIMM1.126 UC1.AC26
DDR_A_MA6: JDIMM1.127 UC1.AD21
DDR_A_MA7: JDIMM1.122 UC1.AC27
DDR_A_MA8: JDIMM1.125 UC1.AD22
DDR_A_MA9: JDIMM1.121 UC1.AC21
DDR_A_MA10: JDIMM1.146 UC1.AF22
DDR_A_MA11: JDIMM1.120 UC1.AA24
DDR_A_MA12: JDIMM1.119 UC1.AC23
DDR_A_MA13: JDIMM1.158 UC1.AJ25
DDR_A_MA14_WE#: JDIMM1.151 UC1.AG27
DDR_A_MA15_CAS#: JDIMM1.156 UC1.AG23
DDR_A_MA16_RAS#: JDIMM1.152 UC1.AG26
DDR_A_ODT0: JDIMM1.155 UC1.AG24
DDR_A_ODT1: JDIMM1.161 UC1.AJ22
DDR_A_PAR: JDIMM1.143 UC1.AF24
DDR_A_RST#: CD1.1 JDIMM1.108 UC1.Y24
DDR_B_ACT#: JDIMM2.114 UC1.V30
DDR_B_ALERT#: JDIMM2.116 UC1.W30
DDR_B_BA0: JDIMM2.150 UC1.AH31
DDR_B_BA1: JDIMM2.145 UC1.AG32
DDR_B_BG0: JDIMM2.115 UC1.V31
DDR_B_BG1: JDIMM2.113 UC1.V29
DDR_B_CKE0: JDIMM2.109 UC1.U29
DDR_B_CKE1: JDIMM2.110 UC1.T30
DDR_B_CLK0: JDIMM2.137 UC1.AC31
DDR_B_CLK0#: JDIMM2.139 UC1.AD30
DDR_B_CLK1: JDIMM2.138 UC1.AD29
DDR_B_CLK1#: JDIMM2.140 UC1.AD31
DDR_B_CS0#: JDIMM2.149 UC1.AJ31
DDR_B_CS1#: JDIMM2.157 UC1.AM31
DDR_B_DM0: JDIMM2.12 UC1.C21
DDR_B_DM1: JDIMM2.33 UC1.C25
DDR_B_DM2: JDIMM2.54 UC1.E32
DDR_B_DM3: JDIMM2.75 UC1.K30
DDR_B_DM4: JDIMM2.178 UC1.AP30
DDR_B_DM5: JDIMM2.199 UC1.AW31
DDR_B_DM6: JDIMM2.220 UC1.BB26
DDR_B_DM7: JDIMM2.241 UC1.BD22
DDR_B_DQ0: JDIMM2.8 UC1.B21
DDR_B_DQ1: JDIMM2.7 UC1.D21
DDR_B_DQ2: JDIMM2.20 UC1.B23
DDR_B_DQ3: JDIMM2.21 UC1.D23
DDR_B_DQ4: JDIMM2.4 UC1.A20
DDR_B_DQ5: JDIMM2.3 UC1.C20
DDR_B_DQ6: JDIMM2.16 UC1.A22
DDR_B_DQ7: JDIMM2.17 UC1.C22
DDR_B_DQ8: JDIMM2.28 UC1.D24
DDR_B_DQ9: JDIMM2.29 UC1.A25
DDR_B_DQ10: JDIMM2.41 UC1.D27
DDR_B_DQ11: JDIMM2.42 UC1.C27
DDR_B_DQ12: JDIMM2.24 UC1.C23
DDR_B_DQ13: JDIMM2.25 UC1.B24
DDR_B_DQ14: JDIMM2.38 UC1.C26
