# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_CLK1: length 52
  IN1 w0.099: v1(116.87,67.88) 116.64,68.08 116.63,68.21 116.63,68.28 116.46,68.45 115.88,68.45 115.38,67.96 114.57,67.96 114.31,68.22 112.53,68.22 112.13,68.62 104.6,68.62 103.26,69.96 101.67,69.96 101.62,70.01
  IN1 w0.102: 80.55,74.41 80.53,74.41 80.48,74.37 79.98,74.37 79.37,74.97 76.87,74.97 75.61,76.23 75.61,76.42 75.17,76.87 74.2,76.87 73.96,76.63 73.96,76.37 v1(73.81,76.22)
  IN1 w0.188: 80.55,74.41 84.81,74.41 89.21,70.01 101.53,70.01 101.57,70.05 101.62,70.01
  BOTTOM w0.099: UC1.AE26 117.23,68.25 116.87,67.89 v1(116.87,67.88)
  BOTTOM w0.163: v1(73.81,76.22) 73.9,76.14 73.9,75.78 73.69,75.58 71.9,75.58 71.74,75.74 JDIMM1.138
DDR_A_CLK1#: length 51.9
  IN1 w0.099: v1(116.2,67.85) 116.26,67.85 116.44,68.06 116.43,68.2 116.38,68.25 115.96,68.25 115.47,67.76 114.49,67.76 114.23,68.02 112.45,68.02 112.05,68.42 104.52,68.42 103.18,69.76 101.69,69.76 101.62,69.69
  IN1 w0.102: v1(74.4,76.22) 74.2,76.42 74.2,76.53 74.3,76.63 75.07,76.63 75.37,76.33 75.37,76.13 76.77,74.73 79.27,74.73 79.88,74.13 80.48,74.13 80.53,74.09 80.55,74.09
  IN1 w0.188: 101.62,69.69 101.61,69.68 89.08,69.68 84.67,74.09 80.55,74.09
  BOTTOM w0.099: v1(116.2,67.85) 116.22,67.86 116.22,67.99 UC1.AE27
  BOTTOM w0.163: JDIMM1.140 73.83,75.24 74.23,75.64 74.23,76.06 v1(74.4,76.22)
DDR_A_CS0#: length 56.3
  IN1 w0.099: 101.49,63.49 102.19,64.19 104.49,64.19 105.03,64.73 114.56,64.73 114.91,65.08 116.41,65.08 116.61,65.28 117.33,65.28 117.35,65.27 117.69,65.27 117.95,65.52 118.58,65.52 118.8,65.75 118.8,66 118.96,66.16 119.64,66.16 119.7,66.21 120.56,66.21 120.83,65.94 v1(120.83,65.81)
  IN1 w0.188: v1(74.49,70.48) 75.78,69.18 78.23,69.18 80.04,67.37 83.11,67.37 86.99,63.49 101.49,63.49
  BOTTOM w0.1: v1(120.83,65.81) 121.23,66.21 UC1.AG21
  BOTTOM w0.168: v1(74.49,70.48) 75,70.99 JDIMM1.149
DDR_A_CS1#: length 48.7
  IN1 w0.099: v1(116.88,64.71) 116.87,64.7 116.82,64.7 116.8,64.68 115.07,64.68 114.72,64.34 105.33,64.34 104.24,63.24 102.47,63.24 101.53,62.3
  IN1 w0.188: v1(77.75,68.42) 77.35,68.02 76.68,68.02 76.49,67.84 76.49,67.12 76.73,66.87 79.2,66.87 80.34,65.74 83.06,65.74 86.49,62.3 87.06,62.3 87.24,62.12 87.24,61.93 87.43,61.74 87.81,61.74 88,61.93 88,62.12 88.18,62.3 101.53,62.3
  BOTTOM w0.102: UC1.AJ27 116.87,64.96 116.87,64.71 v1(116.88,64.71)
  BOTTOM w0.168: v1(77.75,68.42) 78.32,68.99 JDIMM1.157
DDR_A_DM0: length 65.7
  IN1 w0.099: 110.14,96.53 112.92,93.75 115.9,93.75 117.14,92.5 117.14,90.1 119.61,87.64 119.61,86.67 120.61,85.67 120.61,84.43 v1(120.73,84.31)
  IN1 w0.102: v1(72.77,107.72) 72.41,107.37 72.41,106.7 72.51,106.6 73.08,106.6 73.18,106.7 73.18,107.08 73.28,107.18 73.49,107.18 73.59,107.08 73.59,106.7 73.69,106.6 75.48,106.6 76.23,107.35 80.55,107.35
  IN1 w0.109: 110.14,96.53 100.32,106.34 82.44,106.34 81.43,107.35 80.55,107.35
  BOTTOM w0.1: v1(120.73,84.31) 121.03,84.01 UC1.F21
  BOTTOM w0.102: v1(72.77,107.72) 72.29,107.24 JDIMM1.12
DDR_A_DM1: length 62.7
  IN1 w0.099: v1(116.14,84.01) 116.34,84.2 116.34,84.73 116.68,85.07 116.68,86.26 114.71,88.24 112.44,88.24 107.89,92.79 106.76,92.79 106.6,92.95 106.6,93.09 106.89,93.38 106.89,93.52 106.75,93.66 106.61,93.66 106.32,93.37 106.18,93.37 106.04,93.51 106.04,93.65 106.33,93.94 106.33,94.08 106.19,94.22 106.05,94.22 105.76,93.93 105.62,93.93 105.48,94.07 105.48,94.21 105.77,94.5 105.77,94.64 105.63,94.78 105.49,94.78 105.2,94.49 105.06,94.49 104.92,94.63 104.92,94.77 105.21,95.06 105.21,95.2 105.07,95.34 104.93,95.34 104.64,95.06 104.5,95.06 104.34,95.22 104.34,95.36 104.61,95.63 104.61,95.77 104.47,95.91 104.33,95.91 104.06,95.64 103.92,95.64 103.55,96.01 103.55,96.53
  IN1 w0.102: 80.55,101.15 80.18,101.15 79.87,100.83 79.72,100.83 79.05,101.51 78.86,101.51 78.76,101.41 78.76,101.22 79.4,100.58 79.4,100.37 79.23,100.2 78.83,100.2 78.73,100.3 78.73,100.69 78.63,100.8 78.43,100.8 78.33,100.69 78.33,100.3 78.22,100.2 78.02,100.2 77.92,100.3 77.92,100.5 77.82,100.6 77.61,100.6 77.51,100.5 77.51,100.3 77.41,100.2 76.61,100.2 76.46,100.35 76.46,100.49 76.6,100.63 77.04,100.63 77.11,100.69 77.11,100.97 v1(77.07,101)
  IN1 w0.109: 103.55,96.53 98.93,101.15 80.55,101.15
  BOTTOM w0.1: v1(116.14,84.01) 116.23,83.91 116.23,83.61 UC1.G27
  BOTTOM w0.102: JDIMM1.33 77.89,101.99 77.07,101.18 v1(77.07,101)
DDR_A_DM2: length 57.1
  IN1 w0.099: v1(118.43,78.81) 118.41,78.81 118.02,78.42 116.18,78.42 116.16,78.43 116.11,78.43 115.5,79.04 114.71,79.04 113.22,80.53 112.91,80.53 112.56,80.88 112.3,80.88 112.26,80.93 110.94,80.93 106.47,85.39 106.47,85.67 101.58,90.56
  IN1 w0.102: v1(75.44,95.41) 75.15,95.13 75.15,94.25 75.33,94.08 80.55,94.08
  IN1 w0.109: 101.58,90.56 98.07,94.08 80.55,94.08
  BOTTOM w0.1: v1(118.43,78.81) 118.83,78.41 UC1.N24
  BOTTOM w0.102: JDIMM1.54 72.22,96.74 72.69,96.27 74.58,96.27 v1(75.44,95.41)
DDR_A_DM3: length 63.7
  IN1 w0.099: v1(120.73,77.75) 120.94,77.75 121.04,77.65 121.04,77.31 120.92,77.19 120.05,77.19 119.8,76.94 119.8,76.52 119.05,75.78 117.34,75.78 117.01,76.11 116.7,76.11 116.27,75.68 115.09,75.68 114.58,76.2 113.81,76.2 113.4,76.61 113.4,77.51 113.12,77.79 112.65,77.79 111.3,79.14 110.2,79.14 106.76,82.58 106.32,82.58 103.78,85.13 103.37,85.13 102.6,85.9 102.54,85.9 102.2,86.23 98.48,86.23
  IN1 w0.102: v1(77.32,90.87) 76.67,90.22 76.67,89.75 76.77,89.65 77.08,89.65 77.18,89.75 77.18,90.09 77.28,90.2 77.48,90.2 77.58,90.09 77.58,89.75 77.69,89.65 77.89,89.65 77.99,89.75 77.99,90.09 78.09,90.2 78.3,90.2 78.4,90.09 78.4,89.75 78.5,89.65 78.7,89.65 78.8,89.75 78.8,90.09 78.9,90.2 79.11,90.2 79.21,90.09 79.21,89.75 79.31,89.65 80.22,89.65 80.55,89.99
  IN1 w0.109: 80.55,89.99 94.73,89.99 95.82,88.9 95.97,88.9 96.21,89.14 96.37,89.14 96.52,88.98 96.52,88.83 96.28,88.59 96.28,88.43 96.44,88.28 96.59,88.28 96.83,88.52 96.98,88.52 97.14,88.36 97.14,88.21 96.9,87.97 96.9,87.81 97.05,87.66 97.21,87.66 97.45,87.9 97.6,87.9 97.76,87.74 97.76,87.59 97.52,87.35 97.52,87.2 97.67,87.04 97.83,87.04 98.07,87.28 98.22,87.28 98.37,87.13 98.37,86.97 98.14,86.73 98.14,86.58 98.48,86.23
  BOTTOM w0.1: v1(120.73,77.75) 120.19,77.75 UC1.N23
  BOTTOM w0.102: JDIMM1.75 78.43,91.49 77.81,90.87 v1(77.32,90.87)
DDR_A_DM4: length 53.9
  IN1 w0.099: v1(119.16,63.81) 119.12,63.81 118.61,63.31 118.47,63.31 118.01,62.85 118.01,62.65 117.79,62.43 117.47,62.43 117.45,62.46 117.19,62.2 116.73,62.2 116.22,62.7 113.25,62.7 112.91,62.36 105.8,62.36 104.34,60.91 103.65,60.91 101.58,58.84
  IN1 w0.102: v1(72.23,63.74) 72.4,63.56 78.25,63.56 79.17,62.64 79.93,62.64 80.08,62.49 80.55,62.49
  IN1 w0.109: 101.58,58.84 101.49,58.84 101.48,58.85 90.91,58.85 90.46,58.4 85.8,58.4 81.71,62.49 80.55,62.49
  BOTTOM w0.102: v1(72.23,63.74) JDIMM1.178 ; UC1.AL24 119.16,63.64 v1(119.16,63.81)
DDR_A_DM5: length 62.7
  IN1 w0.099: v1(117.41,59.81) 117.34,59.88 117.17,59.88 117.03,59.74 117.03,59.34 116.35,58.66 113.03,58.66 112.48,59.21 106.55,59.21 106,58.67 106,56.58 103.17,53.74
  IN1 w0.102: v1(77.6,58.33) 77.43,58.49 75.72,58.49 75.62,58.39 75.62,58.14 75.52,58.03 75.32,58.03 75.21,58.14 75.21,58.39 75.11,58.49 74.81,58.49 74.71,58.39 74.71,57.83 74.81,57.73 75.85,57.73 75.95,57.83 75.95,58.06 76.05,58.16 76.26,58.16 76.36,58.06 76.36,57.83 76.46,57.73 77.54,57.73 78.07,58.26 78.22,58.26 78.38,58.1 78.38,57.96 78.03,57.61 78.03,57.47 78.18,57.32 78.32,57.32 78.67,57.67 78.81,57.67 78.99,57.49 78.99,57.34 78.65,57 78.65,56.85 78.79,56.71 78.93,56.71 79.28,57.06 79.42,57.06 79.57,56.91 79.57,56.77 79.22,56.42 79.22,56.28 79.36,56.13 79.51,56.13 79.86,56.48 80,56.48 80.16,56.32 80.16,56.18 79.81,55.83 79.81,55.69 80.21,55.29 80.55,55.29
  IN1 w0.109: 80.55,55.29 81.83,55.29 83.38,53.74 102.07,53.74 102.18,53.63 102.18,53.5 102.29,53.39 102.51,53.39 102.62,53.5 102.62,53.63 102.73,53.74 103.17,53.74
  BOTTOM w0.099: v1(117.41,59.81) 117.42,59.82 117.42,59.91 117.64,60.13 117.64,60.4 116.73,61.31 UC1.AN27
  BOTTOM w0.102: v1(77.6,58.33) 77.76,58.49 JDIMM1.199
DDR_A_DM6: length 57.6
  IN1 w0.099: v1(117.67,56.17) 117.63,56.12 117.63,55.99 116.71,55.07 114.21,55.07 113.7,55.59 108.15,55.59 107.32,54.76 107.32,54.33 107.42,54.23 108.58,54.23 108.86,53.95 108.86,52.51 108.51,52.16 106.41,52.16 103.32,49.07 101.58,49.07
  IN1 w0.102: 80.55,49.67 80.29,49.67 77.61,52.36 74,52.36 72.71,53.64 v1(72.71,53.86)
  IN1 w0.109: 80.55,49.67 80.86,49.67 81.47,49.07 101.58,49.07
  BOTTOM w0.102: v1(72.71,53.86) 72.09,53.24 70.95,53.24 JDIMM1.220 ; UC1.AW25 118.23,56.41 118.02,56.2 117.7,56.2 v1(117.67,56.17)
DDR_A_DM7: length 69.3
  IN1 w0.099: 101.58,44.82 102.36,45.6 105.86,45.6 105.96,45.7 105.96,45.87 106.05,45.97 106.25,45.97 106.35,45.87 106.35,45.7 106.45,45.6 107.23,45.6 110.46,48.83 110.46,49.18 110.56,49.28 110.81,49.28 110.91,49.18 110.91,48.82 111,48.72 111.42,48.72 111.54,48.84 111.54,49.05 111.64,49.14 112.02,49.14 113.22,50.34 113.22,50.48 113.06,50.64 113.06,50.78 113.2,50.92 113.34,50.92 113.5,50.76 113.64,50.76 114.01,51.14 115.45,51.14 115.55,51.04 115.55,50.33 115.65,50.23 115.84,50.23 115.94,50.33 115.94,51.04 116.04,51.14 116.24,51.14 116.34,51.04 116.34,50.33 116.44,50.23 116.64,50.23 116.74,50.33 116.74,51.04 116.83,51.14 117.06,51.14 117.16,51.04 117.16,50.35 117.26,50.25 117.46,50.25 117.56,50.35 117.56,51.04 117.66,51.14 117.92,51.14 118.04,51.02 118.04,50.53 118.14,50.43 118.31,50.43 118.44,50.56 118.44,51.31 118.58,51.45 118.72,51.45 118.97,51.21 119.11,51.21 119.26,51.36 119.26,51.5 119.01,51.76 119.01,51.9 119.15,52.04 119.29,52.04 119.54,51.78 119.68,51.78 119.82,51.92 119.82,52.06 119.57,52.32 119.57,52.46 119.77,52.66 119.91,52.66 120.16,52.41 120.3,52.41 120.44,52.55 120.44,52.69 120.19,52.94 120.19,53.08 121.26,54.15 121.26,54.95 121.26,56.53 121.2,56.59 121.2,57.2 120.98,57.42 120.98,57.56 121.2,57.79 121.2,58.04 v1(120.73,58.51)
  IN1 w0.102: v1(77.1,46.82) 77.06,46.78 76.55,46.78 76.45,46.68 76.45,46.48 76.55,46.38 77.94,46.38 79.7,44.61 80.34,44.61 80.55,44.82
  IN1 w0.109: 80.55,44.82 101.58,44.82
  BOTTOM w0.1: v1(120.73,58.51) 121.13,58.91 UC1.AT21
  BOTTOM w0.102: v1(77.1,46.82) 77.1,47.02 77.42,47.34 77.57,47.34 78.22,47.99 JDIMM1.241
DDR_A_DQ0: length 67
  IN1 w0.099: 121.09,84.49 120.96,84.62 120.96,85.6 119.81,86.75 119.81,87.72 117.34,90.19 117.34,92.75 116.14,93.94 113.31,93.94 110.72,96.53
  IN1 w0.102: v1(74.28,107.73) 74.76,107.25 75.8,107.25 76.11,107.55 80.13,107.55 80.34,107.76 80.55,107.76
  IN1 w0.109: 80.55,107.76 81.6,107.76 82.56,106.8 100.45,106.8 110.72,96.53 ; v1(121.72,81.41) 121.23,81.9 121.23,84.35 121.09,84.49
  BOTTOM w0.1: UC1.J21 121.53,81.41 v1(121.72,81.41)
  BOTTOM w0.102: JDIMM1.8 73.77,108.24 v1(74.28,107.73)
DDR_A_DQ1: length 68.7
  IN1 w0.099: 112.48,96.53 113.01,96 115.24,96 118.09,93.16 118.09,90.38 119.33,89.13 119.47,89.13 119.87,89.53 120.01,89.53 120.15,89.39 120.15,89.25 119.75,88.85 119.75,88.71 119.89,88.57 120.03,88.57 120.43,88.97 120.57,88.97 120.71,88.83 120.71,88.69 120.31,88.29 120.31,88.15 120.56,87.9 120.56,87.43 121.08,86.92
  IN1 w0.102: 81.03,109.37 77.12,109.37 76.81,109.06 v1(76.73,109.06)
  IN1 w0.109: 81.03,109.37 81.39,109.01 82.58,109.01 83.55,108.04 100.97,108.04 112.48,96.53 ; 121.08,86.92 121.1,86.92 121.81,86.2 121.97,86.2 122.36,86.6 122.51,86.6 122.67,86.44 122.67,86.29 122.28,85.89 122.28,85.74 122.62,85.4 122.62,82.96 v1(121.76,82.1)
  BOTTOM w0.1: UC1.H21 121.64,82.1 v1(121.76,82.1)
  BOTTOM w0.102: v1(76.73,109.06) 77.24,108.56 77.62,108.56 77.63,108.57 77.97,108.57 77.98,108.56 78.23,108.56 78.3,108.49 JDIMM1.7
DDR_A_DQ2: length 66.2
  IN1 w0.099: 108.34,96.53 108.34,96.31 112.01,92.64 112.78,92.64 115.29,90.13 116.27,90.13 118.43,87.98 118.43,86.57 119.36,85.64 119.36,84.62 v1(119.75,84.23)
  IN1 w0.102: v1(75.19,105.83) 75.19,105.7 74.96,105.47 74.18,105.47 74.08,105.37 74.08,105.09 74.18,104.99 75.65,104.99 75.75,105.09 75.75,105.3 75.85,105.41 76.06,105.41 76.16,105.3 76.16,105.09 76.26,104.99 76.46,104.99 76.56,105.09 76.56,105.3 76.67,105.41 76.87,105.41 76.97,105.3 76.97,105.09 77.07,104.99 77.28,104.99 77.38,105.09 77.38,105.3 77.48,105.41 77.68,105.41 77.78,105.3 77.78,105.09 77.89,104.99 78.3,104.99 78.41,105.09 78.41,105.81 78.51,105.91 78.71,105.91 78.81,105.81 78.81,105.09 78.91,104.99 79.85,104.99 79.93,105.07 80.52,105.07 80.53,105.07 80.55,105.07
  IN1 w0.109: 108.34,96.53 100.33,104.54 96.96,104.54 96.42,105.07 80.55,105.07
  BOTTOM w0.1: v1(119.75,84.23) 119.46,84.23 UC1.F23
  BOTTOM w0.102: v1(75.19,105.83) 75.19,105.63 74.8,105.24 JDIMM1.20
DDR_A_DQ3: length 69.4
  IN1 w0.099: v1(119.53,81.95) 119.25,82.23 119.25,82.96 118.96,83.25 118.96,85.44 117.99,86.42 117.99,87.72 115.97,89.74 115.12,89.74 112.61,92.25 111.45,92.25 107.17,96.53
  IN1 w0.102: 80.55,104.17 78.58,104.17 78.18,104.58 74.23,104.58 74.13,104.48 74.13,104.01 74.23,103.91 76.72,103.91 v1(77.11,103.52)
  IN1 w0.109: 80.55,104.17 89.86,104.17 89.97,104.06 89.97,103.82 90.08,103.71 90.3,103.71 90.41,103.82 90.41,104.06 90.52,104.17 90.74,104.17 90.85,104.06 90.85,103.82 90.96,103.71 91.18,103.71 91.28,103.82 91.28,104.06 91.39,104.17 91.61,104.17 91.72,104.06 91.72,103.82 91.83,103.71 92.05,103.71 92.16,103.82 92.16,104.06 92.27,104.17 92.49,104.17 92.59,104.06 92.59,103.82 92.7,103.71 92.92,103.71 93.03,103.82 93.03,104.06 93.14,104.17 93.36,104.17 93.47,104.06 93.47,103.82 93.58,103.71 93.8,103.71 93.91,103.82 93.91,104.06 94.01,104.17 94.25,104.17 94.36,104.06 94.36,103.82 94.47,103.71 94.69,103.71 94.8,103.82 94.8,104.06 94.91,104.17 95.12,104.17 95.23,104.06 95.23,103.82 95.34,103.71 95.56,103.71 95.67,103.82 95.67,104.06 95.78,104.17 96.15,104.17 96.61,103.71 99.99,103.71 107.17,96.53
  BOTTOM w0.1: UC1.H23 119.23,82.25 v1(119.53,81.95)
  BOTTOM w0.102: JDIMM1.21 77.96,104.99 77.11,104.13 v1(77.11,103.52)
DDR_A_DQ4: length 66.3
  IN1 w0.099: 111.9,96.53 112.62,95.8 115.16,95.8 117.83,93.14 117.83,90.36 120.37,87.82 120.37,87.06 121.09,86.34
  IN1 w0.102: v1(75.17,109) 75.17,108.64 75.27,108.54 75.78,108.54 75.95,108.36 76.44,108.36 76.62,108.54 79.71,108.54 79.76,108.59 80.55,108.59
  IN1 w0.109: 80.55,108.59 81.95,108.59 82.91,107.63 100.79,107.63 111.9,96.53 ; v1(121.73,83.61) 122.16,84.04 122.16,84.67 121.76,85.07 121.76,85.67 121.09,86.34
  BOTTOM w0.1: UC1.G20 122.03,83.31 v1(121.73,83.61)
  BOTTOM w0.102: v1(75.17,109) 74.7,109.47 73.82,109.47 73.59,109.24 JDIMM1.4
DDR_A_DQ5: length 69.4
  IN1 w0.099: 111.31,96.53 112.44,95.4 113.26,95.4 113.36,95.3 113.36,94.37 113.46,94.27 113.66,94.27 113.76,94.37 113.76,95.3 113.86,95.4 114.06,95.4 114.15,95.3 114.15,94.37 114.25,94.27 114.45,94.27 114.55,94.37 114.55,95.3 114.65,95.4 114.97,95.4 117.54,92.82 117.54,90.26 120.14,87.67 120.14,86.71 121.09,85.76
  IN1 w0.102: 80.55,108.18 80.31,108.18 79.9,107.77 78.85,107.77 78.75,107.87 78.75,108.19 78.65,108.29 78.44,108.29 78.34,108.19 78.34,107.88 78.24,107.78 v1(75.48,107.78)
  IN1 w0.109: 121.09,85.76 121.27,85.58 121.27,84.98 121.73,84.52 v1(121.73,84.31) ; 111.31,96.53 103.26,104.58 100.62,107.22 82.74,107.22 81.78,108.18 80.55,108.18
  BOTTOM w0.1: v1(121.73,84.31) 122.03,84.01 UC1.F20
  BOTTOM w0.102: 75.55,108.83 75.55,109.17 75.87,109.49 JDIMM1.3
  BOTTOM w0.112: 75.55,108.83 75.48,108.77 v1(75.48,107.78)
DDR_A_DQ6: length 65.7
  IN1 w0.099: 107.76,96.53 111.84,92.44 112.69,92.44 115.2,89.93 116.19,89.93 118.23,87.89 118.23,86.49 119.16,85.56 119.16,83.72 119.64,83.24 120.08,83.24 120.3,83.02 120.3,82.57 v1(120.7,82.18)
  IN1 w0.102: v1(73.98,105.83) 73.96,105.85 72.76,105.85 72.66,105.75 72.66,104.88 72.76,104.78 79.41,104.78 79.53,104.66 80.52,104.66 80.53,104.66 80.55,104.66
  IN1 w0.109: 107.76,96.53 100.16,104.12 96.79,104.12 96.25,104.66 80.55,104.66
  BOTTOM w0.1: v1(120.7,82.18) UC1.J22
  BOTTOM w0.102: JDIMM1.16 73.57,106.24 v1(73.98,105.83)
DDR_A_DQ7: length 69.6
  IN1 w0.099: 106.58,96.53 111.07,92.05 112.53,92.05 115.04,89.54 115.83,89.54 117.79,87.58 117.79,86.23 118.72,85.31 118.72,84.32 118.35,83.96 118.35,82.21 118.73,81.83 v1(118.73,81.81)
  IN1 w0.102: v1(76,103.42) 76.34,103.08 78.21,103.08 78.31,103.18 78.31,103.7 78.41,103.81 78.61,103.81 78.72,103.7 78.72,103.18 78.82,103.08 79.02,103.08 79.12,103.18 79.12,103.7 79.22,103.81 79.43,103.81 79.53,103.7 79.53,103.18 79.63,103.08 80.33,103.08 80.55,103.29
  IN1 w0.109: 106.58,96.53 99.82,103.29 89.38,103.29 89.27,103.4 89.27,103.65 89.16,103.76 88.94,103.76 88.83,103.65 88.83,103.4 88.72,103.29 88.5,103.29 88.39,103.4 88.39,103.65 88.29,103.76 88.07,103.76 87.96,103.65 87.96,103.4 87.85,103.29 87.54,103.29 87.44,103.4 87.44,103.65 87.33,103.76 87.11,103.76 87,103.65 87,103.4 86.89,103.29 86.67,103.29 86.56,103.4 86.56,103.65 86.45,103.76 86.23,103.76 86.13,103.65 86.13,103.4 86.02,103.29 85.8,103.29 85.69,103.4 85.69,103.65 85.58,103.76 85.36,103.76 85.25,103.65 85.25,103.4 85.14,103.29 84.92,103.29 84.81,103.4 84.81,103.65 84.71,103.76 84.49,103.76 84.38,103.65 84.38,103.4 84.27,103.29 84.05,103.29 83.94,103.4 83.94,103.65 83.83,103.76 83.61,103.76 83.5,103.65 83.5,103.4 83.39,103.29 83.18,103.29 83.07,103.4 83.07,103.65 82.96,103.76 82.74,103.76 82.63,103.65 82.63,103.4 82.52,103.29 82.3,103.29 82.19,103.4 82.19,103.65 82.08,103.76 81.87,103.76 81.76,103.65 81.76,103.4 81.65,103.29 81.43,103.29 81.32,103.4 81.32,103.65 81.21,103.76 80.99,103.76 80.88,103.65 80.88,103.4 80.77,103.29 80.55,103.29
  BOTTOM w0.1: UC1.J23 v1(118.73,81.81)
  BOTTOM w0.102: v1(76,103.42) 75.91,103.51 75.91,104.27 77.06,105.42 77.83,105.42 78.4,105.99 JDIMM1.17
DDR_A_DQ8: length 60.1
  IN1 w0.099: 105.31,96.53 105.6,96.53 106,96.13 106,95.99 105.84,95.83 105.84,95.69 105.98,95.55 106.12,95.55 106.28,95.71 106.42,95.71 106.58,95.55 106.58,95.41 106.42,95.25 106.42,95.11 106.56,94.97 106.7,94.97 106.86,95.13 107,95.13 113.3,88.83 114.95,88.83 117.29,86.49 117.29,84.27 117.73,83.83 v1(117.73,83.61)
  IN1 w0.102: 80.55,102.39 79.21,102.39 79.14,102.46 74.82,102.46 74.72,102.56 74.72,102.89 74.62,102.99 74.41,102.99 74.31,102.89 74.31,102.56 74.21,102.46 73.98,102.46 73.69,102.75 73.69,103.15 v1(73.93,103.39)
  IN1 w0.109: 105.31,96.53 99.44,102.39 80.55,102.39
  BOTTOM w0.1: UC1.G25 118.03,83.31 v1(117.73,83.61)
  BOTTOM w0.102: JDIMM1.28 71.73,103.24 71.95,103.02 73.56,103.02 v1(73.93,103.39)
DDR_A_DQ9: length 63.1
  IN1 w0.099: 104.13,96.53 104.43,96.53 112.52,88.44 114.78,88.44 116.87,86.35 116.87,84.74 v1(116.71,84.57)
  IN1 w0.102: 80.55,101.56 80.34,101.77 78.77,101.77 78.49,102.05 76.33,102.05 76.23,101.95 76.23,101.56 76.13,101.46 75.93,101.46 75.83,101.56 75.83,101.95 75.72,102.05 74.62,102.05 74.52,101.95 74.52,100.3 74.62,100.2 74.96,100.2 75.06,100.3 75.06,101.56 75.16,101.66 75.36,101.66 75.46,101.56 75.46,100.3 75.57,100.2 75.84,100.2 75.94,100.3 v1(75.94,101)
  IN1 w0.109: 104.13,96.53 99.1,101.56 80.55,101.56
  BOTTOM w0.1: UC1.F26 117.2,84.01 116.71,84.49 v1(116.71,84.57)
  BOTTOM w0.102: v1(75.94,101) 77.93,102.99 JDIMM1.29
DDR_A_DQ10: length 63.4
  IN1 w0.099: v1(118.43,80.81) 117.96,81.28 117.53,81.28 117.38,81.43 115.58,81.43 114.9,82.1 114.9,85.41 113.36,86.95 112.29,86.95 107.46,91.78 105.28,91.78 101.58,95.48
  IN1 w0.102: v1(74.42,98.93) 74.25,98.75 74.25,98.43 74.35,98.33 76.97,98.33 77.07,98.23 77.07,98 77.17,97.9 77.38,97.9 77.48,98 77.48,98.23 77.58,98.33 77.78,98.33 77.88,98.23 77.88,98 77.98,97.9 78.19,97.9 78.29,98 78.29,98.23 78.39,98.33 78.59,98.33 78.7,98.23 78.7,98 78.8,97.9 79,97.9 79.1,98 79.1,98.23 79.2,98.33 79.41,98.33 79.51,98.23 79.51,98 79.61,97.9 79.81,97.9 79.92,98 79.92,98.23 80.02,98.33 80.37,98.33
  IN1 w0.109: 80.37,98.33 98.73,98.33 101.58,95.48
  BOTTOM w0.1: UC1.L24 118.83,80.41 v1(118.43,80.81)
  BOTTOM w0.102: JDIMM1.41 78.24,99.99 78.15,99.9 78.15,99.69 76.61,98.15 74.75,98.15
  BOTTOM w0.112: v1(74.42,98.93) 74.42,98.48 74.75,98.15
DDR_A_DQ11: length 60.2
  IN1 w0.099: 101.58,94.89 105,91.48 107.48,91.48 112.27,86.68 112.47,86.68 114.71,84.45 114.71,82.02 115.52,81.21 116.53,81.21 v1(116.93,80.81)
  IN1 w0.102: 80.55,97.8 80.32,97.8 80.21,97.7 76.54,97.7 76.44,97.8 76.44,98.03 76.34,98.13 76.14,98.13 76.03,98.03 76.03,97.8 75.93,97.7 75.57,97.7 75.31,97.44 74.92,97.44 74.81,97.54 74.81,97.96 74.71,98.06 74.51,98.06 74.41,97.96 74.41,97.54 74.31,97.44 74.08,97.44 73.98,97.54 73.98,98.04 73.87,98.14 73.67,98.14 73.57,98.04 73.57,97.54 73.47,97.44 73.24,97.44 72.84,97.84 72.84,98.68 v1(73.09,98.93)
  IN1 w0.109: 101.58,94.89 98.68,97.8 80.55,97.8
  BOTTOM w0.1: UC1.L26 117.23,80.51 v1(116.93,80.81)
  BOTTOM w0.102: v1(73.09,98.93) 73.09,99.34 72.69,99.74 JDIMM1.42
DDR_A_DQ12: length 60.8
  IN1 w0.099: v1(119.34,80.81) 119.12,80.81 117.35,82.57 117.35,83.92 117.09,84.19 117.09,86.41 114.86,88.64 112.61,88.64 104.72,96.53
  IN1 w0.102: 80.55,101.98 78.85,101.98 78.57,102.26 73.9,102.26 v1(72.74,103.41)
  IN1 w0.109: 80.55,101.98 99.27,101.98 104.72,96.53
  BOTTOM w0.1: v1(119.34,80.81) 119.44,80.7 119.44,80.53 119.63,80.34 UC1.L23
  BOTTOM w0.102: JDIMM1.24 71.91,104.24 v1(72.74,103.41)
DDR_A_DQ13: length 64.1
  IN1 w0.099: v1(117.77,84.32) 117.59,84.5 117.59,87.43 115.78,89.24 113.18,89.24 113.02,89.4 113.02,89.54 113.53,90.06 113.53,90.2 113.39,90.34 113.25,90.34 112.74,89.82 112.6,89.82 112.45,89.96 112.45,90.1 112.97,90.62 112.97,90.76 112.83,90.9 112.69,90.9 112.17,90.38 112.03,90.38 111.89,90.53 111.89,90.67 112.6,91.37 112.6,91.51 112.46,91.65 112.32,91.65 111.61,90.95 111.47,90.95 105.89,96.53
  IN1 w0.102: v1(74.88,103.42) 74.88,103.29 75.3,102.87 79.36,102.87 79.43,102.8 80.55,102.8
  IN1 w0.109: 105.89,96.53 99.62,102.8 80.55,102.8
  BOTTOM w0.1: v1(117.77,84.32) 117.77,84.27 118.03,84.01 UC1.F25
  BOTTOM w0.102: JDIMM1.25 78.31,103.99 78.08,103.75 78.08,103.42 77.35,102.7 75.31,102.7 74.88,103.13 v1(74.88,103.42)
DDR_A_DQ14: length 60.1
  IN1 w0.099: v1(117.56,81.79) 117.56,81.8 117.13,82.23 116.24,82.23 115.85,82.61 115.85,83.19 115.36,83.68 115.36,84.33 115.46,84.42 115.46,86.3 114.41,87.35 112.45,87.35 107.6,92.2 106.04,92.2 101.71,96.53
  IN1 w0.102: v1(76.27,98.93) 76.27,99.11 76.37,99.21 80.82,99.21
  IN1 w0.109: 101.71,96.53 99.03,99.21 94.57,99.21 94.1,99.68 93.79,99.68 93.68,99.57 93.68,99.32 93.57,99.21 93.35,99.21 93.24,99.32 93.24,99.57 93.13,99.68 92.91,99.68 92.8,99.57 92.8,99.32 92.69,99.21 92.47,99.21 92.37,99.32 92.37,99.57 92.26,99.68 92.04,99.68 91.93,99.57 91.93,99.32 91.82,99.21 91.6,99.21 91.49,99.32 91.49,99.57 91.38,99.68 81.29,99.68 80.82,99.21
  BOTTOM w0.1: UC1.K25 118.03,81.41 117.66,81.78 117.56,81.78 v1(117.56,81.79)
  BOTTOM w0.102: 73.79,99.54 72.71,100.62 71.85,100.62 71.73,100.74 JDIMM1.38
  BOTTOM w0.112: 73.79,99.54 75.81,99.54 76.27,99.07 v1(76.27,98.93)
DDR_A_DQ15: length 63.5
  IN1 w0.099: v1(116.23,81.81) 116.23,81.96 115.66,82.53 115.66,83.11 115.17,83.6 115.17,85.43 113.44,87.15 112.37,87.15 107.54,91.98 105.67,91.98 101.58,96.07
  IN1 w0.102: 80.44,98.79 80.18,98.53 75.16,98.53 75.06,98.64 v1(75.06,98.93)
  IN1 w0.109: 80.44,98.79 82.3,98.79 82.41,98.9 82.41,99.15 82.52,99.26 82.73,99.26 82.84,99.15 82.84,98.9 82.95,98.79 83.17,98.79 83.28,98.9 83.28,99.15 83.39,99.26 83.61,99.26 83.72,99.15 83.72,98.9 83.83,98.79 84.04,98.79 84.15,98.9 84.15,99.15 84.26,99.26 84.48,99.26 84.59,99.15 84.59,98.9 84.7,98.79 84.92,98.79 85.03,98.9 85.03,99.15 85.14,99.26 85.36,99.26 85.46,99.15 85.46,98.9 85.57,98.79 85.79,98.79 85.9,98.9 85.9,99.15 86.01,99.26 86.23,99.26 86.34,99.15 86.34,98.9 86.45,98.79 86.67,98.79 86.78,98.9 86.78,99.15 86.88,99.26 87.1,99.26 87.21,99.15 87.21,98.9 87.32,98.79 87.56,98.79 87.67,98.9 87.67,99.15 87.78,99.26 87.99,99.26 88.1,99.15 88.1,98.9 88.21,98.79 88.43,98.79 88.54,98.9 88.54,99.15 88.65,99.26 88.87,99.26 88.98,99.15 88.98,98.9 89.09,98.79 89.31,98.79 89.41,98.9 89.41,99.15 89.52,99.26 89.74,99.26 89.85,99.15 89.85,98.9 89.96,98.79 90.18,98.79 90.29,98.9 90.29,99.15 90.4,99.26 90.62,99.26 90.72,99.15 90.72,98.9 90.83,98.79 98.86,98.79 101.58,96.07
  BOTTOM w0.1: UC1.K27 116.53,81.51 v1(116.23,81.81)
  BOTTOM w0.102: 75.06,98.7 75.39,98.37 76.35,98.37 77.97,99.99 77.97,100.62 78.34,100.99 JDIMM1.37
  BOTTOM w0.112: 75.06,98.7 v1(75.06,98.93)
DDR_A_DQ16: length 57.7
  IN1 w0.099: v1(117.63,79.81) 117.25,80.19 115.93,80.19 115.61,79.88 115.1,79.88 114.84,80.13 114.84,81.03 114.73,81.14 114.73,81.15 114.11,81.77 114.11,84.2 113.43,84.89 108.77,84.89 102.66,91 102.66,91.57 101.58,92.65 101.58,92.94
  IN1 w0.102: 80.55,96.36 80.37,96.19 75.4,96.19 v1(74.55,97.04)
  IN1 w0.109: 80.55,96.36 81.21,96.36 81.81,95.76 98.77,95.76 101.58,92.94
  BOTTOM w0.102: v1(74.55,97.04) 74.12,97.47 72.26,97.47 71.99,97.74 JDIMM1.50 ; v1(117.63,79.81) 118.03,79.41 UC1.M25
DDR_A_DQ17: length 60.4
  IN1 w0.099: 101.58,92.36 102.46,91.48 102.46,90.91 108.68,84.69 113.34,84.69 113.91,84.12 113.91,81.69 114.53,81.07 114.53,81.06 114.64,80.95 114.64,80.05 115.01,79.68 115.69,79.68 115.77,79.75 116.23,79.75 v1(116.29,79.81)
  IN1 w0.102: 80.55,95.95 80.34,95.95 80.34,95.96 75.15,95.96 75.03,96.08 73.76,96.08 73.37,96.47 73.37,97.02 v1(73.36,97.04)
  IN1 w0.109: 80.55,95.95 80.77,95.95 81.37,95.35 98.59,95.35 101.51,92.43 101.58,92.36
  BOTTOM w0.102: UC1.M27 116.53,79.59 116.31,79.81 v1(116.29,79.81)
  BOTTOM w0.112: JDIMM1.49 78.23,97.99 78.11,97.88 78.11,97.05 77.68,96.62 73.85,96.62 73.43,97.04 v1(73.36,97.04)
DDR_A_DQ18: length 56.8
  IN1 w0.099: 101.58,89.39 101.99,88.98 102.32,88.98 110.77,80.53 112.09,80.53 112.14,80.48 112.4,80.48 112.75,80.14 113.05,80.14 114.9,78.29 114.9,78.15 115.26,77.8 v1(116.26,77.8)
  IN1 w0.102: 80.55,93.25 80.05,93.25 79.63,93.67 73.21,93.67 72.97,93.91 72.97,94.14 73.07,94.24 74.16,94.24 74.27,94.34 74.27,94.55 74.16,94.65 73.07,94.65 72.97,94.75 72.97,95.37 v1(72.95,95.38)
  IN1 w0.109: 101.58,89.39 100.33,89.39 96.47,93.25 80.55,93.25
  BOTTOM w0.102: v1(116.26,77.8) 116.53,77.53 UC1.P27 ; v1(72.95,95.38) 72.31,94.74 JDIMM1.62
DDR_A_DQ19: length 59.8
  IN1 w0.099: v1(118.43,76.96) 117.99,77.39 117.44,77.39 117.14,77.1 116.04,77.1 115.73,77.4 115.09,77.4 113.72,78.78 113.46,78.78 113.06,78.78 111.71,80.13 110.61,80.13 107.17,83.57 106.73,83.57 104.19,86.12 103.78,86.12 103.53,86.37 103.53,86.51 103.81,86.79 103.81,86.93 103.67,87.07 103.53,87.07 103.25,86.79 103.11,86.79 102.97,86.93 102.97,87.07 103.25,87.35 103.25,87.49 103.11,87.63 102.97,87.63 102.72,87.38 102.58,87.38 102.07,87.89 102.07,88.08 101.79,88.37 101.58,88.37
  IN1 w0.102: 80.87,92.13 80.24,92.13 80.14,92.23 80.14,92.32 80.04,92.43 79.84,92.43 79.74,92.32 79.74,92.23 79.63,92.13 79.4,92.13 79.3,92.23 79.3,92.95 79.2,93.05 79,93.05 78.9,92.95 78.9,92.23 78.8,92.13 78.59,92.13 78.49,92.23 78.49,92.95 78.39,93.05 78.19,93.05 78.08,92.95 78.08,92.23 77.92,92.06 77.01,92.06 76.91,92.17 76.91,92.56 v1(76.93,92.58)
  IN1 w0.109: 80.87,92.13 81.1,92.13 81.21,92.24 81.21,92.31 81.32,92.42 81.54,92.42 81.65,92.31 81.65,92.24 81.76,92.13 90.04,92.13 90.15,92.24 90.15,92.31 90.26,92.42 90.48,92.42 90.59,92.31 90.59,92.24 90.7,92.13 90.92,92.13 91.03,92.24 91.03,92.31 91.14,92.42 91.35,92.42 91.46,92.31 91.46,92.24 91.57,92.13 91.79,92.13 91.9,92.24 91.9,92.31 92.01,92.42 92.23,92.42 92.34,92.31 92.34,92.24 92.45,92.13 92.66,92.13 92.77,92.24 92.77,92.31 92.88,92.42 93.1,92.42 93.21,92.31 93.21,92.24 93.32,92.13 96.42,92.13 100.18,88.37 101.58,88.37
  BOTTOM w0.102: v1(76.93,92.58) 76.93,93.11 78.31,94.49 JDIMM1.63 ; v1(118.43,76.96) 118.43,76.81 118.83,76.41 UC1.R24
DDR_A_DQ20: length 57.1
  IN1 w0.099: 101.58,94.2 101.58,93.9 104.21,91.28 107.4,91.28 112.19,86.49 112.39,86.49 114.51,84.37 114.51,81.94 115.13,81.32 115.13,81.31 115.55,80.88 116.21,80.88 v1(116.27,80.83)
  IN1 w0.102: v1(75.72,97.05) 76.16,97.49 79.87,97.49 80.05,97.31 80.55,97.31
  IN1 w0.109: 101.58,94.2 98.48,97.31 90.27,97.31 90.16,97.2 90.16,96.94 90.05,96.83 89.83,96.83 89.72,96.94 89.72,97.2 89.61,97.31 89.37,97.31 89.26,97.2 89.26,96.73 89.15,96.62 88.93,96.62 88.82,96.73 88.82,97.2 88.71,97.31 80.55,97.31
  BOTTOM w0.1: UC1.L27 116.53,80.55 116.27,80.82 v1(116.27,80.83)
  BOTTOM w0.102: JDIMM1.46 71.86,98.74 72.08,98.52 72.78,98.52 73.34,97.96 74.55,97.96 74.97,97.54
  BOTTOM w0.112: v1(75.72,97.05) 75.23,97.54 74.97,97.54
DDR_A_DQ21: length 60
  IN1 w0.099: 101.58,93.62 104.12,91.08 107.32,91.08 112.11,86.29 112.3,86.29 114.31,84.28 114.31,81.86 114.93,81.23 114.93,81.22 115.47,80.68 115.88,80.68 116.17,80.39 117.33,80.39 117.33,80.39 117.85,80.39 v1(118.43,79.81)
  IN1 w0.102: v1(76.96,97.07) 77.35,96.68 78.2,96.68 78.35,96.83 80.55,96.83
  IN1 w0.109: 80.55,96.83 82.38,96.83 82.49,96.72 82.49,96.28 82.6,96.18 82.82,96.18 82.92,96.28 82.92,96.72 83.03,96.83 83.25,96.83 83.36,96.72 83.36,96.28 83.47,96.18 83.69,96.18 83.8,96.28 83.8,96.72 83.91,96.83 84.13,96.83 84.24,96.72 84.24,96.28 84.34,96.18 84.56,96.18 84.67,96.28 84.67,96.72 84.78,96.83 85,96.83 85.11,96.72 85.11,96.28 85.22,96.18 85.44,96.18 85.55,96.28 85.55,96.72 85.66,96.83 85.87,96.83 85.98,96.72 85.98,96.28 86.09,96.18 86.31,96.18 86.42,96.28 86.42,96.72 86.53,96.83 86.93,96.83 87.03,96.72 87.03,96.56 87.14,96.45 87.36,96.45 87.47,96.56 87.47,96.72 87.58,96.83 87.92,96.83 88.58,96.18 99.02,96.18 101.58,93.62
  BOTTOM w0.1: v1(118.43,79.81) 118.83,79.41 UC1.M24
  BOTTOM w0.102: JDIMM1.45 78.24,98.99 76.96,97.72 v1(76.96,97.07)
DDR_A_DQ22: length 57.1
  IN1 w0.099: v1(118.42,77.77) 117.97,78.22 116.09,78.22 116.08,78.23 116.03,78.23 115.42,78.84 114.63,78.84 113.14,80.34 112.83,80.34 112.48,80.68 112.22,80.68 112.18,80.73 110.86,80.73 108.18,83.41 102.41,89.18 102.08,89.18 102,89.26 102,89.56 101.58,89.98
  IN1 w0.102: v1(74.17,95.41) 74.17,94.95 75.24,93.87 79.71,93.87 79.92,93.66 80.55,93.66
  IN1 w0.109: 80.55,93.66 97.9,93.66 98.39,93.17 98.39,93.01 98.13,92.75 98.13,92.59 98.28,92.44 98.44,92.44 98.7,92.7 98.86,92.7 101.58,89.98
  BOTTOM w0.102: JDIMM1.58 72.7,95.74 72.81,95.84 73.74,95.84 v1(74.17,95.41) ; UC1.P24 118.83,77.41 118.45,77.79 118.42,77.79 v1(118.42,77.77)
DDR_A_DQ23: length 59.7
  IN1 w0.099: 101.58,88.8 101.61,88.78 102.24,88.78 110.69,80.33 111.79,80.33 113.15,78.98 113.46,78.98 113.72,78.98 113.8,78.98 115.18,77.6 115.85,77.6 116.15,77.3 117.02,77.3 117.5,77.77 v1(117.67,77.77)
  IN1 w0.102: v1(75.82,92.59) 75.82,92.81 75.41,93.22 75.41,93.37 75.51,93.47 76.07,93.47 76.17,93.37 76.17,93.19 76.27,93.09 76.47,93.09 76.57,93.19 76.57,93.37 76.68,93.47 77.12,93.47 77.22,93.37 77.22,93.19 77.33,93.09 77.53,93.09 77.63,93.19 77.63,93.37 77.73,93.47 79.55,93.47 80.18,92.83 80.55,92.83
  IN1 w0.109: 101.58,88.8 100.33,88.8 96.3,92.83 89.72,92.83 89.61,92.73 89.61,92.65 89.5,92.55 89.28,92.55 89.17,92.65 89.17,92.73 89.06,92.83 88.85,92.83 88.74,92.73 88.74,92.65 88.63,92.55 88.41,92.55 88.3,92.65 88.3,92.73 88.19,92.83 87.97,92.83 87.86,92.73 87.86,92.65 87.75,92.55 87.54,92.55 87.43,92.65 87.43,92.73 87.32,92.83 87.1,92.83 86.99,92.73 86.99,92.65 86.88,92.55 86.66,92.55 86.55,92.65 86.55,92.73 86.44,92.83 86.22,92.83 86.12,92.73 86.12,92.65 86.01,92.55 85.79,92.55 85.68,92.65 85.68,92.73 85.57,92.83 85.35,92.83 85.24,92.73 85.24,92.65 85.13,92.55 84.91,92.55 84.8,92.65 84.8,92.73 84.7,92.83 84.48,92.83 84.37,92.73 84.37,92.65 84.26,92.55 84.04,92.55 83.93,92.65 83.93,92.73 83.82,92.83 83.6,92.83 83.49,92.73 83.49,92.65 83.38,92.55 83.17,92.55 83.06,92.65 83.06,92.73 82.95,92.83 82.73,92.83 82.62,92.73 82.62,92.65 82.51,92.55 82.29,92.55 82.18,92.65 82.18,92.73 82.07,92.83 80.55,92.83
  BOTTOM w0.1: v1(117.67,77.77) 117.67,77.72 117.72,77.72 118.03,77.41 UC1.P25
  BOTTOM w0.102: JDIMM1.59 78.44,95.49 77.94,94.99 77.94,94.4 77.19,93.66 76.78,93.66
  BOTTOM w0.112: v1(75.82,92.59) 75.82,92.69 76.78,93.66
DDR_A_DQ24: length 60.9
  IN1 w0.099: v1(120.17,80.11) 120.17,79.9 120.43,79.64 120.43,78.3 120.08,77.95 120.08,77.79 119.4,77.11 119.4,76.69 118.89,76.17 117.51,76.17 117.18,76.5 115.79,76.5 115.49,76.81 114.74,76.81 113.36,78.19 112.82,78.19 111.46,79.54 110.36,79.54 106.92,82.98 106.49,82.98 103.94,85.52 103.54,85.52 102.77,86.29 102.7,86.29 102.37,86.63 102.16,86.63 101.99,86.8 101.99,86.81 101.75,87.05 101.58,87.05
  IN1 w0.102: 80.55,90.81 78.67,90.81 78.03,91.45 74.98,91.45 74.38,92.06 73.2,92.06 72.78,92.48 v1(72.78,92.74)
  IN1 w0.109: 80.55,90.81 95.87,90.81 99.62,87.05 101.58,87.05
  BOTTOM w0.102: v1(120.17,80.11) 120.17,80.11 120.17,79.57 UC1.M22 ; v1(72.78,92.74) 72.41,92.38 72.03,92.38 71.67,92.74 JDIMM1.70
DDR_A_DQ25: length 63.6
  IN1 w0.099: 99.45,86.64 101.81,86.64 102.02,86.43 102.29,86.43 102.62,86.09 102.69,86.09 103.45,85.33 103.86,85.33 106.4,82.78 106.84,82.78 110.28,79.34 111.38,79.34 112.73,77.99 113.28,77.99 114.5,76.76 114.5,76.55 115.12,75.93 116.24,75.93 116.62,76.31 117.1,76.31 117.42,75.98 118.97,75.98 119.6,76.61 119.6,77.02 120.34,77.76 120.34,77.93 120.84,78.43 v1(120.84,78.82)
  IN1 w0.102: v1(76.09,90.87) 76.23,90.87 76.36,90.74 76.36,90.69 76.42,90.63 76.42,89.75 76.32,89.65 75.54,89.65 74.44,90.75 74.44,90.89 74.8,91.25 77.6,91.25 78.45,90.4 80.55,90.4
  IN1 w0.109: 99.45,86.64 95.69,90.4 80.55,90.4
  BOTTOM w0.1: UC1.N21 120.84,78.7 v1(120.84,78.82)
  BOTTOM w0.102: v1(76.09,90.87) 76.09,91.1 76.87,91.89 77.82,91.89 78.42,92.49 JDIMM1.71
DDR_A_DQ26: length 63.5
  IN1 w0.099: 101.58,84.55 102.63,84.55 102.84,84.34 103.45,84.34 105.99,81.79 106.43,81.79 109.87,78.35 110.97,78.35 112.32,77 112.61,77 112.61,76.28 113.48,75.4 114.16,75.4 114.67,74.89 116.22,74.89 116.35,74.76 117.3,74.76 117.63,74.43 118.14,74.43 118.29,74.58 119.28,74.58 119.84,75.14 120.22,75.14 v1(120.84,75.75)
  IN1 w0.102: v1(77.02,88.46) 76.9,88.46 76.72,88.29 76.72,87.73 76.82,87.63 77.28,87.63 77.38,87.73 77.38,88.07 77.48,88.17 77.68,88.17 77.79,88.07 77.79,87.73 77.89,87.63 78.09,87.63 78.19,87.73 78.19,88.07 78.29,88.17 78.5,88.17 78.6,88.07 78.6,87.73 78.7,87.63 78.9,87.63 79.01,87.73 79.01,88.07 79.11,88.17 79.31,88.17 79.41,88.07 79.41,87.73 79.51,87.63 79.8,87.63 80.38,88.2 80.55,88.2
  IN1 w0.109: 80.55,88.2 81.11,88.2 81.5,87.81 92.98,87.81 93.66,87.13 93.82,87.13 94.12,87.43 94.27,87.43 94.43,87.27 94.43,87.12 94.13,86.82 94.13,86.66 94.29,86.49 94.45,86.49 94.84,86.89 95.04,86.89 95.15,86.78 95.15,86.58 94.76,86.19 94.76,86.03 94.91,85.88 95.07,85.88 95.46,86.27 95.62,86.27 95.75,86.14 95.75,85.94 95.38,85.57 95.38,85.41 95.53,85.26 95.69,85.26 96.3,85.87 96.46,85.87 96.61,85.72 96.61,85.57 95.99,84.95 95.99,84.79 96.24,84.55 101.58,84.55
  BOTTOM w0.102: v1(77.02,88.46) 77.02,88.86 77.65,89.49 JDIMM1.83 ; UC1.T22 120.43,75.35 v1(120.84,75.75)
DDR_A_DQ27: length 60.6
  IN1 w0.099: v1(120.83,74.81) 120.83,74.35 120.65,74.16 120.18,74.16 120.16,74.18 118.46,74.18 118.3,74.03 117.47,74.03 117.13,74.36 116.31,74.36 115.88,73.93 114.54,73.93 113.83,74.64 112.89,74.64 112.62,74.91 112.62,75.37 112.62,75.7 112.21,76.11 112.21,76.6 112.16,76.6 110.8,77.96 109.7,77.96 106.26,81.39 105.83,81.39 103.5,83.72 101.58,83.72
  IN1 w0.102: 80.55,87.37 80.22,87.37 80.07,87.22 72.97,87.22 72.72,87.47 v1(72.72,89.73)
  IN1 w0.109: 80.55,87.37 80.77,87.37 81.16,86.98 92.64,86.98 95.89,83.72 101.58,83.72
  BOTTOM w0.1: v1(120.83,74.81) 121.23,74.41 UC1.V21
  BOTTOM w0.102: v1(72.72,89.73) 72.72,89.41 72.54,89.24 JDIMM1.84
DDR_A_DQ28: length 61.8
  IN1 w0.099: v1(120.73,80.46) 120.64,80.55 119.9,80.55 119.65,80.31 119.65,77.64 119.2,77.19 119.2,76.77 118.8,76.37 117.59,76.37 117.45,76.51 117.45,76.51 117.26,76.7 115.87,76.7 115.57,77 114.82,77 113.44,78.38 112.9,78.38 111.54,79.74 110.44,79.74 107,83.18 106.57,83.18 104.02,85.72 103.62,85.72 102.85,86.49 102.85,86.49 101.87,87.46 101.58,87.46
  IN1 w0.102: v1(73.99,92.73) 75.07,91.66 78.39,91.66 78.82,91.23 80.55,91.23
  IN1 w0.109: 101.58,87.46 99.8,87.46 96.04,91.23 80.55,91.23
  BOTTOM w0.102: JDIMM1.66 73.26,93.74 73.27,93.75 73.93,93.75 74.07,93.61 74.07,92.81 v1(73.99,92.73) ; v1(120.73,80.46) 121.08,80.11 UC1.L21
DDR_A_DQ29: length 65
  IN1 w0.099: 101.58,87.88 101.75,87.88 102,87.63 102,87.62 102.93,86.68 102.94,86.68 103.7,85.92 104.11,85.92 106.65,83.38 107.09,83.38 110.53,79.94 111.63,79.94 112.98,78.58 113.46,78.58 113.63,78.58 115.01,77.2 115.65,77.2 115.95,76.9 117.24,76.9 117.3,76.96 117.3,76.98 117.52,77.2 117.83,77.2 118.05,76.98 118.05,76.8 118.14,76.71 118.14,76.71 118.28,76.57 118.71,76.57 118.81,76.67 118.81,80.02 119.21,80.43 119.49,80.43 119.9,80.83 120.91,80.83 121.09,80.65
  IN1 w0.102: 80.55,91.64 78.89,91.64 78.67,91.86 75.43,91.86 v1(74.68,92.62)
  IN1 w0.109: v1(121.73,79.71) 121.73,79.96 121.31,80.39 121.31,80.44 121.09,80.65 ; 101.58,87.88 99.98,87.88 96.21,91.64 80.55,91.64
  BOTTOM w0.1: v1(121.73,79.71) 122.02,79.42 122.12,79.42 UC1.M20
  BOTTOM w0.102: 75.19,91.98 76.53,91.98 76.65,92.1 77.74,92.1 77.98,92.34 77.98,93.06 78.41,93.49 JDIMM1.67
  BOTTOM w0.112: 75.19,91.98 74.68,92.49 v1(74.68,92.62)
DDR_A_DQ30: length 63.8
  IN1 w0.099: 97.95,84.97 102.03,84.97 102.25,84.75 102.71,84.75 102.92,84.53 103.53,84.53 106.07,81.99 106.51,81.99 109.95,78.55 111.05,78.55 112.41,77.19 112.81,77.19 112.81,76.36 113.56,75.6 114.24,75.6 114.76,75.09 116.31,75.09 116.44,74.96 117.18,74.96 117.4,75.18 119.3,75.18 119.42,75.31 119.73,75.31 120.13,75.7 v1(120.13,75.76)
  IN1 w0.102: v1(75.75,88.46) 75.75,88.87 75.85,88.97 78.14,88.97 78.5,88.62 80.55,88.62
  IN1 w0.109: 97.95,84.97 94.69,88.22 90.56,88.22 90.45,88.33 90.45,88.39 90.34,88.5 90.13,88.5 90.02,88.39 90.02,88.33 89.91,88.22 89.55,88.22 89.44,88.33 89.44,88.61 89.34,88.72 89.12,88.72 89.01,88.61 89.01,88.33 88.9,88.22 88.68,88.22 88.57,88.33 88.57,88.61 88.46,88.72 88.24,88.72 88.13,88.61 88.13,88.33 88.02,88.22 87.81,88.22 87.7,88.33 87.7,88.61 87.59,88.72 87.37,88.72 87.26,88.61 87.26,88.33 87.15,88.22 86.93,88.22 86.82,88.33 86.82,88.61 86.71,88.72 86.5,88.72 86.39,88.61 86.39,88.33 86.28,88.22 86.06,88.22 85.95,88.33 85.95,88.61 85.84,88.72 85.62,88.72 85.51,88.61 85.51,88.33 85.4,88.22 85.18,88.22 85.08,88.33 85.08,88.61 84.97,88.72 84.75,88.72 84.64,88.61 84.64,88.33 84.53,88.22 84.31,88.22 84.2,88.33 84.2,88.61 84.09,88.72 83.87,88.72 83.76,88.61 83.76,88.33 83.66,88.22 83.44,88.22 83.33,88.33 83.33,88.61 83.22,88.72 83,88.72 82.89,88.61 82.89,88.33 82.78,88.22 82.56,88.22 82.45,88.33 82.45,88.61 82.35,88.72 82.13,88.72 82.02,88.61 82.02,88.33 81.91,88.22 81.67,88.22 81.28,88.62 80.55,88.62
  BOTTOM w0.102: JDIMM1.79 77.54,90.49 77.51,90.46 76.92,90.46 75.75,89.29 v1(75.75,88.46) ; v1(120.13,75.76) 120.13,75.81 UC1.R23
DDR_A_DQ31: length 61.1
  IN1 w0.099: 101.45,84.14 103.37,84.14 105.91,81.59 106.35,81.59 109.78,78.15 110.89,78.15 112.24,76.8 112.41,76.8 112.41,76.19 113.4,75.2 114.08,75.2 114.59,74.69 116.14,74.69 116.27,74.56 117.21,74.56 117.55,74.23 118.22,74.23 118.37,74.38 120.24,74.38 120.25,74.38 120.45,74.58 120.45,75.04 120.65,75.24 121.77,75.24 v1(121.85,75.32)
  IN1 w0.102: 80.26,87.79 79.89,87.42 74.36,87.42 74.26,87.52 v1(74.26,89.57)
  IN1 w0.109: 80.26,87.79 80.94,87.79 81.33,87.4 92.81,87.4 96.07,84.14 101.45,84.14
  BOTTOM w0.1: UC1.T21 121.84,75.31 v1(121.85,75.32)
  BOTTOM w0.102: v1(74.26,89.57) 74.37,89.68 74.37,89.89 74,90.25 72.99,90.25 72.97,90.24 JDIMM1.80
DDR_A_DQ32: length 53.2
  IN1 w0.099: v1(116.14,63.7) 115.93,63.5 113.85,63.5 113.6,63.74 111.96,63.74 111.37,63.16 105.47,63.16 104.08,61.77 102.84,61.77 101.78,60.71 101.58,60.71
  IN1 w0.102: 80.55,64.15 80.23,64.15 78.68,65.7 74.95,65.7 73.94,66.71 72.81,66.71 72.26,66.17 72.26,65.2 v1(72.89,64.57)
  IN1 w0.109: 80.55,64.15 82.4,64.15 86.47,60.07 89.79,60.07 90.43,60.71 101.58,60.71
  BOTTOM w0.102: v1(72.89,64.57) 72.58,64.88 72.58,64.89 72.48,64.99 71.95,64.99 71.69,64.74 JDIMM1.174 ; UC1.AL27 v1(116.14,63.7)
DDR_A_DQ33: length 56
  IN1 w0.099: v1(117.63,62.81) 117.52,62.81 117.11,62.4 116.81,62.4 116.3,62.9 113.17,62.9 112.83,62.56 105.71,62.56 104.26,61.11 103.41,61.11 101.63,59.33 101.58,59.33
  IN1 w0.102: v1(76.67,64.66) 76.25,64.24 73.69,64.24 73.5,64.05 73.5,63.84 73.58,63.76 76.71,63.76 76.81,63.86 76.81,64.08 76.91,64.18 77.12,64.18 77.22,64.08 77.22,63.86 77.32,63.76 78.42,63.76 79.13,63.06 79.86,63.06 80.01,62.91 80.55,62.91
  IN1 w0.109: 80.55,62.91 81.88,62.91 85.97,58.82 90.29,58.82 90.8,59.33 101.58,59.33
  BOTTOM w0.102: JDIMM1.173 78.23,64.99 78.04,65.19 77.19,65.19 v1(76.67,64.66) ; v1(117.63,62.81) 118.03,63.21 UC1.AL25
DDR_A_DQ34: length 56.9
  IN1 w0.099: v1(116.3,60.81) 116.17,60.81 115.74,61.24 114.8,61.24 114.71,61.14 114.71,61.02 114.61,60.92 114.41,60.92 114.31,61.02 114.31,61.14 114.21,61.24 113.25,61.24 112.92,61.57 106.54,61.57 104.62,59.65 104.62,58.57 104.36,58.32 104.22,58.32 103.82,58.72 103.68,58.72 103.54,58.58 103.54,58.44 103.94,58.04 103.94,57.9 103.78,57.74 103.64,57.74 103.24,58.14 103.1,58.14 102.96,58 102.96,57.86 103.36,57.46 103.36,57.32 102.76,56.72 101.58,56.72
  IN1 w0.102: v1(75.64,61.57) 75.64,61.39 75.46,61.21 74.94,61.21 74.84,61.11 74.84,60.89 74.94,60.79 75.92,60.79 76.02,60.89 76.02,61.13 76.12,61.24 76.32,61.24 76.42,61.13 76.42,60.89 76.52,60.79 77.24,60.79 77.72,60.31 79.78,60.31 79.97,60.5 79.97,60.82 80.07,60.92 80.41,60.92 80.48,60.85 80.48,60.68 80.55,60.61
  IN1 w0.109: 80.55,60.61 80.63,60.54 80.82,60.54 84.64,56.72 101.58,56.72
  BOTTOM w0.102: UC1.AP26 116.73,60.81 v1(116.3,60.81) ; v1(75.64,61.57) 76.06,61.15 78.01,61.15 78.35,61.49 JDIMM1.187
DDR_A_DQ35: length 52.9
  IN1 w0.099: v1(115.86,59.83) 115.8,59.77 115.01,59.77 114.97,59.8 114.76,59.8 113.73,60.84 113.09,60.84 112.75,61.17 106.7,61.17 105.01,59.49 105.01,57.09 103.82,55.89 101.58,55.89
  IN1 w0.102: 80.55,59.64 80.28,59.9 77.55,59.9 77.07,60.38 73.82,60.38 73.06,61.14 v1(73.06,61.61)
  IN1 w0.109: 80.55,59.64 84.3,55.89 101.58,55.89
  BOTTOM w0.102: UC1.AR27 116.12,59.72 115.97,59.72 v1(115.86,59.83) ; v1(73.06,61.61) 73.06,61.64 72.78,61.92 72.1,61.92 71.92,61.74 JDIMM1.186
DDR_A_DQ36: length 53.2
  IN1 w0.099: v1(116.88,63.71) 116.71,63.71 116.29,63.3 113.77,63.3 113.52,63.54 112.27,63.54 111.68,62.96 105.55,62.96 104.16,61.57 102.92,61.57 101.65,60.3 101.58,60.3
  IN1 w0.102: v1(74.16,64.65) 74.16,64.89 73.76,65.28 73.76,65.43 74.26,65.93 74.4,65.93 74.83,65.5 78.59,65.5 80.36,63.73 80.55,63.73
  IN1 w0.109: 80.55,63.73 82.23,63.73 86.31,59.65 89.96,59.65 90.6,60.3 101.58,60.3
  BOTTOM w0.102: v1(116.88,63.71) 116.9,63.71 117.23,64.05 UC1.AK26 ; v1(74.16,64.65) 73.07,65.74 JDIMM1.170
DDR_A_DQ37: length 56.7
  IN1 w0.099: 101.58,59.84 103.11,61.37 104.24,61.37 105.63,62.76 112.75,62.76 113.09,63.1 116.38,63.1 116.6,63.32 118.09,63.32 v1(118.46,63.69)
  IN1 w0.102: v1(75.43,64.66) 75.43,65.19 75.53,65.29 75.94,65.29 76.11,65.12 76.35,65.12 76.52,65.29 76.75,65.29 76.92,65.12 77.16,65.12 77.33,65.29 77.56,65.29 77.74,65.12 77.97,65.12 78.14,65.29 78.51,65.29 78.73,65.08 78.73,64.93 78.2,64.41 78.2,64.27 78.35,64.13 78.49,64.13 79.01,64.65 79.16,64.65 79.3,64.5 79.3,64.36 78.78,63.84 78.78,63.69 78.92,63.55 79.07,63.55 79.53,64.01 79.67,64.01 80.36,63.32 80.55,63.32
  IN1 w0.109: 101.58,59.84 101.54,59.8 90.68,59.8 90.12,59.23 86.14,59.23 82.05,63.32 80.55,63.32
  BOTTOM w0.102: UC1.AK24 118.83,64.06 v1(118.46,63.69) ; 76.75,65.99 v1(75.43,64.66)
  BOTTOM w0.112: JDIMM1.169 76.75,65.99
DDR_A_DQ38: length 56.2
  IN1 w0.099: v1(118.53,62.8) 118.44,62.8 117.87,62.23 117.53,62.23 117.25,61.95 117.25,61.44 117.15,61.34 117.03,61.34 116.93,61.25 116.02,61.25 115.8,61.46 114.88,61.46 114.85,61.44 113.33,61.44 113,61.77 106.45,61.77 106.16,61.48 106.02,61.48 106,61.5 105.86,61.5 105.72,61.36 105.72,61.22 105.74,61.2 105.74,61.06 105.6,60.92 105.46,60.92 105.44,60.94 105.29,60.94 105.15,60.8 105.15,60.66 105.18,60.64 105.18,60.5 104.72,60.03 104.58,60.03 104.39,60.22 104.25,60.22 104.11,60.08 104.11,59.94 104.3,59.75 104.3,59.61 102.56,57.88 102.56,57.74 102.96,57.34 102.96,57.2 102.82,57.06 102.68,57.06 102.28,57.46 102.14,57.46 101.82,57.13 101.58,57.13
  IN1 w0.102: v1(76.86,61.61) 76.81,61.56 76.81,61.1 76.91,60.99 77.8,60.99 77.87,61.06 77.87,61.25 78.2,61.59 78.4,61.59 78.5,61.49 78.5,60.83 78.6,60.73 78.8,60.73 78.9,60.83 78.9,61.49 79,61.59 79.21,61.59 79.31,61.49 79.31,60.83 79.41,60.73 79.61,60.73 79.72,60.83 79.72,61.16 79.82,61.26 80.44,61.26 80.48,61.22 80.55,61.22
  IN1 w0.109: 80.55,61.22 80.72,61.22 84.81,57.13 91.02,57.13 91.48,57.58 91.92,57.58 92.37,57.13 101.58,57.13
  BOTTOM w0.102: JDIMM1.183 77.73,62.49 77.66,62.41 77.66,62.4 77.42,62.16 77.41,62.16 v1(76.86,61.61) ; UC1.AM24 118.53,62.61 v1(118.53,62.8)
DDR_A_DQ39: length 53.3
  IN1 w0.099: v1(115.61,60.83) 115.5,60.72 114.13,60.72 113.81,61.04 113.17,61.04 112.84,61.37 106.62,61.37 104.82,59.57 104.82,57.17 103.95,56.3 101.58,56.3
  IN1 w0.102: 80.55,60.11 77.63,60.11 77.16,60.59 74.13,60.59 74.01,60.7 74.01,61.28 v1(74.34,61.62)
  IN1 w0.109: 101.58,56.3 84.47,56.3 80.67,60.11 80.55,60.11
  BOTTOM w0.099: 115.93,60.65 115.75,60.83 v1(115.61,60.83)
  BOTTOM w0.102: v1(74.34,61.62) 73.22,62.74 JDIMM1.182 ; UC1.AP27 116.27,60.31 115.93,60.65
DDR_A_DQ40: length 62.7
  IN1 w0.099: 101.58,54.99 103.48,54.99 105.41,56.92 105.41,59.32 106.87,60.78 112.59,60.78 112.92,60.44 113.43,60.44 113.89,59.99 113.89,59.78 113.79,59.67 113.79,59.53 113.93,59.39 114.07,59.39 114.17,59.49 114.31,59.49 114.55,59.25 116.1,59.25 116.44,59.59 116.44,59.98 117.69,61.24 117.89,61.24 118.31,61.66 118.31,61.96 118.55,62.2 119.09,62.2 119.23,62.06 v1(119.23,61.81)
  IN1 w0.102: 80.08,58.82 79.79,59.11 79.11,59.11 79,59.01 79,58.75 78.9,58.64 78.7,58.64 78.6,58.75 78.6,59.01 78.5,59.11 77.01,59.11 76.91,59.22 76.91,59.35 76.79,59.46 76.65,59.46 76.5,59.32 76.5,59.22 76.4,59.11 76.04,59.11 75.97,59.19 75.97,59.43 76.23,59.69 76.28,59.69 v1(76.39,59.8)
  IN1 w0.109: 101.58,54.99 83.92,54.99 81.85,57.06 81.7,57.06 81.23,56.59 81.08,56.59 80.95,56.72 80.95,56.87 81.39,57.31 81.39,57.52 81.23,57.68 81.08,57.68 80.45,57.05 80.29,57.05 80.14,57.21 80.14,57.36 80.77,57.99 80.77,58.14 80.61,58.3 80.55,58.3 80.46,58.3 79.87,57.7 79.64,57.7 79.53,57.82 79.53,58.05 80.12,58.64 80.12,58.79 80.08,58.82
  BOTTOM w0.102: UC1.AM23 119.63,62.21 v1(119.23,61.81) ; JDIMM1.195 78.34,59.49 78.03,59.8 v1(76.39,59.8)
DDR_A_DQ41: length 59.7
  IN1 w0.099: v1(120.83,61.81) 120.41,61.38 118.88,61.38 118.76,61.5 118.43,61.5 117.96,61.03 117.76,61.03 116.63,59.9 116.63,59.51 116.18,59.05 113.99,59.05 112.84,60.2 112.84,60.25 112.51,60.58 106.95,60.58 105.61,59.24 105.61,56.75 103.43,54.57 101.58,54.57
  IN1 w0.102: v1(73.96,59.75) 73.96,59.17 74.21,58.91 78.14,58.91 80.55,56.5
  IN1 w0.109: 80.55,56.5 80.69,56.36 80.72,56.36 80.96,56.12 82.2,56.12 83.75,54.57 101.58,54.57
  BOTTOM w0.1: v1(120.83,61.81) 121.23,62.21 UC1.AM21
  BOTTOM w0.102: JDIMM1.194 72,59.74 72.46,59.28 73.77,59.28 73.96,59.47 v1(73.96,59.75)
DDR_A_DQ42: length 62.3
  IN1 w0.099: v1(117.64,58.82) 117.35,58.82 116.75,58.22 116.75,57.69 116.45,57.4 116.04,57.4 115.58,57.87 114.3,57.87 114.2,57.77 114.2,57.35 114.1,57.25 113.9,57.25 113.8,57.35 113.8,57.77 113.7,57.87 113.48,57.87 113.38,57.77 113.38,57.69 113.28,57.59 113.08,57.59 112.98,57.69 112.98,57.77 112.88,57.87 112.65,57.87 112.44,57.65 112.43,57.65 112.33,57.55 112.33,57.1 112.23,57 111.99,57 111.89,57.1 111.89,57.55 111.79,57.65 111.59,57.65 111.49,57.55 111.49,57.1 111.39,57 111.2,57 111.1,57.1 111.1,57.55 111,57.65 110.8,57.65 110.7,57.55 110.7,57.1 110.6,57 110.4,57 110.3,57.1 110.3,57.55 110.21,57.65 110.01,57.65 109.91,57.55 109.91,57.1 109.81,57 107.03,57 106.93,56.9 106.93,56.37 102.59,52.04
  IN1 w0.102: v1(77.33,56.1) 77.33,55.66 77.23,55.56 76.63,55.56 76.53,55.46 76.53,55.09 76.63,54.99 77.48,54.99 77.84,54.63 77.98,54.63 78.04,54.69 78.19,54.69 78.33,54.55 78.33,54.4 78.27,54.34 78.27,54.19 78.52,53.95 78.66,53.95 79.28,54.57 79.43,54.57 79.57,54.42 79.57,54.28 78.95,53.66 78.95,53.51 79.09,53.37 79.24,53.37 79.86,53.99 80,53.99 80.15,53.85 80.15,53.71 79.52,53.08 79.52,52.94 79.95,52.51 80.21,52.51 80.31,52.62 80.31,53.34 80.41,53.44 80.61,53.44 80.71,53.34 80.71,52.73 80.82,52.63 80.99,52.63 81.1,52.73 81.1,53.25 81.2,53.35 81.4,53.35 81.5,53.25 81.5,52.78 81.65,52.63 82.11,52.63
  IN1 w0.109: 102.59,52.04 82.7,52.04 82.11,52.63
  BOTTOM w0.1: v1(117.64,58.82) 117.64,58.82 117.71,58.82 118.03,59.14 UC1.AR25
  BOTTOM w0.102: v1(77.33,56.1) 77.73,56.5 78.07,56.5 78.09,56.49 JDIMM1.207
DDR_A_DQ43: length 60
  IN1 w0.099: v1(116.31,57.79) 116.04,58.06 112.57,58.06 112.36,57.85 110.22,57.85 110.09,57.97 109.31,57.97 109.21,57.88 109.21,57.3 109.12,57.2 108.92,57.2 108.82,57.3 108.82,57.88 108.72,57.97 108.52,57.97 108.42,57.88 108.42,57.3 108.32,57.2 108.12,57.2 108.03,57.3 108.03,57.88 107.93,57.97 107.73,57.97 107.63,57.88 107.63,57.3 107.53,57.2 107.33,57.2 107.23,57.3 107.23,57.88 107.13,57.97 106.91,57.97 106.7,57.76 106.7,56.43 102.73,52.45 101.58,52.45
  IN1 w0.102: 80.55,54.02 79.46,55.11 79.32,55.11 78.76,54.55 78.61,54.55 78.47,54.7 78.47,54.84 79.03,55.4 79.03,55.54 78.89,55.69 78.74,55.69 78.18,55.13 78.04,55.13 77.89,55.27 77.89,55.41 78.46,55.98 78.46,56.12 77.5,57.08 77.28,57.08 76.6,56.4 76.6,56.25 v1(76.75,56.11)
  IN1 w0.109: 101.58,52.45 82.87,52.45 81.3,54.02 80.55,54.02
  BOTTOM w0.1: UC1.AU27 116.53,58.05 116.31,57.84 v1(116.31,57.79)
  BOTTOM w0.112: v1(76.75,56.11) 76.2,55.56 72.49,55.56 71.81,56.24 JDIMM1.208
DDR_A_DQ44: length 62.7
  IN1 w0.099: v1(120.03,62.81) 119.98,62.86 119.98,63.3 120.08,63.4 120.36,63.4 120.45,63.3 120.45,62.65 120.55,62.55 120.55,62.28 120.45,62.18 119.39,62.18 119.17,62.4 118.45,62.4 118.02,61.98 118.03,61.97 118.03,61.66 117.81,61.44 117.61,61.44 116.24,60.06 116.24,59.67 116.02,59.45 114.71,59.45 113.52,60.64 113,60.64 112.67,60.98 106.78,60.98 105.21,59.41 105.21,57 103.61,55.4 101.58,55.4
  IN1 w0.102: v1(75.15,59.74) 75.59,60.18 76.78,60.18 77.36,59.6 77.36,59.42 77.46,59.32 77.66,59.32 77.77,59.42 77.77,59.6 77.87,59.7 78.07,59.7 78.17,59.6 78.17,59.42 78.27,59.32 78.48,59.32 78.58,59.42 78.58,59.6 78.68,59.7 78.88,59.7 78.99,59.6 78.99,59.42 79.09,59.32 79.29,59.32 79.39,59.42 79.39,59.6 79.49,59.7 80.14,59.7 80.55,59.29 80.55,58.94
  IN1 w0.109: 101.58,55.4 84.1,55.4 80.55,58.94
  BOTTOM w0.1: UC1.AL22 120.43,63.21 v1(120.03,62.81)
  BOTTOM w0.102: JDIMM1.191 78.22,60.49 78.05,60.66 76.07,60.66 v1(75.15,59.74)
DDR_A_DQ45: length 60.6
  IN1 w0.099: v1(120.83,62.81) 121.09,62.55 ; 121.29,62.26 121.29,61.51 121.06,61.28 120.68,61.28 120.58,61.18 118.39,61.18 118.04,60.83 117.84,60.83 116.83,59.82 116.83,59.42 116.26,58.86 113.12,58.86 112.56,59.41 106.46,59.41 105.81,58.76 105.81,56.66 103.3,54.16 101.58,54.16
  IN1 w0.102: v1(72.71,59.79) 73.79,58.71 78.06,58.71 80.33,56.44 80.33,56.43 80.53,56.24 80.53,55.97 80.55,55.95
  IN1 w0.109: 121.09,62.55 121.29,62.34 121.29,62.26 ; 101.58,54.16 83.55,54.16 82,55.71 80.79,55.71 80.55,55.95
  BOTTOM w0.1: UC1.AL21 121.23,63.21 v1(120.83,62.81)
  BOTTOM w0.102: JDIMM1.190 72.2,60.74 72.71,60.23 v1(72.71,59.79)
