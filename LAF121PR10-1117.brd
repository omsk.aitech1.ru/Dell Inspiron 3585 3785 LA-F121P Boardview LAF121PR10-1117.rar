# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 42.7
  TOP w0.089: v1(14.83,19.24) v4(14.83,17.94) ; v4(8,7.32) 8.57,7.9 JHP1.7 ; v1(8.1,19.54) 7.41,19.54 v4(7.21,19.34)
  TOP w0.203: v1(22.95,15.5) 22.98,15.47 UA1.25 ; UA1.38 25.48,9.63 v1(25.24,9.39)
  TOP w0.508: v1(22.83,7.49) 22.44,7.88 CA27.2 ; v1(11.34,19.49) 11.08,19.24 RA30.2 ; CA28.2 v1(24.42,20.32) ; v1(24.58,18.73) CA56.2 ; CA10.2 v1(19.15,18.35) ; RA13.2 20.21,16.84 CA6.2 v1(19.08,17.27) ; CA20.1 v1(23.78,6.85) ; v1(20.67,13.97) CA23.2 ; CA48.2 30.64,19.68 30.18,20.14 CA29.2 v1(29.37,20.32) ; CA25.2 v1(25.48,20.6) ; CA19.1 v1(20.67,15.24) ; RA51.2 v1(21.37,20.25) ; CA26.2 v1(8.1,19.54) ; 24.99,6.15 v1(24.99,6.85)
  GND1 w0.203: JHP1.7 11.08,7.9 ; JHP1.7 10,7.23 ; JHP1.7 11.08,7.23 ; JHP1.7 8.92,7.9 ; JHP1.7 8.92,7.23
  VCC w0.203: 8.92,7.9 JHP1.7 ; JHP1.7 8.92,7.23 ; JHP1.7 11.08,7.9 ; JHP1.7 11.08,7.23 ; JHP1.7 10,7.23
  GND2 w0.203: 8.92,7.23 JHP1.7 ; JHP1.7 8.92,7.9 ; JHP1.7 10,7.23 ; JHP1.7 11.08,7.23 ; JHP1.7 11.08,7.9
  BOTTOM w0.508: CA67.2 CA42.2 CA41.2 ; v1(14.83,19.24) RA32.2 CA40.2 ; CA41.2 CA68.2 ; CA41.2 v1(17.29,12.58) ; CA39.2 v1(19.15,18.35) ; RA31.2 v1(19.08,19.24)
V3D3_STB: length 6.3
  TOP w0.203: RA54.2 RA12.1 26.01,20.24 v3(26.01,19.95) 26.01,18.09 26.62,17.48 26.62,16.96 26.68,16.9 UA1.20
VBAT_CHG: length 4.7
  TOP w0.089: v1(207.39,44) 207.29,43.9 v3(207.29,43.28)
  TOP w0.254: PCB45.1 208.24,42.68 207.75,43.17 207.75,43.63 v1(207.39,44)
  BOTTOM w0.203: PRB39.2 207.85,43.54 v1(207.39,44) 207.26,44.12 207.26,44.69 207.06,44.89 PUB01.31
VBUS_C_CTRL_P1: length 43.9
  TOP w0.089: v1(38.31,119.09) 38.31,119.15 v3(36.94,120.52)
  TOP w0.254: PUS02.1 59.99,125.79 v1(60.57,126.37) ; v1(66.49,125.47) 66.39,125.57 PRS35.2
  IN1 w0.089: v1(60.57,126.37) 61.01,125.94 61.01,124.38 60.54,123.91 60.54,121.68 v1(60.6,121.62) 59.57,120.59 57.13,120.59 56.1,119.57 51.16,119.57 50.75,119.99 49.31,119.99 49.23,120.07 43.03,120.07 42.05,119.09 v1(38.31,119.09)
  IN2 w0.254: v1(66.49,125.47) 66.52,125.45 66.52,124.91 65.54,123.93 65.54,122.78 63.77,121.01 61.21,121.01 v1(60.6,121.62)
  BOTTOM w0.089: RT118.1 38.2,118.97 v1(38.31,119.09) 38.31,119.5 38.14,119.68 UT1.12
VBUS_DISCHARGE: length 5.2
  BOTTOM w0.089: QT3.2 32.85,116.37 33.23,116.75 RT32.1 33.77,117.81 v3(33.77,118.33) 33.77,119.57 34.14,119.94 UT1.20
VBUS_MON_P1: length 7.1
  TOP w0.089: CT9.1 RT3.1 36.44,119.69 36.48,119.73 37.21,119.73 37.73,119.21 v1(37.73,119.04) 37.17,118.49 v3(35.9,118.49)
  BOTTOM w0.089: RT1.2 37.73,118.79 v1(37.73,119.04) 37.73,119.39 37.64,119.48 UT1.13
VBUS_P_CTRL_P1: length 29.9
  TOP w0.254: PRS38.1 v1(50.3,127.54) 50.4,127.54 50.8,127.15 51.35,127.15 51.68,126.82 51.68,126.27 51.91,126.04 PUS03.1
  BOTTOM w0.089: RT117.1 38.83,118.63 38.83,119.48 38.64,119.67 UT1.11 ; RT117.1 39.35,118.11 40.41,118.11 41.41,117.1 41.41,116.12 38.86,113.57 QT5.1 ; RT117.1 40.45,119.86 v3(40.76,119.86) 43.03,119.86 50.3,127.12 v1(50.3,127.54)
VCCSENSE_VGA: length 75.7
  TOP w0.254: RV159.1 116.45,139.81 116.11,139.81 v3(115.28,140.64) 114.37,141.55 114.37,143.23 113.84,143.76 113.84,143.94 111.48,146.3 110.41,146.3 108.86,147.85 107.05,147.85 105.46,146.26 105.46,144.14 103.51,142.19 103.51,134.66 105.7,132.47 105.7,128.52 103.35,126.17 103.35,123.17 100.63,120.45 99.12,120.45 97.55,118.89 93.96,118.89 93.53,118.46 v1(93.53,118.22) ; PRV34.1 76.64,123.57 76.9,123.82 76.9,124.09 76.92,124.12 v1(76.92,124.13)
  IN2 w0.254: v1(93.53,118.22) 93.53,118.29 92.8,119.02 88.73,119.02 87.45,120.3 79.72,120.3 76.93,123.09 76.93,124.13 v1(76.92,124.13)
VDD_1.2V: length 9.1
  TOP w0.508: 31.93,25.16 31.93,23.66 32.44,23.15 36.56,23.15 36.91,22.8 v3(37.36,22.8) 37.68,22.8 37.94,23.05 37.94,23.77 37.77,23.94 PRM03.2
VDD_CHG: length 14.4
  TOP w0.254: v1(203.61,48.88) 203.61,48.07 v3(203.37,47.84) 202.66,47.12 PRB09.2
  BOTTOM w0.203: PRB13.2 203.81,50.04 203.81,49.26 203.61,49.06 v1(203.61,48.88) 203.57,48.85 PUB01.18
  BOTTOM w0.254: PRB11.1 PCB28.1 207.6,52.14 207.13,52.62 204.93,52.62 204.44,52.13 204.44,50.68 PRB13.2
VDDIO_APU: length 4.6
  TOP w0.203: PUZ01.6 154.37,91.12 v3(154.39,91.14) 153.96,91.58 v1(153.96,91.68) 153.96,92.13 154.16,92.34 PRZ16.2
  BOTTOM w0.254: PCZ21.1 154.44,91.08 153.96,91.56 v1(153.96,91.68)
VDDIO_AUDIO: length 20.4
  TOP w0.089: v1(143.2,64.3) 143.08,64.3 142.74,63.96 142.74,62.55 143.11,62.17 v3(143.31,62.17) 144.09,62.17 RC97.2
  IN2 w0.203: v1(130.16,60.24) 130.16,60.6 130.83,61.27 130.83,61.9 131.3,62.37 133.17,62.37 133.4,62.13 134.93,62.13 136.8,63.99 142.71,63.99 143.02,64.3 v1(143.2,64.3)
  BOTTOM w0.25: v1(130.16,60.24) 129.5,60.24 UC1.AP12
VDDIO_VGA: length 4
  TOP w0.203: PRV12.2 PRV14.2 69.48,130.31 PCV10.1 70.44,130.16 70.56,130.04 v3(70.56,130.04) 70.56,130.04 71.16,129.44 PUV01.6
VDDP_CHG: length 3.8
  TOP w0.089: v1(202.04,43.31) 201.6,43.75 v3(201.58,43.75)
  TOP w0.254: v1(202.04,43.31) 202.38,43.65 PRB09.1 202.74,43.73 PCB29.1
  BOTTOM w0.203: PUB01.8 203.17,43.54 202.8,43.18 202.18,43.18 v1(202.04,43.31)
VDDP_SENSE_H: length 70
  TOP w0.203: PQH01.3 163.55,41.44 163.1,40.99 161.5,40.99 160.68,40.17 159.13,40.17 158.93,39.96 158.93,38.61 v1(159.09,38.44)
  TOP w0.254: PCH19.1 162.62,44.12 163.55,43.19 PQH01.3
  IN2 w0.203: v1(159.09,38.44) 158.99,38.34 158.99,37.69 158.55,37.26 155.18,37.26 153.45,38.99 152.93,38.99 149.64,42.28 149.64,51.13 150.88,52.37 150.88,61.61 151.59,62.32 151.59,63.61 149.42,65.78 147.23,65.78 146.66,65.21 141.03,65.21 140.43,65.81 136.91,65.81 135.91,64.81 135.91,64 135.37,63.46 132.68,63.46 132.19,62.97 131.48,62.97 130.35,61.84 130.35,61.84 v1(130.35,61.77)
  BOTTOM w0.203: UC1.AN11 130.03,61.43 130.31,61.7 130.31,61.77 v1(130.35,61.77)
VDDP_SENSE_L: length 66.6
  TOP w0.203: PRH14.2 161.87,41.31 161.4,41.31 160.56,40.47 159,40.47 158.58,40.05 v3(158.58,39.85) 158.58,38.52 v1(158.49,38.44)
  IN2 w0.203: v1(158.49,38.44) 158.63,38.3 158.63,37.76 158.43,37.55 155.3,37.55 153.57,39.29 153.05,39.29 149.94,42.4 149.94,51.01 151.18,52.25 151.18,61.49 151.88,62.2 151.88,63.74 149.54,66.08 147.1,66.08 146.54,65.51 141.15,65.51 140.55,66.1 136.79,66.1 135.61,64.93 135.61,64.13 135.24,63.76 132.56,63.76 132.07,63.27 131.36,63.27 130.35,62.26 130.12,62.26 129.73,61.87 v1(129.73,61.77)
  BOTTOM w0.203: UC1.AM11 129.73,62 v1(129.73,61.77)
VDDR4: length 2.1
  BOTTOM w0.381: UV1.U12 UV1.V12 122.21,129.87 121.47,129.87 UV1.Y12
VSS_MECH: length 62.7
  TOP w0.254: v1(134.71,144.91) 133.45,146.17 129.83,146.17 129.45,145.79 129.45,145.09 129.04,144.69 v1(127.14,144.69) ; v1(111.16,121.65) 111.16,121.65 111.16,121.65 110.99,121.81 110.35,121.81 108.3,123.86 108.3,125.41 108.94,126.04 v3(108.94,128.27) 108.94,129.98 106.86,132.05 106.86,132.29 104.2,134.95 104.2,141.57 104.64,142.01 109.13,142.01 111.37,144.24 111.71,144.24 111.84,144.38 v1(111.97,144.38)
  IN3 w0.254: v1(111.97,144.38) 113.98,146.39 117.65,146.39 118.06,145.98 118.91,145.98 119.03,146.11 121.24,146.11 121.75,145.6 126.42,145.6 126.75,145.27 126.75,145.07 v1(127.14,144.69)
  BOTTOM w0.254: v1(111.97,144.38) 112.16,144.2 UV1.AM32 ; v1(134.71,144.91) 134.71,144.37 UV1.A32 ; v1(111.16,121.65) 111.16,121.65 111.16,121.65 111.29,121.78 112.13,121.78 UV1.AM1
VSS_SENSEA: length 7.5
  TOP w0.089: 124.66,85.71 123.73,86.64 v3(123.73,87.31) RC19.2
  TOP w0.099: v1(124.73,82.11) 125.06,82.43 125.06,84.64 124.8,84.9 124.8,85.58 124.66,85.71
  BOTTOM w0.127: UC1.J18 124.33,81.71 v1(124.73,82.11)
VSSSENSE_VGA: length 73.3
  TOP w0.254: RV158.1 115.91,139.45 115.83,139.45 114.69,140.59 114.69,140.64 114.02,141.31 114.02,143.1 113.5,143.62 113.5,143.75 111.3,145.95 110.26,145.95 108.72,147.5 107.19,147.5 105.81,146.12 105.81,143.98 103.86,142.03 103.86,134.81 106.05,132.61 106.05,128.38 103.7,126.03 103.7,123.02 100.78,120.11 99.26,120.11 97.7,118.54 94.44,118.54 v1(94.11,118.22) ; PRV36.1 77.57,123.96 v1(77.4,123.8)
  IN2 w0.254: v1(94.11,118.22) 94.11,118.28 93.02,119.37 88.87,119.37 87.6,120.64 79.87,120.64 77.35,123.16 77.35,123.6 77.39,123.65 77.39,123.79 v1(77.4,123.8)
0.9_1.8VALW_PWREN: length 248.5
  TOP w0.089: UE1.127 36.53,69.81 36.82,70.1 36.82,71.65 37.99,72.81 42.53,72.81 43.27,72.07 45.07,72.07 45.46,71.69 45.82,71.69 46.14,72.01 v1(49.32,72.01) ; v3(170.44,48.27) 170.34,48.37 169.33,48.37 168.81,47.86 v1(168.81,47.68)
  IN2 w0.089: v1(49.32,72.01) 49.02,72.31 49.02,72.98 49.42,73.38 49.42,79.14 48.47,80.09 48.47,83.36 49.08,83.97 49.08,87.91 48.17,88.82 48.17,105.02 47.54,105.65 47.54,111.07 49.26,112.78 50.34,112.78 51.55,113.99 59.24,113.99 60.34,115.09 63.49,115.09 65.15,113.44 72.8,113.44 73.53,114.18 76.36,114.18 77.44,113.1 80.19,113.1 80.94,113.86 86.18,113.86 86.21,113.83 90.09,113.83 91.26,112.65 95.18,112.65 95.79,112.04 101.5,112.04 106.2,107.34 117.41,107.34 117.49,107.41 125.44,107.41 125.85,107.82 127.97,107.82 128.56,108.41 134.47,108.41 137.15,105.73 139.39,105.73 139.6,105.52 143.73,105.52 143.73,105.52 143.88,105.52 145.13,104.27 156.91,104.27 157.54,104.91 163.58,104.91 167.55,100.94 167.55,97.45 168.37,96.63 168.37,91.75 168.71,91.41 168.71,87.08 169.26,86.53 169.26,72.07 170.29,71.04 170.29,69.82 171.56,68.55 171.56,66.37 173.25,64.68 173.25,59.96 173.68,59.53 173.68,55.65 v1(173.07,55.04)
  IN2 w0.254: v1(173.07,55.04) 173.07,52.38 169.11,48.42 169.11,47.98 v1(168.81,47.68)
  BOTTOM w0.254: PRH01.1 v1(168.81,47.68) ; PR1801.1 v1(173.07,55.04)
32K_X1: length 12.5
  BOTTOM w0.089: RC914.2 144.34,53.92 CC686.1 145.93,53.89 146.02,53.98 YC3.1
  BOTTOM w0.1: UC1.AY1 136.39,55.95 136.27,55.95 136.17,55.85 136.17,55.69 136.47,55.39
  BOTTOM w0.102: 136.47,55.39 136.97,55.39 136.98,55.38 138.04,55.38 140.08,53.34 v3(142.48,53.34) 142.55,53.34 143.14,53.92 RC914.2
32K_X2: length 12.6
  BOTTOM w0.089: YC3.2 146.02,52.94 145.93,53.03 CC682.1 144.34,53.01 RC914.1
  BOTTOM w0.1: 136.39,55.2 135.96,55.63 UC1.AY4
  BOTTOM w0.102: RC914.1 v3(141.08,53.01) 140,53.01 137.82,55.19 136.9,55.19 136.89,55.2 136.39,55.2
48M_X1: length 15.8
  BOTTOM w0.1: RC939.2 v3(142.34,49.09) 140.29,49.09 137.97,51.42 137.97,52.88 135.94,54.91 UC1.BB3
  BOTTOM w0.112: RC939.2 144.41,49.09 C797.1 144.84,49.07 145.09,48.81 146.89,48.81 147.44,49.37 YC2.1
48M_X2: length 15.8
  BOTTOM w0.089: 142.31,48.72 v3(140.84,48.72) 139.71,48.72 137.73,50.71
  BOTTOM w0.1: 137.73,50.71 137.73,52.85 136.09,54.49 135.23,54.49 134.73,54.99 UC1.BA5
  BOTTOM w0.112: YC2.3 145.14,48.2 C796.1 144.41,48.18 RC939.1 143.56,48.13 143.08,48.13 142.97,48.24 142.97,48.61 142.86,48.72 142.31,48.72
+APU_VDDCORE: length 84
  TOP w0.508: v1(154.73,53.49) 154.73,53.82 PCZ115.1 ; PCZ117.1 163.81,53.88 v1(163.81,53.48) ; PCZ119.1 166.2,53.97 v1(166.2,53.49) ; v1(164.99,53.46) 164.99,53.91 PCZ120.1 ; v1(162.57,53.48) 162.57,53.86 PCZ116.1 ; PRZ37.2 147.1,81.45 v1(147.56,81.91) ; v1(167.5,53.46) 167.5,53.95 PCZ118.1
  BOTTOM w0.3: v1(130.61,79.82) 130.61,79.59 130.83,79.37 UC1.M10 ; UC1.P7 133.51,77.03 133.51,76.85 v1(133.55,76.81) ; v1(131.23,66.78) 131.23,66.91 UC1.AF10 ; UC1.H15 126.33,82.51 126.46,82.63 v1(126.73,82.91) ; v1(129.76,82.91) 129.83,82.91 UC1.H11 ; UC1.R8 132.77,75.96 v1(132.77,75.84) ; v1(130.45,75.84) 130.45,75.69 UC1.T10 ; v1(132.05,80.89) 132.43,80.51 UC1.L8 ; v1(128.78,80.58) 128.9,80.58 UC1.K12 ; UC1.K7 132.75,81.79 v1(132.75,82.08) ; v1(131.75,83.62) 131.43,83.31 UC1.G10 ; v1(130.36,76.72) 130.36,76.84 UC1.P10 ; v1(133.57,64.83) 133.57,64.96 UC1.AJ7 ; v1(127.73,83.61) 127.43,83.31 UC1.G14 ; UC1.AJ10 130.53,65.61 v1(130.53,65.83) ; v1(133.57,68.76) 133.55,68.78 133.55,68.99 UC1.AD7 ; v1(131.26,68.92) 131.22,68.92 UC1.AD10 ; UC1.T7 133.23,75.06 v1(132.88,74.71) ; v1(133.58,79.83) 133.23,79.48 UC1.M7 ; UC1.G12 129.43,83.31 v1(129.73,83.61) ; UC1.K14 v1(127.65,80.49) ; UC1.G7 v1(132.73,82.81) UC1.H8 ; v1(132.01,68.73) UC1.AE8
  BOTTOM w0.305: v1(131.35,70.79) 131.24,70.79 130.83,71.21 UC1.AA10 ; v1(128.43,67.91) UC1.AF13 UC1.AG14 v1(126.83,66.31) UC1.AH15 UC1.AJ14 ; UC1.AB19 v1(123.63,71.11) UC1.AA18 UC1.Y17 v1(125.23,72.71) UC1.W16 UC1.V15 v1(126.83,74.31) UC1.U14 UC1.T13 v1(128.43,75.91) 128.52,75.82 129.6,75.82 v1(129.66,75.88) ; UC1.Y8 132.92,72.79 v1(133.46,72.79) 133.46,73.08 UC1.W7 ; v1(128.37,69.53) 128.37,69.44 UC1.AD13 UC1.AE14 v1(126.83,67.91) UC1.AF15 UC1.AG16 v1(125.23,66.31) 125.08,66.16 UC1.AH17 UC1.AJ16 v1(125.23,64.71) UC1.AK17 ; UC1.AK19 v1(123.63,64.71) UC1.AJ18 UC1.AH19 v1(123.63,66.31) UC1.AG18 UC1.AF17 v1(125.23,67.91) UC1.AE16 125.63,68.31 UC1.AD15 v1(126.83,69.51) UC1.AC14 UC1.AB13 v1(128.43,71.11) ; v1(126.73,82.91) 127.13,83.31 UC1.G14 ; UC1.V17 v1(125.23,74.31) UC1.U16 UC1.T15 v1(126.83,75.91) UC1.R14 UC1.P13 v1(128.43,77.51) ; UC1.W10 130.83,73.21 131.27,72.77 v1(131.35,72.77) ; v1(128.42,74.3) UC1.V13 UC1.W14 v1(126.83,72.71) UC1.Y15 UC1.AA16 v1(125.23,71.11) UC1.AB17 UC1.AC18 v1(123.63,69.51) UC1.AD19 ; UC1.AA7 133.23,71.11 133.45,70.89 v1(133.45,70.79) ; UC1.AF19 v1(123.63,67.91) UC1.AE18 UC1.AD17 v1(125.23,69.51) UC1.AC16 UC1.AB15 v1(126.79,71.07) UC1.AA14 UC1.Y13 v1(128.43,72.71) ; UC1.AJ14 v1(126.83,64.71) 126.68,64.56 UC1.AK15 ; UC1.AJ14 UC1.AH13 v1(128.43,66.31) ; UC1.N14 v1(126.83,77.51) UC1.P15 125.63,76.31 UC1.R16 v1(125.23,75.91) UC1.T17 ; v1(128.43,64.7) UC1.AK13
  BOTTOM w0.35: UC1.G7 133.75,83.82 v1(133.75,83.87)
  BOTTOM w0.381: v1(132.88,66.76) 132.88,66.95 UC1.AF7
  vias: v1(147.82,67.89) v1(147.82,67.31) v1(150.44,67.88) v1(150.44,67.24) v1(153.75,58.34) v1(153.75,57.73) v1(153.75,57.07) v1(153.75,56.46) v1(153.75,55.8) v1(153.75,55.19) v1(154.36,58.34) v1(154.36,57.73) v1(154.36,57.07) v1(154.36,56.46) v1(154.36,55.8) v1(154.36,55.19) v1(155.1,56.74) v1(155.1,56.13) v1(155.71,56.74) v1(155.71,56.13) v1(156.23,52.76) v1(156.23,52.13) v1(156.23,51.49) v1(156.23,50.86) v1(157.6,56.74) v1(157.6,56.13) v1(158.21,56.74) v1(158.21,56.13) v1(158.83,58.25) v1(158.83,57.64) v1(158.83,57.03) v1(158.83,56.42) v1(158.83,55.76) v1(158.83,55.15) v1(159.44,58.25) v1(159.44,57.64) v1(159.44,57.03) v1(159.44,56.42) v1(159.44,55.76) v1(159.44,55.15) v1(160.05,58.25) v1(160.05,57.64) v1(160.05,57.03) v1(160.05,56.42) v1(160.05,55.76) v1(160.05,55.15) v1(160.66,58.25) v1(160.66,57.64) v1(160.66,57.03) v1(160.66,56.42) v1(160.66,55.76) v1(160.66,55.15) v1(161.27,58.25) v1(161.27,57.64) v1(161.27,57.03) v1(161.27,56.42) v1(161.27,55.76) v1(161.27,55.15) v1(161.88,58.25) v1(161.88,57.64) v1(161.88,57.03) v1(161.88,56.42) v1(161.88,55.76) v1(161.88,55.15) v1(166.56,57.08) v1(166.56,56.47) v1(166.56,55.81) v1(166.56,55.2) v1(167.17,57.08) v1(167.17,56.47) v1(167.17,55.81) v1(167.17,55.2) v1(167.78,57.08) v1(167.78,56.47) v1(167.78,55.81) v1(167.78,55.2) v1(168.39,57.08) v1(168.39,56.47) v1(168.39,55.81) v1(168.39,55.2) v1(168.99,57.08) v1(168.99,56.47) v1(168.99,55.81) v1(168.99,55.2) v1(169.6,57.08) v1(169.6,56.47) v1(169.6,55.81) v1(169.6,55.2) v4(156.88,55.43)
+APU_VDDSOC: length 22.3
  BOTTOM w0.305: v1(124.79,79.71) 124.64,79.71 UC1.M18 ; 125.72,78.73 126.23,79.24 UC1.M15 126.34,79.31 v1(126.72,78.93) ; 125.72,78.73 125.84,78.6 125.84,78.12 UC1.N16 v1(125.23,77.51) UC1.P17 124.03,76.31 UC1.R18 v1(123.63,75.91) UC1.T19 UC1.U20 v1(122.03,74.31) ; 125.72,78.73 125.2,78.73 125.18,78.74 124.79,78.74 UC1.M18 ; UC1.M18 124.03,79.11 UC1.N18 v1(123.63,77.51) UC1.P19 UC1.R20 v1(122.03,75.91) ; UC1.M18 123.85,79.68 v1(123.67,79.68) 123.66,79.67 123.6,79.67 UC1.M19 122.69,78.76 122.43,78.76 122.43,78.67 122.05,78.29 122.43,77.91 UC1.N20 v1(122.03,77.51) ; UC1.W18 v1(123.63,72.71) UC1.Y19 ; v1(122.11,72.7) 122.43,73.02 UC1.W20 UC1.V19 v1(123.63,74.31) UC1.U18
  vias: v1(146.91,103.06) v1(146.91,102.42) v1(146.91,101.79) v1(146.91,101.15) v1(147.1,97.94) v1(147.1,97.3) v1(147.1,96.67) v1(147.1,96.03) v1(147.54,103.06) v1(147.54,102.42) v1(147.54,101.79) v1(147.54,101.15) v1(147.74,97.94) v1(147.74,97.3) v1(147.74,96.67) v1(147.74,96.03) v1(148.18,103.06) v1(148.18,102.42) v1(148.18,101.79) v1(148.18,101.15) v1(148.37,97.94) v1(148.37,97.3) v1(148.37,96.67) v1(148.37,96.03) v4(145.96,104.45)
+BIF_VDDC: length 1.5
  BOTTOM w0.381: UV1.R21 125.14,136.82 124.69,137.27 v1(124.54,137.27) ; UV1.U21 123.34,136.89 v1(123.76,137.3)
  vias: v1(122.13,142.19) v1(122.97,142.25) v1(123.68,142.22) v3(122.59,141.85)
+CCG_VBUS: length 89.1
  TOP w0.279: JUSBC1.B9 6,122.57 6.04,122.61 6.67,122.61 6.96,122.32 JUSBC1.A4 ; JUSBC1.B4 6.14,120.07 6.39,119.82 JUSBC1.A9
  TOP w0.508: v1(65.05,120.33) 65.55,120.83 PRS26.1
  IN1 w0.508: 37.19,128.18 37.23,128.14 42.35,128.14 43.82,126.67 46.73,126.67 48.47,128.41 48.47,128.66 55.05,135.24 v1(56.66,135.24) 57.45,136.03 61.12,136.03 64.69,139.59 70.58,139.59 72.5,141.51 76.17,141.51
  IN3 w0.508: v1(29.52,117.09) 29.83,117.39 37.11,117.39 37.63,116.87 v1(37.63,116.76)
  BOTTOM w0.508: RT1.1 37.37,117.28 37.63,117.03 v1(37.63,116.76) ; v1(65.05,120.33) 65.05,120.56 65.78,121.3 65.78,122.51 65.2,123.1 65.2,125.33 65.99,126.12 65.99,128.73 68.44,131.18 68.44,132.17 66.32,134.29 57.97,134.29 57.02,135.24 v1(56.66,135.24) ; CT28.1 CT27.1 12.09,123.62 v1(12.8,124.33)
  vias: v1(8.29,122.55) v1(8.33,119.63) v1(8.87,122.55) v1(8.91,119.63) v1(9.75,118.92) v1(9.75,118.33) v1(12.78,127.58) v1(13.37,127.58) v1(14,127.58) v1(14.64,127.58) v1(15.22,127.58) v1(15.81,127.58) v1(29.52,116.45) v1(35.37,129.77) v1(35.37,129.18) v1(35.37,128.6) v1(35.37,128.01) v1(35.96,128.6) v1(35.96,128.01) v1(36.54,128.6) v1(36.54,128.01) v1(76.81,141.66) v1(77.44,141.66) v4(17.5,128.44)
+CCG_VBUS_1: length 25
  TOP w0.089: v1(39.51,132.53) v4(38.94,132.53)
  IN2 w0.508: 39.87,130.73 39.33,130.18 39.33,120.86 38.67,120.2 34.63,120.2 33.78,119.35 33.78,117.14 32.98,116.34 32.98,115.92 31.67,114.61 29.43,114.61 v1(29.18,114.36)
  vias: v1(39.51,131.95) v1(39.51,131.36) v1(40.09,132.53) v1(40.09,131.95) v1(40.09,131.36) v1(40.68,132.53) v1(40.68,131.95) v1(46.24,139.67) v1(46.24,139.09) v1(46.24,138.5) v1(46.24,137.92) v1(46.82,139.67) v1(46.82,139.09) v1(46.82,138.5) v1(46.82,137.92)
+CHARGER_SRC: length 1.4
  TOP w0.089: PCB04.1 v3(200.6,52.78)
  vias: v1(199.8,56.24) v1(199.8,55.6) v1(199.8,54.97) v1(199.8,54.33)
+CHGRTC: length 5.3
  TOP w0.089: 158.47,31.05 v3(157.01,31.05)
  TOP w0.508: DC1.2 160.21,28 158.8,29.41 158.8,30.81
+DC_IN: length 289.4
  TOP w0.089: v4(143.21,104.69) 143.09,104.57 v1(141.8,104.57)
  TOP w0.508: v1(141.8,104.57) 141.8,104.71 140.93,105.58 139.51,105.58 v4(139.14,105.95) 137.63,107.46 v4(137.63,108.14) v1(137.63,109.19) ; v1(48.71,127.02) 47.99,127.02 46.96,125.99 PR61.1 ; PR13.1 v1(93.39,151.96) ; v1(52.5,118.42) 52.05,117.97 PRS03.1 ; PR36.1 171.54,31.57 v1(171.18,31.21)
  IN2 w0.508: v1(170.57,35.85) 170.27,36.15 166.89,36.15 162.96,40.08 162.8,40.08 162.61,40.26 155,40.26 154.53,40.74 153.65,40.74 151.96,42.43 151.96,48 153.64,49.67 159.82,49.67 162.02,51.87 165.76,51.87 166.62,51.01 167.66,51.01 168.69,52.04 171.09,52.04 172.49,53.44 172.49,64.59 171.1,65.97 171.1,68.45 169.69,69.86 169.69,71.03 168.82,71.9 168.82,86.42 167.98,87.26 167.98,96.47 167.1,97.34 167.1,100.83 163.42,104.52 157.7,104.52 157.07,103.88 146.53,103.88 146.15,103.5 144.01,103.5 142.94,104.57 v1(141.8,104.57) ; v1(83.18,145.8) 81.58,145.8 80.73,144.95 78.27,144.95 74.52,141.21 72.45,141.21 71.27,140.03 63.02,140.03 60.5,137.51 56.45,137.51 55.09,136.15 55.09,132.64 53.86,131.41 v1(53.86,130.6) 53.86,128.11 52.4,126.64 52.4,118.53 v1(52.5,118.42) ; v1(93.39,151.96) 93.39,150.45 92.93,150 92.93,146.53 v1(92.29,145.88) 89.32,142.91 89.32,139 90.87,137.45 94.75,137.45 95.98,136.22 95.98,130.91 99.97,126.93 99.97,119.24 102.69,116.51 107.52,116.51 109.46,114.58 109.46,112.85 111.9,110.41 118.62,110.41 119.72,109.3 123.2,109.3 124.03,110.13 132.23,110.13 132.45,110.34 134.46,110.34 135.62,109.19 v1(137.63,109.19)
  BOTTOM w0.254: v1(170.57,35.85) 170.57,31.82 v1(171.18,31.21)
  BOTTOM w0.508: v1(48.71,127.02) 48.86,127.02 49.37,127.53 49.37,127.93 52.04,130.6 v1(53.86,130.6)
+DC_IN_SS: length 168.3
  TOP w0.089: 92.11,138.04 v4(92.11,137.54)
  IN2 w0.508: 202.15,59.43 201.9,59.18 190.38,59.18 186.41,63.15 178.88,63.15 171.65,70.38 171.65,70.47 171.65,71.6 170.62,72.63 170.62,87.35 170.57,87.4 170.13,87.84 170.13,95.52 170.13,97.04 169.1,98.07 169.1,102.32 165.16,106.27 164.44,106.27 156.98,106.27 156.74,106.03 156.6,106 156.23,105.63 146.09,105.63 143.42,108.3 141.24,108.3 139.41,110.13 135.89,110.13 134.82,111.2 132.1,111.2 131.88,110.98 123.67,110.98 122.85,110.16 120.2,110.16 119.1,111.26 112.26,111.26 110.32,113.2 110.32,115.81 108.76,117.37 102.69,117.37 100.57,119.49 100.57,127.17 97.25,130.49 97.25,138.32
  BOTTOM w0.508: v1(97.28,145.66) PR11.1
  vias: v1(91.86,138.87) v1(91.86,138.26) v1(92.46,138.87) v1(92.46,138.26) v1(93.07,138.87) v1(93.07,138.26) v1(97.96,143.77) v1(97.96,143.16) v1(98.57,143.77) v1(98.57,143.16) v1(99.18,143.77) v1(99.18,143.16) v1(202.66,60.07) v1(203.3,60.07)
+DP_VDDC: length 6.6
  TOP w0.508: RV30.2 113.94,129.07 v3(114.21,129.34) 114.37,129.51 CV30.1 115.59,129.55 116.27,130.23 CV34.1 CV33.1 117.5,130.3 v1(117.5,131.02)
  BOTTOM w0.305: UV1.AD14 117.74,131.27 v1(117.5,131.02)
+DP_VDDR: length 8.3
  TOP w0.102: v3(111.5,128.16) 112.02,128.68 112.94,128.68 113.04,128.79 RV27.2
  TOP w0.508: v1(116.26,131) 115.65,131 CV26.1 115.59,130.77 115.23,130.41 114.33,130.41 CV35.1 113.19,130.86 CV27.1 112.9,130.09 113.04,129.95 RV27.2
  BOTTOM w0.305: UV1.AF14 116.14,131.12 v1(116.26,131)
+EC_VCCA: length 4.9
  TOP w0.089: v1(38.69,88.6) v3(38.69,89.15)
  TOP w0.203: v1(49.03,82.21) 48.95,82.29 UE1.67
  TOP w0.508: CE8.1 PR52.2 47.14,86.39 47.14,87.1 v1(47.05,87.2) ; LE1.2 v1(38.69,88.6)
+FB0_VREFCL: length 6.3
  TOP w0.254: UV12.J14 155.11,146.73 154.66,147.18 v1(154.58,147.18)
  BOTTOM w0.102: RV54.2 v3(152.63,149.98)
  BOTTOM w0.254: v1(154.58,147.18) 154.66,147.18 155.11,146.73 UV12.J14
  BOTTOM w0.381: RV54.2 154.59,149.98 RV55.1 CV395.1 154.64,148.51 154.5,148.36 154.5,147.74 154.58,147.66 v1(154.58,147.18)
+FB0_VREFDL: length 21.4
  TOP w0.102: v3(165.07,145.85) 164.54,145.33 RV52.2
  TOP w0.254: UV12.U10 161.51,143.52 v1(161.11,143.13) ; v1(149.14,143.13) 148.74,143.53 UV12.A10
  TOP w0.508: RV52.2 164.06,144.47 CV394.1 RV53.1 v1(162.78,143.5)
  IN1 w0.508: v1(161.11,143.13) 159.56,141.58 150.4,141.58 149.14,142.84 v1(149.14,143.13)
  BOTTOM w0.254: v1(161.11,143.13) 161.51,143.52 UV12.U10 161.61,143.42 162.7,143.42 v1(162.78,143.5) ; v1(149.14,143.13) 148.74,143.53 UV12.A10
+FB1_VREFCL: length 8.2
  TOP w0.254: UV14.J14 155.36,119.05 155.36,118.48 155.68,118.16 v1(156.07,118.16)
  BOTTOM w0.127: RV50.2 v3(156.59,116.65)
  BOTTOM w0.254: UV14.J14 155.11,118.75 155.7,118.16 v1(156.07,118.16)
  BOTTOM w0.508: RV51.1 CV391.1 RV50.2 156.07,117.24 v1(156.07,118.16)
+FB1_VREFDL: length 20.2
  TOP w0.254: UV14.U10 148.71,122.55 148.97,122.81 v1(149.11,122.81)
  TOP w0.508: CV390.1 RV48.2 164.24,121.87 RV49.1 163.63,122.74 163.4,122.51 v3(163.34,122.51) UV14.A10 161.25,122.76 v1(161.25,123.3)
  IN1 w0.508: v1(149.11,122.81) 150.01,123.71 160.84,123.71 v1(161.25,123.3)
  BOTTOM w0.254: UV14.A10 161.51,122.51 161.25,122.76 v1(161.25,123.3) ; UV14.U10 149.01,122.81 v1(149.11,122.81)
+FP_VCC: length 1.5
  BOTTOM w0.089: 220.4,29.1 v1(220.4,27.57)
+INV_PWR_SRC: length 1.7
  TOP w0.089: R5.2 204.69,57.78 v4(204.69,56.32)
  vias: v1(210.4,58.58) v1(210.98,58.58) v4(209.84,57.4) v4(210.16,59.24)
+LAN_VDD10: length 5
  TOP w0.203: UL1.3 v1(22.87,79.93) ; UL1.22 v1(22.87,85.79) ; v1(25.38,80.44) 25.01,80.44 24.87,80.59 UL1.8
  BOTTOM w0.089: CL23.1 v3(25.69,85.64)
  BOTTOM w0.508: v1(25.38,80.44) 24.88,79.94 CL21.1 ; CL20.1 22.82,79.88 v1(22.87,79.93)
  vias: v1(19.53,80.45) v1(19.71,82.39) v1(19.97,80.83) v1(20.48,82.39)
+LAN_VDD33: length 4.4
  TOP w0.203: UL1.11 26.31,82.33 v1(26.37,82.26) ; UL1.32 21.02,81.53 20.9,81.4 v1(20.61,81.4)
  TOP w0.508: RL6.1 28.98,87.75 29.41,87.32 v1(29.55,87.32) ; v1(21.12,87.55) 21.27,87.7 RL10.1 ; UL2.1 32.22,88.01 v1(32.76,88.55)
  vias: v1(24.66,91.05) v1(24.66,90.42) v1(25.29,91.05) v1(25.29,90.42) v4(27.59,91.37)
+LAN_VDDREG: length 1.3
  BOTTOM w0.089: CL6.1 23.03,86.48 23.71,87.16 v3(23.71,87.46)
  vias: v1(21.56,85.78) v1(22.23,85.8)
+LCDVDD: length 1.1
  TOP w0.102: v3(222.93,45.41) 222.49,45.86 221.99,45.86
+LCDVDD_CONN: length 11.3
  TOP w0.089: CW6.1 223.24,48.19 223.74,48.7 223.74,50.22 223.24,50.73 v4(223.24,51.11) ; C16.1 221.15,48.18 220.89,48.45 220.89,50.35 v4(221.52,50.99) ; v4(224.89,51.62) 224.25,50.99 224.25,48.51 223.49,47.75
  vias: v1(213.28,55.3) v1(213.28,54.68) v1(221.86,47.48) v1(221.86,46.85)
+LINE1-VREFO-L: length 3.7
  TOP w0.203: RA26.1 21.28,12.19 22.11,13.01 23.28,13.01 23.33,13.07 UA1.31
+LINE1-VREFO-R: length 3.5
  TOP w0.203: RA29.1 21.56,12.95 22.01,13.39 v3(22.56,13.39) 23.08,13.39 23.16,13.47 UA1.30
+MIC2-VREFO: length 10.2
  TOP w0.089: v1(17.36,15.24) v3(17.36,15.77)
  TOP w0.203: v1(22.87,13.87) UA1.29
  TOP w0.254: v1(17.36,15.24) RA23.1 RA22.1
  IN3 w0.203: v1(17.36,15.24) 17.36,15.29 18,15.93 20.8,15.93 v1(22.87,13.87)
+MPLL_PVDD: length 5.8
  TOP w0.102: v3(128.92,125.85) 128.8,125.85 v1(128.43,126.22)
  TOP w0.381: LV6.2 126.48,124.53 126.58,124.53 127.27,125.21 CV124.1
  TOP w0.508: v1(128.43,126.22) 128.28,126.37 CV82.1 127.71,125.83 CV124.1 127.3,125.38 127.84,124.84 CV81.1
  BOTTOM w0.381: v1(128.43,126.22) 128.05,126.6 UV1.L8
+MVREFDA: length 18.3
  TOP w0.381: RV33.2 139.09,148.84 RV34.1 CV94.1 v4(136.37,148.89) 131.72,148.89 128.88,146.05 v1(128.88,145.21)
  IN1 w0.508: v1(129.24,141.4) 128.83,141.82 128.83,142.17 128.1,142.9 128.09,142.9 127.87,143.13 127.87,144.2 v1(128.88,145.21)
  BOTTOM w0.254: UV1.K26 128.94,141.1 v1(129.24,141.4)
+MVREFSA: length 13.3
  TOP w0.203: v1(130.21,141.45) 130.72,141.96 130.72,143.49 131.05,143.82 134.65,143.82 v3(137.1,146.27) 137.27,146.44 CV95.1
  TOP w0.381: RV32.2 139.09,146.49 RV35.1 CV95.1
  BOTTOM w0.254: UV1.J26 130.19,141.45 v1(130.21,141.45)
+PCIE_VDDC: length 11.3
  BOTTOM w0.381: v1(127.42,141.28) 127.66,141.28 UV1.L26 ; UV1.R22 v1(124.92,138.38) 124.34,137.8 UV1.T22 124.14,137.93 v1(123.74,138.33) UV1.U22 UV1.V22 v1(122.54,138.4) ; UV1.N23 127.14,138.2 UV1.M22 ; UV1.N23 126.64,138.7 v1(126.14,138.7) UV1.N22 ; UV1.N23 127.14,139 v1(127.16,139) 127.54,139 UV1.L23 ; v1(127.42,140.45) 127.69,140.45 UV1.L25 ; UV1.N24 126.98,139.64 v1(127.3,139.64) 127.7,139.64 UV1.L24
  vias: v1(115.74,121.01) v1(115.74,120.43) v1(116.32,121.01) v1(116.32,120.43) v4(125.95,142.74)
+PWR_SRC_AC:
  vias: v1(185.58,57.08)
+RTC_APU: length 27
  TOP w0.508: v1(131.35,33) 131.89,33 132.25,32.63 v4(133.96,32.63) 137.09,32.63 139.09,34.63 144.01,34.63 148.32,30.32 149.16,30.32 CC92.1 151.94,27.54 UC8.3
  BOTTOM w0.508: v1(131.35,33) 131.7,33 RC98.2
+RTC_APU_R: length 144.5
  TOP w0.508: v1(47.99,52.14) 48.7,52.85 52.02,52.85 53.31,54.15 v4(53.31,55.11) 53.31,56.19 51.47,58.03 Q9.1
  IN2 w0.508: v1(47.99,52.14) 48.1,52.03 48.1,48.19 48.61,47.68 49.95,47.68 54.83,42.8 54.83,40.86 60.3,35.4 61.51,35.4 62.54,34.37 63.03,34.37 63.45,33.95 77.87,33.95 78.32,33.5 79.79,33.5 80.7,32.59 97.04,32.59 98.04,33.58 100.34,33.58 100.71,33.21 103.23,33.21 104.78,31.65 108.51,31.65 109.06,32.2 115.33,32.2 115.8,32.68 116.71,32.68 117.38,33.35 120.3,33.35 120.49,33.17 124.06,33.17 124.6,33.71 125.18,33.71 v1(127.67,36.21) 128.11,36.65 129.28,36.65 133.16,40.53 133.96,42.46 135.66,44.15 135.66,47.79 135.29,48.15 135.29,51.08 135.14,51.24 135.14,52.1 132.98,54.25 132.47,54.25 131.46,55.26 131.46,56.96 130.79,57.63 v1(130.73,57.63)
  BOTTOM w0.3: v1(130.73,57.63) 130.73,58.26 130.23,58.76 UC1.AT11
  BOTTOM w0.508: CLRP1.1 131.76,34.73 129.26,34.73 127.78,36.21 v1(127.67,36.21)
+RTCBATT: length 50.9
  TOP w0.089: v3(162.94,27.24) 162.8,27.38 162.8,28.1 161.96,28.94
  TOP w0.508: v1(162.59,29.81) 162.59,29.45 162.09,28.94 RC99.2
  IN2 w0.508: v1(202.52,33.29) 202.52,33.29 202.05,32.82 192.09,32.82 191.27,33.64 191.27,34.16 190.25,35.18 189.29,35.18 188.94,34.83 186.35,32.24 182.22,32.24 182.08,32.37 180.25,32.37 178.58,30.7 173.72,30.7 173.46,30.44 168.61,30.44 168.4,30.24 163.4,30.24 162.97,29.81 v1(162.59,29.81)
  BOTTOM w0.508: v1(202.52,33.29) 203.2,33.97 JIOB1.11
+RTCBATT_R: length 29
  TOP w0.089: v3(161.95,28.05) 161.35,28.05 v1(161.32,28.08) 160.21,29.19 DC1.3 160.59,29.85 RC99.1
  BOTTOM w0.089: v1(161.32,28.08) 160.98,28.42 148.27,28.42 144.45,32.24 RC801.1 144.02,32.44 143.61,32.03 141.98,32.03 141.69,32.33 141.69,33.37 142.73,34.41 QC27.2
+RTCVCC: length 146.4
  TOP w0.089: v1(61.32,30.26) v4(61.96,30.26)
  TOP w0.508: RA12.2 v1(26.89,22.73)
  IN2 w0.508: v1(155.88,30.98) 154.81,30.98 150.23,35.56 150,35.79 147.35,35.79 146.7,35.79 145.99,35.07 135.44,35.07 135.14,34.77 134.65,34.77 134.45,34.97 130.76,34.97 130.21,34.41 129.57,34.41 125.31,30.15 121.23,30.15 120.94,30.45 116.73,30.45 116.25,29.97 109.99,29.97 109.43,29.4 101.85,29.4 101.06,30.19 99.42,30.19 98.85,29.62 97.22,29.62 96.49,30.36 67.57,30.36 66.92,31 62.05,31 v1(61.32,30.26)
  IN3 w0.508: v1(61.32,30.26) 58.82,30.26 54.05,35.03 40.79,35.03 40.42,34.67 38.17,34.67 36.89,33.38 34.95,33.38 31.85,30.28 30.1,30.28 28.6,28.77 28.6,26.18 27.71,25.29 27.71,23.54 v1(26.89,22.73)
+SDC_IN: length 112.2
  IN1 w0.508: v1(184.86,61.09) 187.16,58.79 193.37,58.79 198.36,53.81 198.36,51.07 199.29,50.14 v1(199.49,50.14)
  BOTTOM w0.508: PR47.1 91.82,147.57 90.81,146.57 90.81,146.19 v1(90.81,146.18) ; 102.7,148.22 101.21,148.22 100.73,147.73 100.73,147.73 PQ19.3 ; PRB04.1 200.17,49.52 PRB05.1 v1(199.49,50.14)
  BOTTOM w2.54: 167.43,118.61 167.43,130.74 166.85,131.31 166.85,150.74 165.33,152.26 138.93,152.26 137.6,150.93 134.45,150.93 ; 131.25,150.88 130.96,150.88 130.16,150.09 130.04,150.03 129.75,149.65 129.02,148.99 128.17,148.48 127.96,148.4 127.84,148.28 127.36,148.19 127.36,148.19 127.24,148.14 126.26,148 125.88,148.02 125.51,148.02 124.08,148.3 123.11,148.7 120.75,150.5 118.16,153.09 116.11,153.09
  vias: v1(64.17,132.08) v1(64.17,131.44) v1(64.8,132.08) v1(64.8,131.44) v1(65.44,132.08) v1(65.44,131.44) v1(66.07,132.08) v1(66.07,131.44) v1(67.92,134.67) v1(68.6,134.64) v1(104.43,151.63) v1(104.43,151) v1(104.43,150.36) v1(105.06,151.63) v1(105.06,151) v1(105.06,150.36) v1(105.7,151.63) v1(105.7,151) v1(106.33,152.22) v1(106.33,151.63) v1(163.74,116.52) v1(163.74,115.91) v1(163.74,115.3) v1(164.35,116.52) v1(164.35,115.91) v1(164.35,115.3) v1(164.96,116.52) v1(164.96,115.91) v1(164.96,115.3) v1(165.57,116.52) v1(165.57,115.91) v1(165.57,115.3) v1(169.96,101.72) v1(169.96,101.11) v1(169.96,100.5) v1(169.96,99.89) v1(169.96,99.28) v1(169.96,98.67) v1(170.57,101.72) v1(170.57,101.11) v1(170.57,100.5) v1(170.57,99.89) v1(170.57,99.28) v1(170.57,98.67) v1(178.02,76.63) v1(178.47,76.22) v1(178.92,75.8) v1(179.42,75.43) v1(179.91,75.07) v1(183.55,61.71) v1(183.55,61.13) v1(184.18,61.71) v1(184.18,61.13) v1(184.82,61.71) v4(161.01,110.36)
+SPI_VCC: length 58.2
  TOP w0.089: v1(131.36,35.85) v3(131.88,35.85)
  TOP w0.508: RX16.1 RX13.1 ; RX13.1 105.01,39.66 v1(104.86,39.81) ; RX13.1 RX14.1 ; v1(119.1,34.72) 119.56,35.18 120.39,35.18 122.07,36.86 122.07,39.83 v1(121.5,40.41) ; v1(118.91,40.09) 118.82,40.09 117.71,41.19 117.71,41.33 v1(117.12,41.93)
  IN2 w0.508: v1(121.5,40.41) 121.3,40.2 119.04,40.2 118.93,40.09 v1(118.91,40.09) ; v1(131.88,41.93) 131.88,41.75 128.97,38.84 128.42,38.84 124.75,35.18 121.08,35.18 120.62,34.72 v1(119.1,34.72)
  IN3 w0.508: v1(131.88,41.93) 131.87,41.93 131.87,41.23 131.82,41.17 131.82,40.9 131.43,40.51 131.43,35.92 v1(131.36,35.85)
  BOTTOM w0.508: v1(119.1,34.72) 119.74,35.36 RC1706.2 ; JH1.8 121.72,40.19 v1(121.5,40.41) ; RC639.2 131.86,41.33 131.88,41.35 v1(131.88,41.93) ; v1(104.86,39.81) 106.14,39.81 110.97,44.64 114.77,44.64 117.12,42.29 v1(117.12,41.93) ; RC640.2 131.36,35.99 v1(131.36,35.85) ; v1(118.91,40.09) 118.93,40.09 119.15,40.32 RC642.2
+SPLL_PVDD: length 8.3
  TOP w0.102: v3(132.13,118.17) LV7.2
  TOP w0.508: LV7.2 132.13,120.11 CV84.1 132.01,120.24 132.01,120.74 131.5,121.24 CV86.1 131.5,121.94 130.93,122.51 CV85.1 130.93,123.82 130.91,123.84 v1(130.91,125.37)
  BOTTOM w0.381: UV1.H7 130.54,125.74 v1(130.91,125.37)
+SPLL_VDDC: length 3.1
  TOP w0.508: v1(130.93,126.24) 131.67,125.51 CV93.1
  BOTTOM w0.305: UV1.H8 130.89,126.24 v1(130.93,126.24)
  vias: v3(131.94,122.87)
+TPAN_VDD_F:
  vias: v4(214.16,38.86)
+TSVDD: length 9.8
  TOP w0.508: LV2.2 110.13,133.55 CV19.1 111.51,133.24 112.69,133.24 113.03,132.89 v3(113.38,132.89) 113.79,132.89 114.06,133.16 114.78,133.16 115.46,132.48 116.77,132.48 CV21.1 117.57,132.57 CV20.1 117.62,132.87 v1(117.62,133.45)
  BOTTOM w0.381: v1(117.62,133.45) 117.62,133.88 UV1.AD17
+V_DAC: length 12.9
  TOP w0.089: v1(27.56,67.1) v3(28.22,67.1)
  TOP w0.508: TL2.11 27.25,66.78 v1(27.56,67.1) ; v1(28.11,70.48) 28.04,70.56 CL9.2 25.82,70.56 TL2.14
  BOTTOM w0.508: TL2.14 28,70.59 v1(28.11,70.48) 28.12,70.47 28.12,67.66 v1(27.56,67.1) 27.25,66.78 TL2.11
+VCHGR:
  vias: v1(170.3,38.39) v1(170.3,37.75) v1(170.94,38.39) v1(170.94,37.75) v1(171.52,38.39) v1(171.52,37.75) v1(175.73,43.8) v1(175.73,43.21) v1(176.31,43.79) v1(176.31,43.2) v1(177.73,45.79) v1(178.32,45.78) v4(171.67,39.37)
+VGA_CORE: length 59.4
  TOP w0.254: CV72.1 125.09,130.81 v1(125.64,131.35) 125.2,131.79 CV78.1
  TOP w0.381: CV112.1 122.49,134.02 v1(122.77,134.3) 123.33,133.73 CV113.1 CV111.1 ; CV77.1 127.89,132.65 v1(127.71,132.47) ; CV71.1 121.38,132.4 v1(120.82,132.4) 120.82,132.91 CV73.1 ; v1(127.64,134.2) 127.36,134.49 CV115.1 127.28,135.24 v1(126.71,135.24) ; v1(124.61,134.19) 125.19,134.77 CV117.1 ; v1(125.76,129.48) 125.4,129.83 125.1,129.83 CV87.1 ; CV116.1 126.67,134.24 v1(126.72,134.24) 126.21,133.73 CV114.1
  TOP w0.508: v1(122.75,127.78) CV102.1 123.4,126.61 CV101.1 CV105.1 ; CV118.1 125.16,135.91 v1(124.67,136.41) ; CV75.1 122.28,135.3 v1(121.77,135.3) 121.39,135.67 CV74.1 ; CV103.1 120.63,127.01 121.2,127.57 v1(121.3,127.57) 121.84,127.57 CV107.1 ; v1(127.41,128.4) 126.98,128.4 CV119.1 ; CV127.1 120.86,136.32 v1(120.86,136.32)
  BOTTOM w0.254: v1(125.64,131.35) 125.28,131 UV1.R13
  BOTTOM w0.381: UV1.N17 125.94,133.8 UV1.R16 UV1.T15 124.14,131.93 v1(123.74,131.53) 123.34,131.13 UV1.U13 ; UV1.M13 UV1.M15 ; UV1.U13 123.34,130.97 v1(122.92,130.55) ; UV1.U13 124.14,130.2 UV1.T12 124.14,129.91 123.34,129.11 UV1.U11 123.34,128.4 UV1.U10 ; UV1.M11 127.14,128.67 v1(127.41,128.4) ; UV1.W9 122.37,127.4 v1(122.75,127.78) 123.14,128.17 UV1.U10 ; UV1.W9 121.4,126.85 v1(121.3,126.85) v1(121.3,127.57) 121.13,127.4 UV1.Y9 ; UV1.W9 UV1.W10 ; UV1.N15 126.14,131.86 v1(125.64,131.35) ; UV1.N12 126.14,129.86 v1(125.76,129.48) ; UV1.N20 UV1.R18 125.14,134.71 v1(124.61,134.19) 124.23,133.8 UV1.T17 UV1.U16 123.27,133 122.77,132.5 122.77,132.43 UV1.V15 122.27,132 121.77,131.5 121.77,131.43 UV1.Y13 UV1.AA12 ; v1(120.86,136.32) UV1.Y21 121.49,136.95 122.19,136.95 UV1.V21 UV1.V20 121.84,135.3 v1(121.77,135.3) 121.77,135.23 UV1.Y18 ; 119.79,131.44 119.96,131.44 120.34,131.82 UV1.AA15 120.38,132 120.78,132.4 v1(120.82,132.4) 120.82,132.44 121.34,132.96 UV1.Y16 121.54,133 UV1.V17 122.34,133.87 v1(122.77,134.3) 123.27,134.8 UV1.U18 123.34,135 UV1.T20 124.14,135.88 v1(124.67,136.41) ; UV1.U10 UV1.T10 ; UV1.M20 UV1.M21
  vias: v1(104.76,139.99) v1(104.76,139.4) v1(104.76,138.46) v1(104.76,137.88) v1(104.76,136.94) v1(104.76,136.36) v1(105.13,122.33) v1(105.13,121.72) v1(105.13,121.14) v1(105.13,120.56) v1(105.34,140.75) v1(105.34,139.99) v1(105.34,139.4) v1(105.34,138.46) v1(105.34,137.88) v1(105.34,136.94) v1(105.34,136.36) v1(105.34,135.67) v1(105.25,124.77) v1(105.25,124.16) v1(105.25,123.55) v1(105.25,122.94) v1(105.71,122.33) v1(105.71,121.72) v1(105.71,121.14) v1(105.71,120.56) v1(105.84,125.38) v1(105.84,124.77) v1(105.84,124.16) v1(105.84,123.55) v1(105.84,122.94) v1(105.93,140.75) v1(105.93,139.99) v1(105.93,139.4) v1(105.93,138.46) v1(105.93,137.88) v1(105.93,136.94) v1(105.93,136.36) v1(105.93,135.67) v1(105.93,135.09) v1(106.29,122.33) v1(106.29,121.72) v1(106.29,121.14) v1(106.29,120.56) v1(106.42,125.38) v1(106.42,124.77) v1(106.42,124.16) v1(106.42,123.55) v1(106.42,122.94) v1(106.51,140.75) v1(106.51,139.99) v1(106.51,139.4) v1(106.51,138.46) v1(106.51,137.88) v1(106.51,136.94) v1(106.51,136.36) v1(106.51,135.67) v1(106.51,135.09) v1(106.88,122.33) v1(106.88,121.72) v1(106.88,121.14) v1(106.88,120.56) v1(107.01,124.77) v1(107.01,124.16) v1(107.01,123.55) v1(107.01,122.94) v1(107.1,140.75) v1(107.1,139.99) v1(107.1,139.4) v1(107.1,138.46) v1(107.1,137.88) v1(107.1,136.94) v1(107.1,136.36) v1(107.1,135.67) v1(107.1,135.09) v1(111.46,121.16) v1(111.46,120.57) v1(115.79,125.4) v1(115.79,124.57) v1(116.54,125.44) v1(118.11,128.61) v1(118.29,131.02) v1(118.56,121.07) v1(118.7,132.22) v1(118.94,121.58) v1(119.25,121.07) v1(119.57,122.56) v1(119.79,130.41) v1(119.81,129.5) v1(119.8,121.39) v1(120.66,123.4) v1(121.34,124.63) v1(121.83,121.39) v1(122.06,123.8) v1(122.15,124.58) v4(113.64,123.12)
+VREF_CA: length 2.6
  TOP w0.102: v3(71.1,68.18) 71.67,67.61 RD2.2
  BOTTOM w0.254: v1(72.37,67.24) 70.95,67.24 JDIMM1.164
+VREFB_CA: length 2.5
  TOP w0.102: CD61.1 58.97,68.59 v3(58.56,69.01)
  BOTTOM w0.254: v1(59.67,67.24) 58.25,67.24 JDIMM2.164
A_MIC_CLK: length 224.2
  TOP w0.112: LA10.1 35.13,11.35 35.35,11.13 35.62,11.13 v1(35.79,11.3) 35.83,11.27 36.19,11.27 CA50.1 ; v1(159.68,38.47) 159.85,38.29 159.85,38.01 159.94,37.92 159.94,34.39 159.85,34.3 159.85,31.12 v1(159.67,30.94)
  IN1 w0.119: v1(159.67,30.94) 159.84,30.77 159.84,29.89 159.11,29.16 146.73,29.16 144.67,31.22 138.89,31.22 133.39,25.73 100.88,25.73 99.96,24.81 60.75,24.81 58.98,26.58 58.98,27.94 58.31,28.61 57.87,28.61 57.17,29.31 57.17,30.06 55.58,31.65 46.51,31.65 46.23,31.38 41.64,31.38 40.55,30.28 39.72,30.28 37.9,28.47 37.9,26.74 39.09,25.55 39.09,23.28 37.44,21.63 37.44,19.28 37.05,18.89 37.05,12.07 36.12,11.13 35.96,11.13 v1(35.79,11.3) ; v1(213.43,45.47) 213.26,45.64 213,45.64 211.3,43.93 211.3,42.15 209.55,40.41 208.38,40.41 206.89,38.92 202.16,38.92 201.62,39.46 192.5,39.46 191.88,38.84 190.33,38.84 189.61,38.13 187.87,38.13 187.48,37.74 182.72,37.74 181.16,39.3 176.16,39.3 174.94,38.08 173.16,38.08 172.27,38.97 166.78,38.97 164.57,36.76 164.55,36.76 164.44,36.65 161.86,36.65 160.66,37.85 160.2,37.85 159.93,38.11 159.93,38.21 v1(159.68,38.47)
  BOTTOM w0.112: v1(213.43,45.47) 213.27,45.63 212.99,45.63 212.81,45.45 JEDP1.31
A_MIC_DATA: length 224.2
  TOP w0.112: v1(160.25,30.94) 160.09,31.1 160.09,34.2 160.18,34.29 v2(160.18,35.85) 160.18,38.02 160.09,38.11 160.09,38.3 v1(160.26,38.47) ; CA51.1 36.09,10.86 35.93,10.86 v1(35.79,10.72) 35.62,10.89 35.3,10.89 35.16,10.75 RA55.1
  IN1 w0.119: v1(160.25,30.94) 160.08,30.77 160.08,29.79 159.21,28.91 146.63,28.91 144.57,30.98 138.99,30.98 133.49,25.48 100.98,25.48 100.06,24.56 60.64,24.56 58.73,26.48 58.73,27.84 58.21,28.36 57.77,28.36 56.92,29.21 56.92,29.96 55.48,31.41 46.61,31.41 46.33,31.13 41.74,31.13 40.65,30.04 39.82,30.04 38.15,28.36 38.15,26.84 39.34,25.65 39.34,23.18 37.69,21.53 37.69,19.18 37.3,18.79 37.3,11.97 36.22,10.89 35.96,10.89 v1(35.79,10.72) ; v1(160.26,38.47) 160.18,38.38 160.18,38.21 160.3,38.1 160.76,38.1 161.96,36.9 164.34,36.9 164.45,37 164.47,37 166.68,39.21 172.37,39.21 173.26,38.33 174.84,38.33 176.06,39.55 181.26,39.55 182.82,37.99 187.38,37.99 187.76,38.37 189.51,38.37 190.22,39.09 191.77,39.09 192.4,39.71 201.72,39.71 202.26,39.16 206.79,39.16 208.28,40.65 209.45,40.65 211.05,42.26 211.05,44.04 212.9,45.89 213.26,45.89 v1(213.43,46.06)
  BOTTOM w0.112: v1(213.43,46.06) 213.24,45.87 212.88,45.87 212.8,45.95 JEDP1.30
AC_B2B_ACOK: length 17.5
  TOP w0.254: v1(94.79,150.87) 94.7,150.96 PD10.1 93.76,150.96 92.52,149.72 90.57,149.72 v1(90.51,149.66) 90.22,149.36 90.22,148.73 90.47,148.48 PQ16.1
  IN2 w0.254: v1(94.79,150.87) 95.61,150.04 95.61,146.57 94.15,145.11 v1(94.15,143.4)
  BOTTOM w0.089: v1(94.79,150.87) 94.79,150.42 v3(94.88,150.34)
  BOTTOM w0.254: v1(94.15,143.4) 94.72,142.84 PQ20.1 ; PR2.1 90.03,150.15 v1(90.51,149.66)
AC_B2B_S1: length 62.9
  TOP w0.089: v3(87.42,147.28) 87.07,147.63 v1(86.97,147.63)
  TOP w0.254: v1(65.76,120.22) 65.31,119.77 PQS11.1 ; v1(86.97,147.63) PC22.1 87.73,148.26 PR22.2 88.6,149.13 PQ16.2
  IN2 w0.254: v1(64.63,127.66) 65.98,126.3 67.46,126.3 68.33,125.44 68.33,122.78 v1(65.76,120.22)
  IN3 w0.254: v1(93.7,149.58) 93.7,149.54 93.32,149.16 88.49,149.16 v1(86.97,147.63) 86.96,147.64 86.6,147.64 86.28,147.32 78.04,147.32 75.55,144.83 75.55,142.05 74.93,141.43 73.04,141.43 70.63,139.02 66.34,139.02 63.31,135.99 63.31,128.98 v1(64.63,127.66)
  BOTTOM w0.254: PQ15.1 93.78,149.5 v1(93.7,149.58)
AC_B2B_S1_A: length 5.4
  BOTTOM w0.089: PC7.1 92.05,152.78 92.49,153.22 93.53,153.22 v3(93.86,152.89)
  BOTTOM w0.254: PC7.1 91.98,152.79 PR100.1 91.06,152.64 PQ5.2 90.71,151.24 PR2.2
AC_B2B_S2: length 7.1
  BOTTOM w0.089: PR17.1 95.65,143.11 v3(95.87,142.9)
  BOTTOM w0.254: PR51.1 92.54,144.69 92.97,145.12 93.74,145.12 94.51,144.34 PQ6.2 95,144.26 95.37,143.89 PR17.1 PC10.1 95.65,145.6 PR11.2
AC_B2B_S2_A: length 9.3
  BOTTOM w0.089: PR50.2 92.4,145.42 92.83,145.85 v3(92.83,146.59)
  BOTTOM w0.254: PR60.2 89.78,148.38 89.21,147.81 89.21,146.72 PQ17.2 ; PQ17.2 90.51,145.42 PR50.2 ; PQ17.2 90.47,144.77 91.1,144.13 PQ18.1
AC_B2B_S2_B: length 16.7
  TOP w0.089: v1(97.94,147.04) 97.94,147.33 v3(98.34,147.73)
  IN2 w0.254: v1(93.98,151.99) 94.9,151.99 97.82,149.07 97.82,147.16 v1(97.94,147.04)
  BOTTOM w0.254: PR47.2 91.81,148.7 91.02,148.7 90.76,148.95 PR48.1 90.76,149.26 90.98,149.48 90.98,150.15 91.27,150.44 92.27,150.44 92.5,150.21 92.95,150.21 93.98,151.24 v1(93.98,151.99) ; v1(97.94,147.04) 97.94,146.9 99.05,145.8 PQ19.2
AC_B2B_S2_G: length 12.7
  TOP w0.254: PQ4.4 100.63,146.35 v1(100.05,146.93) 100.07,146.96 PC6.2 100.07,148.52 100.41,148.86 102.01,148.86 PR9.2
  BOTTOM w0.089: v3(103.03,146.77) PQ19.1
  BOTTOM w0.254: PQ19.1 100.22,146.77 v1(100.05,146.93) 98.69,146.93 98.13,147.49 97.76,147.49 96.75,146.49 PR12.1
AC_B2B_S2_SW: length 8
  BOTTOM w0.089: v4(91.8,140.94) 91.77,140.97 91.77,142.18
  BOTTOM w0.254: PR51.2 92.2,143.59 91.77,143.17 91.77,142.18 91.57,142.18 91.14,142.6 89.9,142.6 89.64,142.86 PQ18.2 88.74,142.86 88.53,142.65 PC23.1 PR49.2
AC_DIS: length 184.1
  TOP w0.089: v3(165.5,27.67) 164.92,28.25 v1(164.92,28.36) ; v1(38.9,71.89) 39.28,71.52 41.44,71.52 42.86,70.1 45.42,70.1 45.86,70.55 47.93,70.55 48.02,70.46 48.02,69.27 47.75,69 UE1.27
  TOP w0.254: v1(164.92,28.36) 164.92,28.44 164.66,28.7 PRB43.2
  IN2 w0.089: v1(164.92,28.36) 164.41,28.36 164.27,28.5 151.17,28.5 150.84,28.83 148.76,28.83 146.1,31.49 146.1,31.88 144.94,33.04 137.86,33.04 136,31.17 130.44,31.17 126.81,27.55 120.95,27.55 120.09,28.41 117.58,28.41 116.71,27.55 112.16,27.55 111.6,28.11 110.76,28.11 110.2,27.55 99.02,27.55 98.81,27.75 97.77,27.75 96.83,26.81 83.63,26.81 83.21,27.23 67.62,27.23 65.7,29.14 62.86,29.14 62.13,28.41 60.55,28.41 59.39,29.57 59.39,30.7 54.32,35.77 48.34,35.77 44.8,39.31 44.8,50.54 41.9,53.44 41.9,54.48 37.82,58.57 37.82,60.48 38.26,60.92 38.26,64.3 38.19,64.37 38.19,68.65 37.5,69.34 37.5,70.97 38.23,71.69 38.71,71.69 v1(38.9,71.89)
AC_DIS1: length 303.1
  TOP w0.254: v3(164.14,27.68) v1(163.75,28.08) 163.34,28.48 PRB43.1 PRB23.1 163.34,29.89 163.05,30.18 163.05,30.49 PQB04.2
  IN1 w0.089: v1(93.71,139.78) 92.19,139.78 91.31,138.91 86.79,138.91 85.91,139.78 84.26,139.78 83.33,138.86 81.98,138.86 81.57,139.26 80,139.26 79.79,139.06 79.79,135.91 79.44,135.56 77.81,135.56 77.38,135.12 75.67,135.12 74.2,133.65 71.89,133.65 71.03,132.79 62.3,132.79 57.04,127.53 51.45,127.53 51.13,127.21 51.08,127.21 50.54,126.67 50.27,126.67 48.27,124.66 v1(48.27,124.14)
  IN2 w0.089: v1(37.65,91.92) 37.65,93.73 40.65,96.73 40.65,99.41 41.91,100.67 41.91,108.31 39.43,110.79 39.43,113.75 40.76,115.08 42.47,115.08 45.92,118.53 46.54,118.53 48.55,120.54 48.55,123.86 v1(48.27,124.14)
  BOTTOM w0.089: v1(37.65,91.92) 37.83,91.74 37.83,88.44 38.2,88.07 40.92,88.07 41.23,87.75 41.23,86.46 40.03,85.25 39.27,85.25 37.61,83.59 37.61,82.14 36.55,81.08 36.55,78.33 38.81,76.07 38.81,72.59 37.37,71.15 37.37,70.18 37.83,69.71 37.83,67.48 37.13,66.77 37.13,65.08 36.05,64 36.05,52.38 32.7,49.03 32.7,47.25 37.73,42.22 40.79,42.22 42.29,40.72 42.29,38.5 45.53,35.26 52.81,35.26 57.79,30.28 57.79,29.65 58.39,29.05 62.82,29.05 65.35,26.53 92.19,26.53 94.18,28.52 98.43,28.52 99.2,27.76 108.16,27.76 114.3,33.9 120.86,33.9 122.49,35.52 124.3,35.52 127.15,32.68 128.82,32.68 129.74,31.76 139.46,31.76 139.56,31.67 144.5,31.67 148.79,27.38 163.05,27.38 v1(163.75,28.08)
  BOTTOM w0.254: v1(93.71,139.78) 93.84,139.91 PQ20.2
AC_OK: length 295.4
  TOP w0.254: v1(53.97,120.87) 53.97,121.09 53.53,121.53 53.53,121.58 52.95,122.15 PRS41.1 52.45,122.72 PRS33.1 ; v1(168.21,32.34) 168.23,32.36 168.23,32.55 168.49,32.8 PRB44.1 ; v1(91.6,150.93) 91.6,151.08 92.1,151.58 PD10.2 92.12,151.61 92.48,151.96 PR13.2 PR15.1
  IN2 w0.254: v1(53.97,120.87) 53.97,117.74 53.26,117.02 49.76,117.02 48.37,115.63 46.95,115.63 43.57,112.25 43.57,111.25 43.09,110.77 43.09,89.39 42.37,88.68 42.37,86.7 41.26,85.59 39.33,85.59 39.07,85.34 39.07,84.09 39.33,83.83 40.11,83.83 41.89,82.05 41.89,81.38 42.4,80.88 42.4,77.55 42.07,77.22 42.07,76.86 42.19,76.73 42.19,72.63 41.95,72.39 41.95,71.85 42.12,71.68 42.12,69.97 41.74,69.59 41.74,67.76 42.26,67.24 42.26,65.82 41.71,65.26 41.71,63.94 40.37,62.6 40.37,59.78 41.93,58.21 42.21,58.21 43.91,56.51 43.91,55.44 44.86,54.5 44.86,53.45 46.9,51.41 46.9,46.48 47.53,45.84 48.01,45.84 49.4,44.46 49.4,40.41 51.27,38.53 54.68,38.53 59.2,34.01 60.57,34.01 61.68,32.9 61.68,32.56 62.4,31.84 67.43,31.84 67.83,31.44 79.88,31.44 80.13,31.2 96.84,31.2 97.57,30.47 98.51,30.47 99.07,31.03 102.86,31.03 103.63,30.26 109.09,30.26 109.65,30.81 115.9,30.81 116.38,31.29 121.28,31.29 121.58,30.99 124.96,30.99 125.26,31.29 125.26,31.29 129.23,35.26 129.86,35.26 131.32,36.72 134.69,36.72 135.5,35.92 144.74,35.92 145.79,36.97 146.65,36.97 147.35,36.26 147.55,36.26 150.2,36.26 150.71,35.76 152.79,33.67 160.61,33.67 161.72,32.56 162.83,32.56 162.97,32.43 163.84,32.43 164.45,31.83 165.87,31.83 166.38,32.34 v1(168.21,32.34)
  IN3 w0.254: v1(91.6,150.93) 91.11,150.44 89.19,150.44 86.81,148.06 86.54,148.06 86.14,147.66 77.89,147.66 75.21,144.98 75.21,142.2 74.79,141.78 72.9,141.78 70.49,139.37 66.2,139.37 62.96,136.13 62.96,127.69 62.7,127.44 54.87,127.44 52.8,125.37 52.8,122.04 v1(53.97,120.87)
AC_SW_PROCHOT: length 3.4
  TOP w0.089: v3(169.36,27.95) PR33.2
  TOP w0.254: PR33.2 170.32,29.16 PQ12.6 169.56,29.25 PC13.1
ACAV_IN1: length 66.1
  TOP w0.203: PRB41.1 163.77,34.47 162.95,33.65 PRB20.1 162.95,33.14 163.19,32.9 163.29,32.9 163.6,32.6 PQB04.1
  TOP w0.254: PRB41.1 163.77,37.11 v1(163.59,37.29)
  IN1 w0.254: v1(163.59,37.29) 163.92,37.61 164.31,37.61 166.33,39.63 172.87,39.63 173.63,38.87 174.99,38.87 176.09,39.97 178.95,39.97 179.42,40.44 180.84,40.44 182.91,38.37 187.23,38.37 187.51,38.65 188.43,38.65 188.76,38.97 188.76,39.24 189.02,39.51 191.8,39.51 192.6,40.31 204.26,40.31 205.02,41.07 209.26,41.07 210.63,42.45 210.63,45.24 209.97,45.91 v1(209.97,47.81)
  BOTTOM w0.203: 208.93,48.87 209.97,47.84 v1(209.97,47.81)
  BOTTOM w0.254: PRB11.2 PRB22.2 208.52,49.29 208.93,48.87
ACIN_65W: length 4.9
  TOP w0.089: v3(51.25,88.12) RV150.2 49.95,88.5 48.9,88.5 48.72,88.32 UV8.2 48.72,86.22 RE36.2
ACIN_CHG: length 7.2
  TOP w0.254: PRB07.1 200.48,51.79 v1(201.15,51.79) 201.15,49.98 201.68,49.45 v3(203.11,49.45) 203.93,49.45 204.19,49.19 v1(204.19,48.83)
  BOTTOM w0.203: v1(204.19,48.83) 204.19,48.64 203.97,48.42 PUB01.19
ACOK_CHG: length 2.6
  BOTTOM w0.203: PRB22.1 207.6,49.48 206.61,48.48 206.17,48.48 205.97,48.28 PUB01.24
AD_BID0: length 4.6
  TOP w0.089: v3(52.22,85.29) RE5.1 CE9.1 RE9.2 49.56,84.86 49.35,84.65 UE1.66
ADJ_0.95V: length 4.5
  TOP w0.089: v3(89.1,115.1) PRF02.2
  TOP w0.254: PUF01.7 86.71,115.24 86.79,115.16 PCF05.2 ; PCF05.2 87.23,115.99 PRF03.1 ; PCF05.2 88.09,115.16 PRF02.2
ADJ_2.5V: length 6.5
  TOP w0.102: PR2503.1 65.62,108.34 v3(65.82,108.14)
  TOP w0.254: PC2505.2 64.91,111.34 64.91,109.63 65.39,109.15 PR2503.1 ; PC2505.2 64.93,111.69 PU2501.7 ; PC2505.2 PR2502.2
ADP_CHG: length 2.4
  BOTTOM w0.203: PUB01.16 202.27,47.49 202.27,47.83 201.18,48.92 PRB04.2
ADP_I: length 263.1
  TOP w0.089: UE1.65 49.75,81.76 48.83,80.84 44.18,80.84 42.85,79.5 40.66,79.5 40.56,79.4 v1(40.56,79.39) ; v1(217.37,42.05) 217.37,42.05 217.02,42.4 v3(215.35,42.4) 215.24,42.4 215.11,42.53 213.59,42.53 213.23,42.89 212.97,42.89 212.83,43.03 211.76,43.03 211.47,43.32 211.47,45.63 v1(211.27,45.83)
  IN2 w0.089: v1(217.37,42.05) 217.39,42.03 217.39,41.5 217.2,41.3 217.2,40.72 217.65,40.27 217.65,36.16 217.12,35.63 217.12,35.15 214.88,32.91 214.14,32.91 213.64,32.41 211.31,32.41 210.54,31.64 204.58,31.64 204.36,31.86 203.7,31.86 203.26,32.3 202.6,32.3 202.36,32.06 197.73,32.06 197.56,31.9 191.71,31.9 190.17,33.44 190.17,34.19 189.93,34.42 189.6,34.42 186.67,31.48 181.55,31.48 181.45,31.59 180.54,31.59 178.71,29.76 175.72,29.76 175.11,29.15 173.59,29.15 173.05,29.68 168.92,29.68 168.71,29.48 163.71,29.48 163.29,29.05 151.39,29.05 151.06,29.38 148.99,29.38 146.65,31.72 146.65,32.11 145.17,33.58 137.63,33.58 135.77,31.72 128.73,31.72 125.11,28.1 121.18,28.1 120.32,28.96 117.35,28.96 116.48,28.1 114.4,28.1 113.83,28.66 110.54,28.66 109.97,28.1 99.83,28.1 99.61,28.32 97.56,28.32 96.82,27.58 83.99,27.58 82.96,28.61 67.2,28.61 66.12,29.69 62.63,29.69 61.9,28.96 60.78,28.96 59.94,29.8 59.94,30.93 54.31,36.56 48.32,36.56 45.35,39.54 45.35,50.76 42.45,53.66 42.45,54.71 38.93,58.23 38.93,59.02 38.82,59.14 38.82,64.61 38.74,64.69 38.74,67.65 39.24,68.15 39.24,71.18 39.64,71.58 39.64,72.27 40.6,73.23 40.6,74.83 39.86,75.57 39.86,76.63 40.37,77.14 40.37,79.14 40.56,79.34 v1(40.56,79.39)
  BOTTOM w0.102: PRB35.2 211.23,45.52 211.23,45.8 v1(211.27,45.83)
AGPIO3: length 31.9
  TOP w0.099: RC40.2 128.44,49.12 v3(127.69,49.87) 126.83,50.74 126.83,51.71 127.41,52.29 127.94,52.29 128.23,52.58 128.23,54.14 128.62,54.53 128.62,55.63 128.2,56.05 128.2,57.27 128.05,57.43 127.32,57.43 126.72,58.03 v1(126.72,58.48)
  IN2 w0.089: v1(132.93,44.26) 132.39,44.79 132.39,48.19 128.75,51.83 128.75,54.05 127.48,55.32 127.48,56 127.35,56.13 127.35,57.85 v1(126.72,58.48)
  BOTTOM w0.089: UC1.AT15 126.23,58.76 126.51,58.48 v1(126.72,58.48) ; RC36.2 131.99,45.52 132.55,44.96 132.55,44.79 132.67,44.66 132.67,44.52 v1(132.93,44.26)
