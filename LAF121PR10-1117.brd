# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_WCKA0_1#: length 20.1
  TOP w0.112: UV12.D5 151.11,139.52 v1(150.71,139.13)
  IN1 w0.13: v1(150.71,139.13) 150.89,139.13 151.01,139 151.01,138.77 150.6,138.36 149.77,138.36 149.06,137.64 135.95,137.64 135.63,137.96 134.8,137.96 134.54,137.7 134.54,137.44 134.39,137.29 v1(134.15,137.29)
  BOTTOM w0.102: UV1.C21 133.86,137 v1(134.15,137.29)
  BOTTOM w0.112: v1(150.71,139.13) 151.11,139.52 UV12.D5
M_WCKA1_0: length 35.2
  TOP w0.112: v1(158.71,126.91) 158.71,127.14 158.88,127.31 UV14.D4
  IN1 w0.13: v1(133.37,130.28) 133.16,130.07 133.16,129.98 133.08,129.9 133.08,129.67 133.25,129.5 133.25,128.31 132.93,127.99 132.93,127.09 134.63,125.39 136.08,125.39 137.38,124.1 147.32,124.1 147.93,124.7 157.54,124.7 158.51,125.67 158.51,125.91 159.05,126.45 159.05,126.75 158.89,126.91 v1(158.71,126.91)
  BOTTOM w0.112: v1(133.37,130.28) 133.44,130.35 133.44,130.51 133.16,130.79 132.96,130.79 132.94,130.77 UV1.E13 ; UV14.D4 159.08,127.34 158.86,127.34 158.66,127.14 158.66,126.96 v1(158.71,126.91)
M_WCKA1_0#: length 34.7
  TOP w0.112: v1(159.41,126.91) 159.41,126.81 UV14.D5
  IN1 w0.13: v1(132.77,130.14) 132.86,130.06 132.86,129.58 133.03,129.41 133.03,128.4 132.72,128.08 132.72,127 134.54,125.17 135.99,125.17 137.29,123.88 147.42,123.88 148.02,124.49 157.63,124.49 158.73,125.58 158.73,125.82 159.27,126.36 159.27,126.81 159.37,126.91 v1(159.41,126.91)
  BOTTOM w0.102: UV1.D12 v1(132.77,130.14)
  BOTTOM w0.112: UV14.D5 159.41,126.81 v1(159.41,126.91)
M_WCKA1_1: length 26
  TOP w0.112: UV14.P4 v1(150.71,126.91)
  IN1 w0.13: v1(138.08,124.95) 138.29,125.16 138.29,125.37 138.6,125.68 143.51,125.68 144.18,125.02 146.79,125.02 147.3,125.53 150.6,125.53 150.87,125.8 150.87,126.75 v1(150.71,126.91)
  BOTTOM w0.089: 133.22,121.87 133.23,121.87 133.27,121.83 135.8,121.83 138.3,124.32 138.3,124.54
  BOTTOM w0.112: UV14.P4 v1(150.71,126.91) ; UV1.E3 132.98,123.44 132.98,123.7 132.87,123.81 132.69,123.81 132.58,123.7 132.58,123.3 132.66,123.21 132.66,122.78 132.63,122.75 132.63,122.45 132.9,122.18 132.9,121.95 132.98,121.87 133.22,121.87
  BOTTOM w0.122: 138.3,124.54 138.3,124.72 v1(138.08,124.95)
M_WCKA1_1#: length 26.3
  TOP w0.112: UV14.P5 v1(151.51,126.91)
  IN1 w0.13: v1(138.66,124.95) 138.5,125.1 138.5,125.28 138.69,125.47 143.42,125.47 144.09,124.8 146.88,124.8 147.39,125.31 150.69,125.31 151.09,125.71 151.09,126.63 151.37,126.91 v1(151.51,126.91)
  BOTTOM w0.089: 138.52,124.54 138.52,124.27 135.88,121.64 133.19,121.64
  BOTTOM w0.112: UV1.F4 132.14,123.44 132.45,123.13 132.45,122.87 132.42,122.84 132.42,122.32 132.66,122.08 132.66,121.85 132.88,121.63 133.19,121.63 133.19,121.64 ; UV14.P5 v1(151.51,126.91)
  BOTTOM w0.122: 138.52,124.54 138.52,124.81 v1(138.66,124.95)
M_WE#0: length 32.3
  TOP w0.102: 147.8,141.73 156.25,141.73 157.83,143.31 157.83,143.66 157.63,143.86 157.44,143.86
  TOP w0.127: 147.36,141.73 147.8,141.73 ; 157.44,143.86 157.11,144.19 v1(157.11,144.73) 156.71,145.13 UV12.L12 ; 135.31,139.87 134.54,139.87 133.55,138.87 v1(133.34,138.87)
  TOP w0.14: 147.36,141.73 144.7,141.73 v3(144.35,141.37) 142.34,139.36 135.83,139.36 135.66,139.53 135.66,139.54 135.43,139.77 135.42,139.77 135.32,139.87 135.31,139.87
  BOTTOM w0.127: UV1.G25 131.82,139.71 132.49,139.71 v1(133.34,138.87) ; UV12.L12 156.71,145.13 v1(157.11,144.73)
M_WE#1: length 31.9
  TOP w0.102: v1(153.11,121.31) 153.11,121.81 152.82,122.1 152.66,122.1 152.38,122.37 152.38,123.16 152.28,123.26 148.93,123.26 148.38,122.72 148.38,122.16 147.88,121.65
  TOP w0.127: v1(130.07,128.71) 130.1,128.71 130.61,128.2 130.61,127.68 130.91,127.39 131.9,127.39 132.37,126.92 132.79,126.92 134.74,124.98 134.74,124.68 135.77,123.65 136.58,123.65 ; v1(153.11,121.31) UV14.L12 ; 147.88,121.27 147.88,121.65
  TOP w0.14: 136.58,123.65 137.81,122.42 v3(143.04,122.42) 143.69,122.42 145.26,120.84 147.74,120.84 147.88,120.98 147.88,121.27
  BOTTOM w0.102: v1(130.07,128.71) 130.42,128.37 130.42,128.32 UV1.H10
  BOTTOM w0.127: UV14.L12 v1(153.11,121.31)
MCT0: length 7.3
  TOP w0.254: TL2.3 17.99,70.59 18.32,70.92 18.32,73.54 16.49,75.37 RL9.1
MCT1: length 10.7
  TOP w0.254: TL2.6 18.19,66.78 18.91,67.5 RL7.1
MCT2: length 14.9
  TOP w0.254: v1(20.11,76.61) RL19.1
  IN1 w0.254: v1(20.11,76.61) 19.01,76.61 17.54,75.14 17.54,73.5 16.1,72.07 16.1,68.26 v1(15.53,67.69)
  BOTTOM w0.089: v1(20.11,76.61) v3(19.53,76.61)
  BOTTOM w0.254: v1(15.53,67.69) 15.53,67.11 15.86,66.78 TL1.3
MCT3: length 13.4
  TOP w0.254: v1(17.7,76.61) RL20.1
  IN1 w0.254: v1(17.7,76.61) 17.04,75.96 17.04,73.58 15.53,72.07 v1(15.53,68.58)
  BOTTOM w0.089: v1(17.7,76.61) v3(17.15,76.61)
  BOTTOM w0.254: v1(15.53,68.58) 15.53,70.23 15.89,70.59 TL1.6
MEM_ERROR_A: length 164.2
  TOP w0.089: v1(132.79,38.35) 133.21,37.93 133.21,37.46 133.12,37.37 130.48,37.37 129.54,36.43 128.88,36.43 127.87,35.43 125.22,35.43 124.52,34.73 124.52,33.55 123.67,32.7 123.67,30.01 124.13,29.56 124.13,28.34 122.82,27.03 119.45,27.03 v1(118.74,27.74) ; UE1.1 37.35,66.56 37.26,66.47 v3(37.26,64.99) 37.26,64.61 v1(37.02,64.37)
  IN2 w0.089: v1(60.71,27.61) 60.58,27.61 58.84,29.34 58.84,30.48 54.14,35.18 48.15,35.18 44.25,39.08 44.25,50.1 41.35,53 41.35,54.26 37.27,58.34 37.27,61.21 36.87,61.61 36.87,64.22 v1(37.02,64.37) ; v1(132.79,38.35) 133.33,38.89 134.64,42.06 136.42,43.84 136.42,47.89 136.75,48.22 136.75,48.69 136.21,49.23 136.21,51.53 135.89,51.84 135.89,52.41 133.07,55.24 133.07,56.32 132.81,56.57 132.54,56.57 132.36,56.76 132.36,57.22 131.69,57.88 v1(131.69,58.39)
  BOTTOM w0.089: v1(60.71,27.61) 61.12,28.01 62.39,28.01 65.65,24.75 100.35,24.75 101.38,25.79 117.72,25.79 118.74,26.8 v1(118.74,27.74) ; v1(131.69,58.39) 131.69,57.84 UC1.AV8
MEM_ERROR_B: length 173
  TOP w0.089: 136.78,45.4 136.78,45.4 v1(137.9,45.4) ; UE1.64 52.28,81.81 v1(52.59,82.11) ; v1(92.6,38.23) 92.6,37.6 92.93,37.27 96.07,37.27 96.29,37.49 96.29,38.38 96.68,38.77 v3(97.53,38.77) 98.28,38.77 98.37,38.68 98.37,33.8 100.57,31.61 107.87,31.61 110.32,34.06 121.39,34.06 121.83,33.62 121.94,33.5 123.15,33.5 123.56,33.92 123.56,34.42 123.12,34.86 123.12,39.28 124.97,41.13 129.04,41.13 129.12,41.22 129.12,42.18 129.93,42.99 130.35,42.99 130.6,42.74 130.6,41.98 131.29,41.29 132.19,41.29 133,42.1 133,42.37 134.69,44.06
  TOP w0.099: 134.69,44.06 136.03,45.4 136.78,45.4
  IN2 w0.089: v1(134.17,60.78) 134.03,60.78 133.16,59.91 133.16,59.52 133.3,59.38 133.92,59.38 135.76,57.53 135.76,55.13 140.74,50.16 140.74,45.86 141.89,44.72 141.89,43.66 141.54,43.31 139.64,43.31 137.9,45.04 v1(137.9,45.4) ; v1(52.59,82.11) 52.59,70.89 51.27,69.58 51.27,68.39 52.81,66.85 52.81,55.89 54.01,54.7 54.01,50.06 56.17,47.9 ; 61.47,42.35 61.47,41.67 62.09,41.05 63.97,41.05 66.76,38.25 79.74,38.25 80.36,37.63 87.25,37.63 88.14,38.51 92.33,38.51 v1(92.6,38.23)
  IN2 w0.102: 61.47,42.35 61.47,42.96 59.32,45.11 58.96,45.11 56.56,47.51 56.17,47.9
  BOTTOM w0.089: v1(134.17,60.78) 133.93,61.02 UC1.AN6
MIC1-L: length 2.6
  TOP w0.203: UA1.19 27.08,17 27.02,17.05 v3(27.02,17.5) 27.02,18.41 CA56.1
MIC_CLK_C: length 5
  TOP w0.112: UA1.3 v3(33.04,11.87) 33.9,11.87 LA10.2 34.28,12.35 RA19.1
MIC_DATA_C: length 4.5
  TOP w0.112: UA1.2 30.99,11.47 31.03,11.42 v3(31.54,11.42) 33.69,11.42 33.86,11.25 33.86,10.95 34.25,10.56 RA55.2
MUX_SBU1: length 17
  TOP w0.089: RT34.2 19.72,119.55 18.98,118.81 18.98,118.54 v1(18.94,118.49) ; v1(12.93,121.13) v3(13.53,121.13)
  TOP w0.102: v1(8.29,120.21) 8.01,120.5 7.9,120.5 7.73,120.32 JUSBC1.A8
  IN2 w0.089: v1(18.94,118.49) 18.74,118.3 17.66,118.3 17.28,118.69 17.28,119.2 17.1,119.38 16.1,119.38 14.34,121.13 v1(12.93,121.13)
  BOTTOM w0.089: 18.82,118.83 18.91,118.73 18.91,118.52 v1(18.94,118.49) ; v1(8.29,120.21) 8.86,120.78 EU8.2 EU8.8 12.58,120.78 v1(12.93,121.13)
  BOTTOM w0.102: UT9.27 18.56,119.09 18.82,118.83
MUX_SBU2: length 20.2
  TOP w0.089: v3(11.67,121.78) 11.84,121.95 v1(12.24,121.95) ; v1(19.51,118.61) 19.52,118.61 19.87,118.61 20.54,119.29 RT60.2
  TOP w0.203: v1(6.47,122.14) 6.35,122.14 6.28,122.07 5.75,122.07 JUSBC1.B8
  IN2 w0.089: v1(19.51,118.61) 19.51,118.38 19.25,118.12 17.59,118.12 17.09,118.61 17.09,119.1 17,119.18 16.03,119.18 14.27,120.95 13.28,120.95 13.09,120.76 12.78,120.76 12.24,121.29 v1(12.24,121.95)
  BOTTOM w0.089: v1(12.24,121.95) 12.07,121.78 EU8.7 EU8.4 8.79,121.78 8.47,122.11 6.59,122.11 6.55,122.14 v1(6.47,122.14) ; 19.3,118.83 v1(19.51,118.61)
  BOTTOM w0.102: 19.3,118.83 18.96,119.17 UT9.26
MUX_USB2_FILP: length 16
  IN3 w0.089: v1(40.71,124.41) 40.11,124.41 38.65,125.87 33.37,125.87 31.62,127.62 30.31,127.62 29.11,128.82 v1(29.11,128.85)
  BOTTOM w0.089: UT1.5 39.85,123.55 v1(40.71,124.41) ; UT10.9 29.11,129.53 v1(29.11,128.85)
NCT7718_DXN: length 111.5
  IN1 w0.089: v1(140.95,104.55) 140.95,104.63 141.27,104.95 142.62,104.95 144.05,103.52 155.72,103.52 160.24,98.99 164.82,98.99 165.98,97.83 165.98,94.11 167.52,92.57 167.52,86.19 169.96,83.75 169.96,73.97 177.52,66.42 177.52,64.8 181.14,61.18 v1(181.14,61.1)
  BOTTOM w0.089: v1(140.95,104.55) 140.95,104.64 141.34,105.02 141.34,105.54 v3(141.01,105.87) 140.29,106.59 134.37,106.59 132.92,105.14 127,105.14 125.49,106.65 116.2,106.65 112.73,110.13 112.73,110.47 C55.2 112.63,111.49 Q10.3 ; C56.2 181.61,60.92 181.43,61.1 v1(181.14,61.1) 181.14,61.18 181.02,61.29 181.02,61.56 180.93,61.65 180.87,61.65 U8.3
NCT7718_DXP: length 112.1
  IN1 w0.089: v1(181.55,61.51) 181.47,61.51 177.99,65 177.99,66.61 170.43,74.17 170.43,83.95 167.99,86.39 167.99,92.76 166.45,94.3 166.45,98.02 165.01,99.46 160.44,99.46 155.91,103.99 144.24,103.99 142.82,105.42 141.07,105.42 140.62,104.96 v1(140.54,104.96)
  BOTTOM w0.089: U8.2 181.35,62.09 181.35,61.71 v1(181.55,61.51) 181.81,61.25 C56.1 ; Q10.2 110.7,113.84 Q10.1 111.67,111.06 C55.1 112.26,110.47 112.26,109.93 116.01,106.18 125.29,106.18 126.81,104.67 133.12,104.67 134.57,106.12 140.1,106.12 140.68,105.54 140.87,105.34 140.87,105.22 140.62,104.96 v1(140.54,104.96)
ODD_DA#: length 3.9
  TOP w0.254: v1(196.28,65.91) 196.28,66.43 196.25,66.45 T46.1
  BOTTOM w0.254: JODD1.23 196.2,65.83 v1(196.28,65.91) 196.2,65.98 JODD1.24
ON/OFF#: length 283.3
  TOP w0.089: RE44.2 34.26,75.43 34.28,75.41 34.42,75.41 34.82,75.01 UE1.114 36.62,75.01 36.72,75.11 38.81,75.11 v1(39.36,74.55) ; ED2.3 37.49,63.7 37.35,63.83 v1(37.25,63.83) 36.63,63.83 36.48,63.69 SW1.2 35.86,64.47 34.95,65.39 v3(34.6,65.39) 32.74,65.39 CE19.1 EC2.1 28.98,64.18 v1(28.8,64)
  IN2 w0.089: v1(39.36,74.55) 39.72,74.19 39.72,73.71 37.13,71.12 37.13,68.08 37.08,68.03 37.08,65.33 37.69,64.72 37.69,64.28 v1(37.25,63.83) 37.25,63.72 37.31,63.65 37.31,61.42 37.45,61.29 37.45,58.41 41.53,54.33 41.53,53.07 44.43,50.17 44.43,39.16 48.23,35.36 54.22,35.36 59.02,30.55 59.02,29.42 60.4,28.04 62.28,28.04 63.01,28.78 65.31,28.78 67.54,26.54 82.91,26.54 83.17,26.29 96.83,26.29 97.88,27.34 98.62,27.34 98.78,27.18 110.35,27.18 110.77,27.6 111.43,27.6 111.85,27.18 128.71,27.18 132.34,30.81 136.15,30.81 137.98,32.64 144.1,32.64 148.31,28.43 148.97,28.43 150.08,27.32 165.73,27.32 166.36,27.95 170.53,27.95 171.04,27.44 172.65,27.44 173.26,28.05 175.61,28.05 176.17,28.61 180.21,28.61 181.98,30.39 188.97,30.39 189.13,30.23 197.19,30.23 198.11,31.15 202.31,31.15 202.87,30.6 202.87,30.31 202.95,30.23 210.83,30.23 212.28,31.67 213.94,31.67 214.45,32.18 215.29,32.18 217.85,34.73 217.85,35.32 218.38,35.86 218.38,41.11 218.33,41.16 218.33,42.69 218.82,43.18 221.41,43.18 222.94,44.71 222.94,47.79 221.6,49.13 221.6,50.19 221.35,50.44 221.35,54.62 221.81,55.08 221.81,56.16 222.68,57.03 222.68,59.16 223.23,59.7 223.23,60.17 222.39,61.01 222.39,62.26 v1(222.78,62.66)
  BOTTOM w0.089: v1(222.78,62.66) 222.64,62.66 222.2,63.1 JPWR1.2 ; v1(28.8,64) 28.61,64.19 SW2.2
OTGEN/CMIN_CHG: length 3.7
  TOP w0.254: v1(204.76,48.96) 204.66,49.05 v3(204.66,49.59) 204.66,50.61 PRB10.1
  BOTTOM w0.203: PRB13.1 204.66,49.33 204.66,49.05 v1(204.76,48.96) 204.76,48.76 204.37,48.37 PUB01.20
OVP_TRIP_P1: length 42.4
  TOP w0.254: PQS03.2 57.12,131.29 57.03,131.38 v1(57.03,131.53)
  BOTTOM w0.089: UT1.14 37.14,119.84 37.33,119.64 37.33,119.14 36.86,118.67 36.86,115.67 QT5.2 36.29,115.1 RT63.1 36.34,112.66 39.37,112.66 v3(39.39,112.68) 40.36,113.65 40.36,114.35 41.74,115.74 41.74,119.38 42.03,119.68 43.11,119.68 50.67,127.23 51.84,127.23 52.07,127.46 56.68,127.46 57.53,128.3 57.53,131.03 v1(57.03,131.53)
PANEL_BKLEN: length 135.8
  TOP w0.089: v1(45.63,82) 45.54,82 45.35,82.19 UE1.76 ; v1(130.03,91.89) 129.78,91.89 129.56,92.11 QC1.1 129.56,93.79 RC3.1 v3(128.56,93.84)
  IN2 w0.089: v1(50.46,83.03) 49.63,83.86 49.63,87.96 50.35,88.68 50.35,90.01 50.16,90.2 49.18,90.2 48.92,90.46 48.92,106.06 53.49,110.63 59.59,110.63 61.08,112.11 62.81,112.11 63.75,111.17 65.19,111.17 65.82,110.54 72.82,110.54 74.39,112.11 75.51,112.11 76.58,111.04 81.09,111.04 81.39,110.74 85.59,110.74 86.5,109.84 100.6,109.84 105.35,105.08 105.66,105.08 119.13,105.08 119.27,105.22 124.31,105.22 125.07,104.47 128.35,104.47 128.55,104.67 129.57,104.67 129.66,104.58 129.66,92.68 130.03,92.31 v1(130.03,91.89)
  IN3 w0.089: v1(50.46,83.03) 50.3,82.87 46.75,82.87 45.88,82 v1(45.63,82)
PANEL_BKLEN_EC: length 42.4
  TOP w0.089: v1(125.26,108.44) 125.26,103.47 121.85,100.06 121.85,94.76 122.07,94.54 124.4,94.54 125.57,93.37 125.57,93.02 126.07,92.52 127.37,92.52 v3(127.63,92.25) 128.32,91.57 v1(128.71,91.57) 129.23,91.57 129.57,91.22 130.07,91.22 130.21,91.08 QC1.3 131.01,90.78 131.05,90.81 RPC1.8
  IN2 w0.089: v1(128.71,91.57) 128.77,91.57 129.21,91.12 129.21,89.13 128.26,88.18 128.26,87.37 127.3,86.41 127.3,84.75 127.11,84.55 127.11,83.95 126.76,83.61 v1(126.73,83.61)
  BOTTOM w0.089: v1(125.26,108.44) 124.64,107.82 121.47,107.82 120.78,108.51 D6.2
  BOTTOM w0.1: v1(126.73,83.61) 126.43,83.31 UC1.G15
PBTN_OUT#: length 169.7
  TOP w0.089: UE1.122 36.7,71.81 37.89,73 42.61,73 43.35,72.26 45.15,72.26 45.26,72.15 45.53,72.15 v1(45.57,72.11)
  TOP w0.099: RC53.2 124.89,44.15 124.89,44.38 v1(125.28,44.78) ; v3(126.15,59.84) 126.31,59.84 126.85,59.29 v1(126.86,59.29)
  IN2 w0.089: 57.41,42.35 57.41,42.05 61.81,37.64 64.54,37.64 65.95,36.24 79,36.24 79.5,35.74 81.36,35.74 81.51,35.74 81.8,35.44 94.42,35.44 95.13,36.15 98.59,36.15 99,35.74 99.62,35.74 100.34,36.46 105.14,36.46 105.32,36.65 106.54,36.65 107.69,35.49 108.69,35.49 109.6,34.58 110.25,34.58 110.56,34.27 114.49,34.27 114.95,34.73 115.86,34.73 116.53,35.4 117.21,35.4 117.95,36.15 120.19,36.15 120.55,36.51 122.67,36.51 125.33,39.17 125.33,39.46 127.29,41.43 127.92,41.43 128,41.52 128,42.13 129.8,43.93 130.9,43.93 131.28,44.3 131.28,45.66 129.82,47.12 129.82,47.34 128.43,48.73 ; v1(45.57,72.11) 45.57,71.41 45.29,71.13 45.29,70.34 45.06,70.12 45.06,65.63 43.98,64.55 43.98,61.29 44.85,60.42 44.85,59.38 45.2,59.03 47.33,59.03 51.72,54.63 51.72,49.58 57.41,43.9 57.41,42.75
  IN2 w0.099: v1(126.86,59.29) 126.64,59.29 126.34,58.99 126.34,58.13 126.4,58.07 126.4,56.65 125.85,56.1 125.85,55.32 124.22,53.7 124.22,52.93 128.43,48.73
  IN2 w0.102: 57.41,42.35 57.41,42.75
  IN3 w0.089: 127.57,55.05 128.66,53.96 128.66,51.42 128.08,50.84 128.08,48.96 127.1,47.98 127.1,46.96 125.28,45.14 v1(125.28,44.78)
  IN3 w0.099: 127.57,55.05 127.22,55.39 127.22,58.73 126.86,59.1 v1(126.86,59.29)
  BOTTOM w0.1: v1(126.86,59.29) 126.45,59.71 UC1.AR15
PC_BEEP: length 4.1
  TOP w0.254: RA49.2 29.68,21.74 v3(30.53,21.74) 31.57,21.74 32.23,21.08 DA3.1
PC_BEEP_C: length 9.5
  TOP w0.089: CA47.1 32.17,18.17 v3(32.17,19.35) 32.17,20.77 31.51,21.42 30.31,21.42 30.02,21.13 RA49.1 RA45.2 27.75,20.33
  TOP w0.102: 27.75,20.33 CA57.2
PCH_PWR_EN: length 146.3
  TOP w0.089: UE1.107 38.25,77.81 v1(38.26,77.82)
  IN2 w0.089: v1(38.26,77.82) 38.39,77.69 38.39,77.31 38.52,77.19 38.52,73.53 36.89,71.91 36.4,71.42 36.4,69.71 35.25,68.56 35.25,62.19 36.46,60.99 36.46,58.07 40.3,54.22 40.3,52.73 41.7,51.34 41.7,50.43 41.91,50.21 42.44,50.21 43.52,49.13 43.52,38.65 48.35,33.82 51.95,33.82 52.44,33.33 54.88,33.33 57.4,30.81 57.4,29.12 58.17,28.36 v1(58.17,27.46)
  BOTTOM w0.089: v3(131.88,28.94) UC20.4 131.88,27.41 131.78,27.31 131.36,27.31 131.03,26.98 CC1193.1 130.34,26.98 129.51,26.16 125.51,26.16 124.02,24.66 101.73,24.66 100.78,23.71 61.47,23.71 58.17,27.01 v1(58.17,27.46)
PCIE_ARX_C_DTX_N4: length 4.6
  TOP w0.112: CL8.2 27.49,86.58 27.23,86.58 26.82,86.17 26.42,86.17 26.41,86.19 25.88,86.19 25.87,86.17 24.8,86.17 24.47,85.85 24.47,85.38 24.47,85.37 UL1.18
PCIE_ARX_C_DTX_P4: length 4.4
  TOP w0.112: UL1.17 24.87,85.39 24.69,85.56 24.69,85.76 24.89,85.95 v2(26.15,85.95) 26.91,85.95 27.32,86.36 27.59,86.36 27.77,86.18 CL7.2
PCIE_ARX_DTX_N0: length 165.7
  IN1 w0.119: v1(29.61,37.06) 29.35,37.33 29.35,37.93 31.43,40.01 35.13,40.01 35.75,40.62 37.41,40.62 37.65,40.38 38.51,40.38 38.75,40.14 41.44,40.14 42.33,39.26 49.5,39.26 50.4,38.36 54.59,38.36 55.1,37.86 56.25,37.86 56.64,37.46 57.75,37.46 59.93,35.28 60.79,35.28 61.15,34.92 63.33,34.92 63.75,34.5 71.28,34.5 72.06,33.71 72.07,33.71 73.05,32.73 96.27,32.73 96.32,32.78 104.34,32.78 104.73,32.39 105.97,32.39 106.04,32.32 106.34,32.01 108.17,32.01 108.34,32.19 116.02,32.19 116.79,32.96 120.09,32.96 120.91,33.78 121.99,33.78 122.81,34.6 123.24,34.6 123.96,35.31 124.46,35.31 131.99,42.85 132.65,42.85 137.51,47.71 137.51,53.38 136.94,53.95 136.94,54.76 136.59,55.11 136.59,57.94 139.22,60.58 139.5,60.58 140.91,61.98 140.91,63.85 141.25,64.19 141.25,66.21 140.38,67.08 139.92,67.08 139.6,67.4 138.94,67.4 138.37,67.4 135.79,69.98 135.79,74.56 135.58,74.77 135.58,76.58 135.83,76.84 135.83,77.67 135.89,77.73 135.89,78.53 135.45,78.96 134.4,78.96 133.97,78.53 132.12,78.53 132,78.65 v1(132,78.79)
  BOTTOM w0.1: UC1.N9 131.63,78.57 131.85,78.79 v1(132,78.79)
  BOTTOM w0.112: v1(29.61,37.06) 29.43,36.88 29.43,35.81 29.1,35.48 29.1,35.19 29.21,35.08 29.3,35.08 29.38,35.01 JSSD1.41
PCIE_ARX_DTX_N1: length 169
  IN1 w0.119: v1(32.78,37.61) 32.62,37.77 32.62,38.64 32.81,38.83 37.96,38.83 38.14,38.65 40.82,38.65 41.71,37.77 45.9,37.77 46.51,37.16 47.88,37.16 48.17,36.87 53.98,36.87 54.48,36.37 55.63,36.37 56.03,35.97 57.13,35.97 59.31,33.79 60.17,33.79 60.53,33.43 62.71,33.43 63.6,32.54 71.13,32.54 71.23,32.44 72.84,30.83 103.67,30.83 103.98,30.53 108.79,30.53 108.96,30.7 116.64,30.7 117.07,31.13 120.37,31.13 121.06,31.82 122.57,31.82 124.28,33.53 124.79,33.53 126.71,35.46 128.2,35.46 133.39,40.64 133.78,41.49 133.9,41.78 133.91,41.8 134.09,42.18 139,47.09 139,54.43 139.18,54.61 139.18,55.3 138.92,55.56 138.92,58.16 139.84,59.09 140.12,59.09 140.39,59.36 141.06,59.36 142.73,61.03 142.73,66.95 140.87,68.81 140.58,68.81 139.52,69.87 138.44,69.87 137.56,70.74 137.56,71.81 137.68,71.93 137.68,73.6 137.31,73.98 137.31,75.14 137.07,75.39 137.07,75.97 137.32,76.22 137.32,76.69 138.12,77.49 138.12,79.93 137.09,80.96 134.36,80.96 133.86,80.47 132.6,80.47 132.59,80.48 131.78,80.48 v1(131.42,80.84)
  BOTTOM w0.089: UC1.L9 131.63,80.63 v1(131.42,80.84)
  BOTTOM w0.112: v1(32.78,37.61) 32.61,37.44 32.61,35.58 32.24,35.2 32.24,34.94 32.38,34.8 JSSD1.29
PCIE_ARX_DTX_N2: length 164.3
  IN1 w0.119: v1(130.02,80.26) 130.02,79.96 130.2,79.78 130.2,79.64 130.49,79.34 130.83,79.34 130.87,79.39 131.06,79.39 131.52,79.42 132.63,79.42 132.63,79.42 132.98,79.42 132.98,79.42 133.4,79.42 133.41,79.42 133.75,79.42 134.05,79.71 135.78,79.71 136.84,78.65 136.84,77.49 136.58,77.23 136.58,76.53 136.32,76.28 136.32,75.08 136.55,74.86 136.55,70.68 138.22,69.01 139.33,69.01 140.27,68.07 140.56,68.07 141.99,66.64 141.99,63.88 141.65,63.54 141.65,61.71 141.62,61.68 141.62,61.64 139.81,59.83 139.53,59.83 138.17,58.47 138.17,54.24 138.25,54.16 138.25,47.4 133.2,42.34 132.98,41.87 129.96,38.84 129.05,38.84 124.48,34.28 123.98,34.28 122.7,33 121.18,33 120.06,31.87 116.76,31.87 116.33,31.44 108.65,31.44 108.48,31.27 106.04,31.27 105.73,31.58 73.15,31.58 70.97,33.75 63.44,33.75 63.02,34.18 60.84,34.18 60.48,34.53 59.62,34.53 57.44,36.71 56.34,36.71 55.94,37.11 54.79,37.11 54.29,37.61 48.48,37.61 48.18,37.9 46.91,37.9 46.31,38.51 42.02,38.51 41.13,39.4 38.44,39.4 38.2,39.64 37.34,39.64 37.1,39.88 36.25,39.88 36.11,39.74 v1(36.11,39.46)
  BOTTOM w0.089: UC1.M11 130.03,80.25 v1(130.02,80.26)
  BOTTOM w0.112: JSSD1.17 35.38,34.61 35.31,34.67 35.31,35.01 35,35.32 35,36.77 35.4,37.17 35.4,38.14 36.11,38.85 36.11,39.46 v1(36.11,39.46)
PCIE_ARX_DTX_N3: length 157.9
  IN1 w0.119: v1(39.82,40.78) 39.67,40.93 39.67,41.15 39.79,41.27 41.36,41.27 42.64,40 54,40 55.41,38.6 56.56,38.6 56.95,38.2 58.06,38.2 60.24,36.02 61.1,36.02 61.46,35.66 63.64,35.66 64.06,35.24 71.59,35.24 72.09,34.74 73.36,33.47 95.49,33.47 95.54,33.53 104.35,33.53 104.87,34.04 106.98,34.04 107.31,33.71 109.12,33.71 109.46,33.37 115.74,33.37 116.36,34 119.66,34 120.48,34.82 120.88,34.82 122.73,36.66 124.26,36.66 127.03,39.43 127.03,39.63 128.26,40.86 128.26,42.43 128.99,43.16 131.24,43.16 133.26,45.17 133.88,45.17 136.77,48.06 136.77,51.88 136.38,52.27 136.38,53.01 135.66,53.73 135.66,54.71 135.83,54.88 135.83,58.31 136.61,59.09 136.61,61.27 136.8,61.46 138.78,61.46 140.17,62.85 140.17,64.21 140.5,64.54 140.5,65.9 140.07,66.34 139.51,66.34 139.25,66.59 138.12,66.59 134.79,69.92 134.79,76.82 134.17,77.44 131,77.44 130.91,77.36 130.2,77.36 130.13,77.43 130.13,77.65 130.24,77.77 v1(130.45,77.77)
  BOTTOM w0.089: v1(130.45,77.77) 130.42,77.75 130.42,77.74 130.03,77.35 UC1.P11
  BOTTOM w0.112: JSSD1.5 38.38,34.84 38.27,34.95 38.27,36.6 39.66,37.99 39.66,40.62 v1(39.82,40.78)
PCIE_ARX_DTX_N4: length 234.6
  TOP w0.112: CL8.1 29.03,86.52 29.14,86.52 v1(29.33,86.71)
  IN3 w0.099: v1(132.76,73.73) 132.95,73.73 133.26,73.41 133.38,73.41 133.61,73.18 134.84,73.18 135.59,72.44 135.59,67.35 135.93,67.01 135.93,66.99 135.96,66.95 135.96,66.91 136.14,66.73
  IN3 w0.135: v1(29.33,86.71) 29.49,86.56 29.81,86.56 30.23,86.14 30.23,83.99 31.24,82.98 31.24,74.29 31.17,74.23 31.17,71.98 31.59,71.56 31.59,67.56 32.1,67.05 32.1,63.27 30,61.17 30,57.92 29.84,57.76 29.84,51.85 30.2,51.49 30.94,51.49 31.4,51.02 31.4,49.91 30.94,49.45 30.94,46.94 31.3,46.58 31.3,43.04 29.59,41.33 29.53,41.33 28.98,40.78 23.69,40.78 22.97,40.06 22.97,36.3 25.3,33.97 30.44,33.97 31.5,35.03 36.2,35.03 37.55,36.38 38.03,36.38 38.88,37.24 44.71,37.24 45.27,36.68 54.74,36.68 59.5,31.91 62,31.91 66.23,27.69 83.42,27.69 83.65,27.46 98.69,27.46 99.07,27.07 110.38,27.07 110.92,27.61 111.6,27.61 112.14,27.07 130.43,27.07 140.61,37.24 141.36,38.65 141.36,41.87 139.11,44.12 139.11,47.45 139.4,47.75 139.4,53.82 138.98,54.24 138.98,55.26 138.67,55.57 138.67,57.84 139.27,58.43 139.27,59.41 139.43,59.57 139.43,60.67 139.73,60.97 139.73,61.48 139.21,62 139.21,63.8 138.88,64.13 136.86,64.13 136.27,64.73 136.27,66.61 136.14,66.73
  BOTTOM w0.089: v1(132.76,73.73) 133.23,74.2 UC1.V7
PCIE_ARX_DTX_N5: length 111.7
  IN3 w0.099: v1(131.3,74.75) 131.48,74.93 131.48,75.11 131.39,75.21 129.23,75.21 128.94,75.5 128.94,76.07 128.84,76.16 128.84,77.9 128.12,78.63 128.12,84.55 128.65,85.08 128.65,85.68 128.42,85.91 128.39,85.91 128.37,85.93
  IN3 w0.135: 128.37,85.93 128.03,86.27 128.03,87.43 128.34,87.74 128.34,88.86 129.13,89.64 129.13,107.4 128.99,107.54 127.23,107.54 126.02,106.32 120.92,106.32 119.49,104.89 106.5,104.89 100.51,110.88 97.13,110.88 96.18,111.83 96.18,113.3 93.96,115.52 91.72,115.52 91.54,115.34 87.34,115.34 83.08,119.6 77.89,119.6 75.92,121.57 75.92,122.75 v1(75.8,122.87)
  BOTTOM w0.102: UC1.T9 131.3,74.98 v1(131.3,74.75)
  BOTTOM w0.112: v1(75.8,122.87) 75.95,123.01 75.95,123.17 75.52,123.6 75.52,125.33 75.81,125.62 75.81,127.68 76.22,128.09 76.22,130.1 77.33,131.21 78.17,131.21 78.23,131.15 JWLAN1.43
PCIE_ARX_DTX_P0: length 165.7
  IN1 w0.119: v1(131.23,78.7) 131.62,78.31 134.06,78.31 134.49,78.75 135.36,78.75 135.67,78.44 135.67,77.82 135.61,77.77 135.61,76.93 135.36,76.67 135.36,74.68 135.57,74.47 135.57,69.89 138.28,67.18 139.03,67.18 139.51,67.18 139.82,66.86 140.29,66.86 141.03,66.12 141.03,64.28 140.69,63.94 140.69,62.07 139.41,60.79 139.13,60.79 136.37,58.03 136.37,55.02 136.72,54.67 136.72,53.86 137.29,53.29 137.29,47.8 132.56,43.06 131.9,43.06 124.37,35.53 123.87,35.53 123.15,34.81 122.72,34.81 121.9,34 120.82,34 120,33.18 116.7,33.18 115.93,32.4 108.25,32.4 108.08,32.23 106.43,32.23 106.13,32.54 106.13,32.54 106.06,32.61 104.82,32.61 104.43,33 96.23,33 96.18,32.95 73.14,32.95 72.16,33.93 71.37,34.71 63.84,34.71 63.42,35.14 61.24,35.14 60.88,35.5 60.02,35.5 57.84,37.68 56.74,37.68 56.34,38.07 55.19,38.07 54.69,38.58 50.49,38.58 49.59,39.47 42.42,39.47 41.53,40.36 38.84,40.36 38.6,40.6 37.74,40.6 37.5,40.84 35.66,40.84 35.04,40.23 31.34,40.23 29.13,38.02 29.13,37.17 v1(29.03,37.06)
  BOTTOM w0.089: v1(131.23,78.7) UC1.N10
  BOTTOM w0.112: JSSD1.43 28.87,35.57 29.21,35.91 29.21,36.88 v1(29.03,37.06)
PCIE_ARX_DTX_P1: length 169
  IN1 w0.119: v1(32.2,37.61) 32.4,37.81 32.4,38.73 32.72,39.05 38.05,39.05 38.23,38.87 40.92,38.87 41.8,37.99 45.99,37.99 46.6,37.38 47.97,37.38 48.26,37.09 54.07,37.09 54.57,36.59 55.72,36.59 56.12,36.19 57.22,36.19 59.4,34.01 60.26,34.01 60.62,33.65 62.8,33.65 63.69,32.76 71.22,32.76 71.32,32.66 72.93,31.05 103.76,31.05 104.07,30.74 108.69,30.74 108.87,30.92 116.55,30.92 116.98,31.35 120.28,31.35 120.97,32.04 122.48,32.04 124.19,33.75 124.7,33.75 126.62,35.67 128.11,35.67 133.21,40.77 133.58,41.58 133.71,41.88 133.72,41.91 133.91,42.31 138.78,47.18 138.78,54.52 138.96,54.7 138.96,55.21 138.7,55.47 138.7,58.26 139.75,59.31 140.03,59.31 140.3,59.58 140.97,59.58 142.52,61.12 142.52,66.86 140.78,68.59 140.49,68.59 139.43,69.65 138.34,69.65 137.34,70.65 137.34,71.9 137.47,72.02 137.47,73.51 137.09,73.89 137.09,75.05 136.85,75.3 136.85,76.06 137.1,76.31 137.1,76.78 137.9,77.58 137.9,79.84 137,80.74 134.45,80.74 133.96,80.25 132.51,80.25 132.5,80.26 131.61,80.26 131.57,80.29 131.37,80.29 131.25,80.17 v1(131.25,79.92)
  BOTTOM w0.089: v1(131.25,79.92) 131.23,79.92 130.84,80.31 UC1.L10
  BOTTOM w0.112: v1(32.2,37.61) 32.39,37.41 32.39,35.67 32.01,35.29 32.01,34.86 31.87,34.72 JSSD1.31
PCIE_ARX_DTX_P2: length 164.2
  IN1 w0.119: v1(129.63,79.71) 129.68,79.76 129.86,79.76 129.98,79.64 129.98,79.55 130.4,79.13 130.92,79.13 130.96,79.17 131.07,79.17 131.53,79.2 132.54,79.2 132.54,79.2 133.07,79.2 133.07,79.2 133.31,79.2 133.32,79.2 133.84,79.2 134.14,79.49 135.69,79.49 136.62,78.56 136.62,77.58 136.36,77.32 136.36,76.62 136.1,76.37 136.1,74.99 136.33,74.76 136.33,70.59 138.13,68.79 139.24,68.79 140.18,67.85 140.47,67.85 141.77,66.55 141.77,63.97 141.44,63.63 141.44,61.8 141.4,61.77 141.4,61.73 139.72,60.05 139.44,60.05 137.96,58.56 137.96,54.15 138.04,54.07 138.04,47.49 133.02,42.47 132.8,42 129.86,39.06 128.96,39.06 124.39,34.49 123.89,34.49 122.61,33.22 121.09,33.22 119.97,32.09 116.67,32.09 116.24,31.66 108.56,31.66 108.39,31.49 106.13,31.49 105.82,31.8 73.24,31.8 71.06,33.97 63.53,33.97 63.11,34.39 60.93,34.39 60.57,34.75 59.71,34.75 57.53,36.93 56.43,36.93 56.03,37.33 54.88,37.33 54.38,37.83 48.57,37.83 48.28,38.12 47.01,38.12 46.4,38.73 42.11,38.73 41.22,39.62 38.53,39.62 38.29,39.86 37.43,39.86 37.19,40.1 36.16,40.1 35.79,39.73 35.79,39.73 v1(35.53,39.46)
  BOTTOM w0.089: UC1.L12 129.54,80.11 129.69,79.96 129.69,79.77 v1(129.63,79.71)
  BOTTOM w0.112: v1(35.53,39.46) 35.89,39.1 35.89,38.95 35.18,38.23 35.18,37.26 34.78,36.86 34.78,35.23 35.09,34.92 35.09,34.82 34.87,34.61 JSSD1.19
PCIE_ARX_DTX_P3: length 157.8
  IN1 w0.119: v1(129.63,77.81) 129.69,77.81 129.91,77.59 129.91,77.34 130.1,77.14 131,77.14 131.09,77.23 134.08,77.23 134.57,76.73 134.57,69.83 138.03,66.38 139.16,66.38 139.42,66.12 139.98,66.12 140.28,65.81 140.28,64.63 139.95,64.3 139.95,63.02 138.64,61.72 136.75,61.72 136.39,61.36 136.39,59.18 135.62,58.4 135.62,54.97 135.44,54.8 135.44,53.64 136.16,52.92 136.16,52.18 136.55,51.79 136.55,48.15 133.79,45.39 133.17,45.39 131.15,43.38 128.9,43.38 128.05,42.52 128.05,40.95 126.82,39.72 126.82,39.52 124.17,36.88 122.64,36.88 120.79,35.03 120.39,35.03 119.57,34.22 116.27,34.22 115.65,33.59 109.55,33.59 109.21,33.92 107.4,33.92 107.07,34.26 104.77,34.26 104.26,33.75 95.45,33.75 95.4,33.69 73.45,33.69 72.18,34.96 71.68,35.46 64.15,35.46 63.73,35.88 61.55,35.88 61.19,36.24 60.33,36.24 58.15,38.42 57.04,38.42 56.65,38.82 55.5,38.82 54.1,40.22 42.73,40.22 41.45,41.49 39.7,41.49 39.45,41.25 39.45,40.99 v1(39.23,40.78)
  BOTTOM w0.089: v1(129.63,77.81) 129.23,77.41 UC1.P12
  BOTTOM w0.112: JSSD1.7 37.87,34.85 38.05,35.03 38.05,36.69 39.44,38.08 39.44,40.57 v1(39.23,40.78)
PCIE_ARX_DTX_P4: length 234.7
  TOP w0.112: v1(29.33,86.13) 29.17,86.3 29.01,86.3 CL7.1
  IN3 w0.099: 136.14,67.08 135.78,67.44 135.78,72.52 134.92,73.38 133.7,73.38 133.43,73.65 v1(133.43,73.8)
  IN3 w0.135: 136.14,67.08 136.51,66.71 136.51,64.83 136.96,64.37 138.98,64.37 139.45,63.9 139.45,62.1 139.97,61.58 139.97,60.87 139.67,60.57 139.67,59.47 139.51,59.31 139.51,58.33 138.91,57.74 138.91,55.67 139.23,55.36 139.23,54.34 139.65,53.92 139.65,47.65 139.35,47.35 139.35,44.22 141.6,41.97 141.6,38.59 140.8,37.09 130.53,26.82 112.04,26.82 111.5,27.36 111.02,27.36 110.48,26.82 98.97,26.82 98.59,27.21 83.55,27.21 83.32,27.45 66.13,27.45 61.9,31.67 59.4,31.67 54.64,36.44 45.17,36.44 44.61,37 38.98,37 38.13,36.14 37.65,36.14 36.3,34.79 31.6,34.79 30.54,33.73 25.2,33.73 22.73,36.2 22.73,40.16 23.59,41.02 28.88,41.02 29.43,41.57 29.49,41.57 31.06,43.14 31.06,46.48 30.7,46.84 30.7,49.55 31.16,50.01 31.16,50.92 30.84,51.25 30.1,51.25 29.6,51.75 29.6,57.86 29.76,58.02 29.76,61.27 31.86,63.37 31.86,66.95 31.35,67.46 31.35,71.46 30.93,71.88 30.93,74.33 31,74.39 31,82.88 29.99,83.89 29.99,86.04 29.71,86.32 29.53,86.32 v1(29.33,86.13)
  BOTTOM w0.089: v1(133.43,73.8) UC1.V6
PCIE_ARX_DTX_P5: length 111.7
  IN3 w0.099: v1(132.03,74.75) 131.84,74.75 131.68,74.91 131.68,75.19 131.47,75.41 129.31,75.41 129.14,75.58 129.14,76.15 129.04,76.25 129.04,77.99 128.32,78.71 128.32,84.46 128.85,85 128.85,85.76 128.56,86.05 128.56,86.08 128.54,86.1
  IN3 w0.135: v1(76.38,122.87) 76.16,122.64 76.16,121.67 77.99,119.85 83.18,119.85 87.44,115.58 91.44,115.58 91.62,115.76 94.06,115.76 96.42,113.4 96.42,111.93 97.23,111.12 100.61,111.12 106.6,105.13 119.39,105.13 120.82,106.57 125.92,106.57 127.13,107.78 129.09,107.78 129.37,107.5 129.37,89.54 128.59,88.76 128.59,87.64 128.27,87.33 128.27,86.37 128.54,86.1
  BOTTOM w0.089: UC1.T8 132.43,75.17 132.03,74.76 v1(132.03,74.75)
  BOTTOM w0.112: v1(76.38,122.87) 76.17,123.08 76.17,123.26 75.74,123.69 75.74,125.23 76.03,125.53 76.03,127.59 76.44,128 76.44,130.01 77.42,130.99 78.08,130.99 78.42,130.65 JWLAN1.41
PCIE_ATX_C_DRX_N0: length 2.4
  BOTTOM w0.112: CS46.2 27.92,35.75 27.92,35.44 27.74,35.25 27.74,35.09 27.88,34.95 27.87,34.95 JSSD1.47
PCIE_ATX_C_DRX_N1: length 2.3
  BOTTOM w0.112: CS45.2 30.85,35.75 30.85,35.41 30.74,35.3 30.74,35.09 30.88,34.95 30.87,34.95 JSSD1.35
PCIE_ATX_C_DRX_N2: length 2.4
  BOTTOM w0.112: CS48.2 33.94,35.8 33.94,35.49 33.74,35.28 33.74,34.82 33.88,34.68 33.87,34.68 JSSD1.23
PCIE_ATX_C_DRX_N3: length 2.3
  BOTTOM w0.112: JSSD1.11 36.87,34.72 36.81,34.78 36.81,34.96 36.82,34.97 36.82,35.4 36.73,35.49 36.73,35.66 36.82,35.76 CS51.2
PCIE_ATX_C_DRX_N4: length 2.5
  TOP w0.112: UL1.14 26.01,83.53 26.09,83.45 26.9,83.45 27.19,83.74 27.44,83.74 CC2.2
PCIE_ATX_C_DRX_N5: length 14.7
  BOTTOM w0.112: JWLAN1.37 78.32,129.65 78.24,129.57 77.33,129.57 76.96,129.21 76.96,127.76 76.69,127.49 76.69,126.75 76.86,126.58 76.86,125.62 76.29,125.05 76.29,123.87 76.79,123.37 76.79,122.19 76.5,121.9 76.5,118.79 76.87,118.42 CC4.2
PCIE_ATX_C_DRX_P0: length 2.4
  BOTTOM w0.112: JSSD1.49 27.38,34.95 27.51,35.09 27.51,35.34 27.7,35.53 27.7,35.75 CS44.2
PCIE_ATX_C_DRX_P1: length 2.3
  BOTTOM w0.112: JSSD1.37 30.38,34.95 30.51,35.09 30.51,35.39 30.63,35.5 30.63,35.75 CS47.2
PCIE_ATX_C_DRX_P2: length 2.4
  BOTTOM w0.112: CS49.2 33.72,35.7 33.72,35.58 33.51,35.38 33.51,34.81 33.38,34.67 JSSD1.25
PCIE_ATX_C_DRX_P3: length 2.3
  BOTTOM w0.112: CS50.2 36.51,35.71 36.51,35.4 36.6,35.31 36.6,35.07 36.59,35.05 36.59,34.85 36.38,34.63 JSSD1.13
PCIE_ATX_C_DRX_P4: length 2.5
  TOP w0.112: CC1.2 27.44,83.51 27.28,83.51 26.99,83.23 v2(26.7,83.23) 26.05,83.23 25.95,83.13 UL1.13
PCIE_ATX_C_DRX_P5: length 14.7
  BOTTOM w0.112: CC3.2 77.31,118.12 77.2,118.12 77.09,118.23 77.09,118.51 76.72,118.88 76.72,121.81 77.01,122.1 77.01,123.46 76.51,123.96 76.51,124.96 77.08,125.53 77.08,126.67 76.91,126.84 76.91,127.39 77.18,127.66 77.18,129.12 77.42,129.35 78.24,129.35 78.45,129.15 JWLAN1.35
PCIE_ATX_DRX_N0: length 182.6
  IN1 w0.119: v1(145.97,77.53) 146.23,77.26 146.23,75.68 146.18,75.63 146.18,72.38 146.49,72.06 146.49,66.9 146.36,66.77 146.36,61.3 146.04,60.98 146.04,60.27 145.2,59.43 145.2,59.14 142.31,56.25 142.31,53.54 141.76,52.98 141.76,45.23 142.25,44.74 142.56,44.43 142.56,43.05 142.13,42.62 142.13,38.32 141.58,37.24 141.47,37.11 139.32,34.96 132.46,34.96 132.18,34.69 131.34,34.69 130.65,34 130.65,32.93 129.03,31.3 128.36,31.3 124.18,27.12 112.12,27.12 111.7,27.54 110.62,27.54 110.34,27.26 100.23,27.26 99.17,26.2 63.05,26.2 59.1,30.16 59.04,30.16 56.16,33.04 55.05,33.04 54.49,33.61 52.66,33.61 52.25,34.02 46.84,34.02 46.52,34.35 40.84,34.35 40.77,34.28 34.63,34.28 33.19,35.72 28.96,35.72 27.74,36.94 27.74,37.27 28.11,37.63 v1(28.11,37.65)
  BOTTOM w0.1: UC1.P3 136.12,77.31 136.43,77.62 136.86,77.62 137.42,78.17 137.92,78.17 138.25,78.5 138.85,78.5 140.43,80.07 142.3,80.07 142.3,80.07
  BOTTOM w0.112: v1(28.11,37.65) 27.83,37.38 27.83,37.2 28.01,37.03 CS46.1 ; 142.3,80.07 145.09,80.07 146.16,79 146.16,77.71 v1(145.97,77.53)
PCIE_ATX_DRX_N1: length 176.8
  IN1 w0.119: v1(144.8,77.52) 144.8,77.38 144.92,77.26 145.02,77.26 145.17,77.12 145.17,76.56 145.28,76.45 145.28,73.91 145.43,73.76 145.43,72.04 145.49,71.98 145.49,67.59 145.12,67.22 145.12,60.57 144.11,59.56 144.11,59.11 141.57,56.56 141.57,53.84 141.01,53.29 141.01,44.92 141.81,44.12 141.81,43.35 141.39,42.93 141.39,38.5 141.03,37.81 140.49,37.19 139.01,35.71 135.95,35.71 135.58,36.08 134.38,36.08 134.08,35.79 132.08,35.79 131.73,35.43 131.03,35.43 129.91,34.31 129.91,33.95 125.66,29.7 121.79,29.7 121.2,29.12 117.94,29.12 116.69,27.86 112.43,27.86 112.01,28.28 110.31,28.28 110.03,28.01 99.66,28.01 97.63,28.01 96.57,26.94 63.58,26.94 59.67,30.86 59.39,30.86 56.9,33.35 56.46,33.79 55.36,33.79 54.79,34.35 53.64,34.35 53.23,34.77 47.15,34.77 46.82,35.09 40.53,35.09 40.46,35.03 38.04,35.03 36.65,36.42 34.61,36.42 34.54,36.48 31.17,36.48 30.68,36.97 30.68,37.36 31.05,37.73 v1(31.05,37.73)
  BOTTOM w0.1: 139.21,77.95 138.52,77.95 137.6,77.02 137.37,77.02 137.18,76.84 136.74,76.84 136.71,76.81 136.61,76.81 136.19,76.4 136.05,76.4 135.84,76.61 135.84,76.75 135.94,76.85 136.09,76.85 UC1.P2
  BOTTOM w0.112: 139.21,77.95 139.33,77.95 140.69,79.31 143.83,79.31 144.68,78.45 144.68,78.37 145.06,77.99 145.06,77.78 v1(144.8,77.52) ; CS45.1 31.17,36.99 30.85,36.99 30.74,37.1 30.74,37.42 v1(31.05,37.73)
PCIE_ATX_DRX_N2: length 171.2
  IN1 w0.119: v1(144.22,77.46) 144.22,77.46 143.86,77.09 143.86,76.8 144.75,75.9 144.75,73.67 144.91,73.52 144.91,71.8 144.58,71.48 144.58,68.99 144.41,68.82 144.41,66.67 144.58,66.5 144.58,60.77 143.57,59.76 142.57,58.76 142.57,58.45 141.04,56.93 141.04,54.06 140.49,53.51 140.49,46.03 139.28,44.82 139.28,42.87 140.78,41.36 140.78,38.82 140.18,37.63 140.1,37.55 138.79,36.23 136.17,36.23 135.8,36.61 131.46,36.61 129.38,34.53 129.38,34.17 125.44,30.23 121.57,30.23 120.99,29.64 117.73,29.64 116.47,28.39 113.42,28.39 113,28.81 110.09,28.81 109.81,28.53 99.88,28.53 99.88,28.53 97.42,28.53 97.11,28.22 96.36,27.47 64.18,27.47 61.86,29.8 61.86,30.88 61.25,31.49 59.5,31.49 56.68,34.31 55.58,34.31 55.01,34.88 53.86,34.88 53.36,35.38 47.55,35.38 47.26,35.67 45.8,35.67 45.19,36.28 37.6,36.28 36.91,36.97 35.9,36.97 34.79,38.08 34.02,38.08 33.9,37.96 33.9,37.81 v1(34.04,37.66)
  BOTTOM w0.1: UC1.R1 136.85,76.63 137.24,76.63 137.44,76.84 137.67,76.84 138.57,77.73 139.87,77.73
  BOTTOM w0.112: v1(144.22,77.46) 143.94,77.75 143.94,78.35 143.54,78.75 140.88,78.75 139.87,77.73 ; v1(34.04,37.66) 33.8,37.42 33.8,37.16 33.93,37.03 CS48.1
PCIE_ATX_DRX_N3: length 156.9
  IN1 w0.119: v1(36.91,37.62) 36.68,37.85 36.68,37.97 36.8,38.09 37.65,38.09 37.83,37.91 40.52,37.91 41.4,37.02 45.5,37.02 46.11,36.42 47.57,36.42 47.86,36.12 53.67,36.12 54.17,35.62 55.32,35.62 55.72,35.23 56.82,35.23 59.81,32.24 62.52,32.24 62.96,31.8 70.82,31.8 72.62,30 103.45,30 103.78,29.68 108.99,29.68 109.27,29.95 116.95,29.95 117.38,30.39 120.68,30.39 121.26,30.97 122.77,30.97 124.59,32.79 126.75,32.79 128.64,34.68 128.64,34.84 134.13,40.34 134.13,40.48 134.46,41.19 134.56,41.42 134.6,41.48 134.73,41.76 134.74,41.77 137.05,44.09 137.49,44.09 139.74,46.34 139.74,53.82 140.3,54.37 140.3,57.24 141.82,58.76 141.82,59.07 143.84,61.08 143.84,66.19 143.67,66.36 143.67,69.13 143.84,69.3 143.84,71.33 143.74,71.43 143.74,73.63 142.84,74.53 142.84,77.32 v1(142.98,77.46)
  BOTTOM w0.089: UC1.T2 136.15,75.82 136.3,75.82 136.31,75.81 136.72,75.81 137.15,76.24 137.39,76.24 137.6,76.45 137.83,76.45 138.54,77.16 140.05,77.16 140.86,77.97 142.31,77.97
  BOTTOM w0.112: 142.31,77.97 142.48,77.97 142.68,77.76 142.68,77.76 142.98,77.46 v1(142.98,77.46) ; CS51.1 36.91,36.97 36.66,37.22 36.66,37.38 36.9,37.62 v1(36.91,37.62)
PCIE_ATX_DRX_N4: length 232.3
  TOP w0.112: v1(29.41,83.92) 29.36,83.87 28.89,83.87 CC2.1
  IN3 w0.135: v1(29.41,83.92) 28.62,83.92 28.34,83.64 28.34,82.82 30.15,81.02 30.15,70.34 30.31,70.18 30.31,66.73 30.91,66.13 30.91,63.53 28.97,61.59 28.97,58.35 28.81,58.19 28.81,51.39 29.92,50.29 29.92,43.11 29.16,42.35 29.11,42.35 28.6,41.84 23.3,41.84 21.95,40.49 21.95,35.88 24.88,32.95 30.86,32.95 31.93,34.01 36.63,34.01 37.98,35.36 38.45,35.36 39.23,36.14 44.07,36.14 44.55,35.66 54.31,35.66 59.08,30.89 61.58,30.89 63.93,28.54 63.93,27.83 65.09,26.66 83,26.66 83.23,26.43 97.08,26.43 97.49,26.03 101.16,26.03 101.18,26.04 132.37,26.04 138.91,32.58 138.91,34.09 141.44,36.62 142.35,38.33 142.38,38.47 142.38,42.3 140.18,44.49 140.18,47.07 140.43,47.32 140.43,56.93 140.74,57.24 140.74,59.29 140.54,59.49 140.54,60.33 140.85,60.64 140.85,65.14 139.83,66.16 138.63,66.16 136.57,68.22 136.57,71.15 136.55,71.17 136.55,71.76 136.97,72.17 v1(137.03,72.17)
  BOTTOM w0.102: v1(137.03,72.17) 137.03,72.22 136.65,72.6 136.37,72.6 136.2,72.51 136.01,72.51 UC1.W4
PCIE_ATX_DRX_N5: length 97
  IN1 w0.119: v1(83.49,116.55) 83.32,116.38 83.32,116.15 83.44,116.03 84.69,116.03 86.45,114.28 97.62,114.28 98.66,113.24 102.64,113.24 107.86,108.01 115.69,108.01 115.87,108.01 116.34,108.01 119.48,104.87 121.02,101.01 123.45,98.58 129.61,98.58 134.8,93.39 135.8,93.39 139.74,89.45 139.74,82.52 138.86,81.64 138.86,77.18 138.07,76.38 138.07,74.28 138.24,74.1 138.43,73.91 138.43,73.65 v1(138.63,73.46)
  BOTTOM w0.102: v1(138.63,73.46) 138.63,73.43 138.34,73.15 138.09,73.15 137.23,74.01 136.91,74.01 136.71,73.8 136.33,73.8 136.32,73.81 UC1.V2
  BOTTOM w0.112: v1(83.49,116.55) 83.33,116.39 83.32,116.39 83.32,116.38 83.29,116.35 83.29,115.81 82.85,115.37 78.31,115.37 76.92,116.76 CC4.1
PCIE_ATX_DRX_P0: length 182.6
  IN1 w0.119: v1(27.52,37.65) 27.52,36.85 28.87,35.5 33.1,35.5 34.54,34.06 40.86,34.06 40.93,34.13 46.43,34.13 46.75,33.8 52.16,33.8 52.57,33.39 54.4,33.39 54.96,32.82 56.06,32.82 58.95,29.94 59.01,29.94 62.96,25.98 99.26,25.98 100.32,27.04 110.43,27.04 110.71,27.32 111.61,27.32 112.03,26.9 124.27,26.9 128.45,31.09 129.12,31.09 130.87,32.84 130.87,33.91 131.43,34.47 132.27,34.47 132.55,34.75 139.41,34.75 141.63,36.96 141.76,37.12 142.35,38.27 142.35,42.53 142.78,42.96 142.78,44.52 141.98,45.32 141.98,52.89 142.53,53.45 142.53,56.16 145.41,59.05 145.41,59.34 146.26,60.18 146.26,60.89 146.57,61.21 146.57,66.68 146.71,66.81 146.71,72.15 146.39,72.47 146.39,75.54 146.45,75.59 146.45,77.42 v1(146.56,77.53)
  BOTTOM w0.1: UC1.N2 136.14,77.82 136.78,77.82 137.33,78.37 137.84,78.37 138.17,78.7 138.77,78.7 140.35,80.27 142.22,80.27 142.22,80.28 142.28,80.28 142.28,80.28 142.3,80.28
  BOTTOM w0.112: v1(27.52,37.65) 27.61,37.56 27.61,37.3 CS44.1 ; 142.3,80.28 142.31,80.28 142.32,80.29 145.18,80.29 146.38,79.09 146.38,77.7 v1(146.56,77.53)
PCIE_ATX_DRX_P1: length 176.9
  IN1 w0.119: v1(145.39,77.52) 145.39,76.65 145.5,76.54 145.5,74 145.65,73.85 145.65,72.13 145.71,72.07 145.71,67.5 145.34,67.13 145.34,60.48 144.33,59.47 144.33,59.02 141.79,56.47 141.79,53.75 141.23,53.2 141.23,45.01 142.03,44.21 142.03,43.26 141.6,42.84 141.6,38.45 141.22,37.69 140.65,37.04 139.1,35.49 135.86,35.49 135.49,35.86 134.47,35.86 134.17,35.57 132.17,35.57 131.82,35.21 131.12,35.21 130.12,34.22 130.12,33.86 125.75,29.48 121.88,29.48 121.3,28.9 118.03,28.9 116.78,27.64 112.34,27.64 111.92,28.06 110.4,28.06 110.12,27.79 99.57,27.79 97.72,27.79 96.66,26.73 63.49,26.73 59.58,30.64 59.3,30.64 56.81,33.13 56.37,33.57 55.27,33.57 54.7,34.13 53.55,34.13 53.14,34.55 47.06,34.55 46.73,34.87 40.62,34.87 40.55,34.81 37.95,34.81 36.56,36.2 34.52,36.2 34.45,36.26 31.08,36.26 30.46,36.88 v1(30.46,37.73)
  BOTTOM w0.1: 139.21,78.16 139.19,78.16 139.19,78.15 139.13,78.15 139.12,78.15 138.44,78.15 137.51,77.22 137.28,77.22 137.1,77.04 136.65,77.04 136.63,77.02 136.4,77.02 136.31,77.11 136.01,77.11 UC1.P4
  BOTTOM w0.112: CS47.1 30.51,37.28 30.51,37.68 v1(30.46,37.73) ; 139.21,78.16 139.24,78.16 140.61,79.53 143.92,79.53 144.9,78.55 144.9,78.46 145.28,78.08 145.28,77.63 v1(145.39,77.52)
PCIE_ATX_DRX_P2: length 171.2
  IN1 w0.119: v1(33.45,37.66) 33.68,37.89 33.68,38.05 33.93,38.3 34.88,38.3 35.99,37.19 37,37.19 37.69,36.5 45.28,36.5 45.89,35.89 47.35,35.89 47.64,35.6 53.45,35.6 53.95,35.1 55.1,35.1 55.67,34.53 56.77,34.53 59.59,31.71 61.34,31.71 62.07,30.98 62.07,29.89 64.28,27.69 96.26,27.69 96.89,28.31 97.32,28.75 99.97,28.75 109.72,28.75 110,29.03 113.09,29.03 113.51,28.6 116.38,28.6 117.63,29.86 120.9,29.86 121.48,30.44 125.35,30.44 129.16,34.26 129.16,34.62 131.37,36.82 135.89,36.82 136.26,36.45 138.7,36.45 139.94,37.69 140,37.76 140.57,38.87 140.57,41.27 139.06,42.78 139.06,44.91 140.27,46.12 140.27,53.6 140.82,54.15 140.82,57.02 142.35,58.55 142.35,58.85 143.35,59.85 144.36,60.86 144.36,66.41 144.19,66.58 144.19,68.91 144.36,69.08 144.36,71.55 144.35,71.56 144.69,71.89 144.69,73.43 144.54,73.58 144.54,75.81 143.64,76.71 v1(143.64,77.46)
  BOTTOM w0.1: UC1.R3 136.41,76.02 136.66,76.02 137.07,76.43 137.32,76.43 137.53,76.64 137.76,76.64 138.66,77.53 139.77,77.53 139.78,77.53 139.95,77.53 140,77.57 140,77.57 140.02,77.58
  BOTTOM w0.112: v1(33.45,37.66) 33.57,37.54 33.57,37.3 CS49.1 ; v1(143.64,77.46) 143.71,77.54 143.71,78.26 143.45,78.53 v2(141.39,78.53) 140.96,78.53 140.02,77.58
PCIE_ATX_DRX_P3: length 156.9
  IN1 w0.119: v1(142.4,77.46) 142.62,77.24 142.62,74.44 143.52,73.54 143.52,71.34 143.62,71.24 143.62,69.39 143.45,69.22 143.45,66.27 143.62,66.1 143.62,61.17 141.61,59.16 141.61,58.85 140.08,57.33 140.08,54.46 139.52,53.91 139.52,46.43 137.4,44.31 136.96,44.31 134.57,41.91 134.54,41.87 134.41,41.59 134.37,41.53 134.26,41.28 133.91,40.53 133.91,40.43 128.42,34.93 128.42,34.77 126.66,33.01 124.5,33.01 122.68,31.19 121.17,31.19 120.59,30.6 117.29,30.6 116.86,30.17 109.18,30.17 108.9,29.89 103.87,29.89 103.55,30.22 72.71,30.22 70.91,32.01 63.05,32.01 62.61,32.46 59.9,32.46 56.91,35.44 55.81,35.44 55.41,35.84 54.26,35.84 53.76,36.34 47.95,36.34 47.66,36.63 46.2,36.63 45.59,37.24 41.49,37.24 40.61,38.13 37.92,38.13 37.74,38.3 36.71,38.3 36.46,38.06 36.46,37.75 v1(36.32,37.62)
  BOTTOM w0.089: UC1.T4 135.33,75.8 136.08,75.52 136.21,75.52 136.38,75.62 136.8,75.62 137.23,76.05 137.47,76.05 137.68,76.26 137.91,76.26 138.62,76.97 140.13,76.97 140.94,77.78 142.22,77.78 142.23,77.77 142.28,77.77 142.3,77.75 142.31,77.75
  BOTTOM w0.112: 142.31,77.75 142.33,77.75 142.4,77.67 v1(142.4,77.46) ; CS50.1 36.44,37.24 36.44,37.51 v1(36.32,37.62)
PCIE_ATX_DRX_P4: length 232.3
  TOP w0.112: CC1.1 28.69,83.48 28.8,83.59 29.16,83.59 v1(29.41,83.33)
  IN3 w0.135: v1(137.05,72.77) 137.03,72.77 136.6,72.34 136.6,72.15 136.31,71.86 136.31,71.07 136.33,71.05 136.33,68.12 138.53,65.92 139.73,65.92 140.61,65.04 140.61,60.74 140.3,60.43 140.3,59.39 140.5,59.19 140.5,57.34 140.19,57.03 140.19,47.42 139.94,47.17 139.94,44.39 142.14,42.19 142.14,38.5 142.12,38.42 141.25,36.77 138.67,34.19 138.67,32.68 132.27,26.28 101.08,26.28 101.06,26.27 97.59,26.27 97.18,26.67 83.33,26.67 83.1,26.9 65.19,26.9 64.17,27.93 64.17,28.64 61.68,31.13 59.18,31.13 54.41,35.9 44.65,35.9 44.17,36.38 39.13,36.38 38.35,35.6 37.88,35.6 36.53,34.25 31.82,34.25 30.76,33.19 24.98,33.19 22.19,35.98 22.19,40.39 23.4,41.6 28.7,41.6 29.21,42.11 29.26,42.11 30.16,43.01 30.16,50.39 29.05,51.49 29.05,58.09 29.22,58.25 29.22,61.49 31.15,63.43 31.15,66.23 30.55,66.83 30.55,70.28 30.39,70.44 30.39,81.12 28.58,82.92 28.58,83.54 28.72,83.68 28.88,83.68 29.02,83.54 29.02,83.47 29.15,83.33 v1(29.41,83.33)
  BOTTOM w0.102: v1(137.05,72.77) 136.98,72.7 136.83,72.7 136.74,72.8 136.54,72.8 136.45,72.9 136.45,72.98 136.26,73.16 136,73.16 135.9,73.06 135.9,72.91 136,72.81 UC1.W2
PCIE_ATX_DRX_P5: length 97
  IN1 w0.119: v1(82.91,116.55) 83.1,116.36 83.1,116.06 83.35,115.81 84.6,115.81 86.36,114.06 97.53,114.06 98.57,113.02 102.55,113.02 107.77,107.79 115.78,107.79 116.25,107.79 119.29,104.75 120.84,100.89 123.36,98.36 129.52,98.36 134.71,93.17 135.71,93.17 139.53,89.36 139.53,82.61 138.65,81.73 138.65,77.27 137.85,76.47 137.85,74.19 138.02,74.01 138.21,73.82 138.21,73.28 138.6,72.89 138.61,72.89 v1(138.63,72.87)
  BOTTOM w0.102: UC1.W3 136.41,73.6 136.79,73.6 137,73.81 137.14,73.81 138.01,72.94 138.55,72.94 v1(138.63,72.87)
  BOTTOM w0.112: CC3.1 77.76,116.23 78.4,115.59 82.76,115.59 83.07,115.9 83.07,116.4 v1(82.91,116.55)
PEG_ARX_C_GTX_N0: length 6
  BOTTOM w0.076: 115.08,144.78 115.08,144.77 115.06,144.76 115.06,144.12 115.02,144.07 115.02,143.72 115.1,143.64 115.24,143.64 115.34,143.75 UV1.AG31
  BOTTOM w0.112: CV2.1 112.57,147.04 112.57,146.82 112.68,146.71 113.18,146.71 113.92,145.96 114.53,145.96 115.08,145.41 115.08,144.78
PEG_ARX_C_GTX_N1: length 5.8
  BOTTOM w0.076: UV1.AF28 115.85,142.89 115.85,143.67 115.88,143.71 115.88,143.97 115.73,144.13 115.73,144.69 115.74,144.71 115.74,144.76 115.76,144.78 115.76,144.78
  BOTTOM w0.112: 115.76,144.78 115.76,145.64 114.74,146.66 114.54,146.66 114.39,146.81 114.39,147.03 CV4.1
PEG_ARX_C_GTX_N2: length 10.1
  BOTTOM w0.089: UV1.AF26 115.89,141.25 115.63,141.25 115.59,141.29 115.11,141.29 115.1,141.3 115.08,141.3 114.08,142.31 114.08,144.36 113.84,144.6 113.84,144.78
  BOTTOM w0.112: CV6.1 110.56,147.07 110.56,146.69 111.4,145.85 112.82,145.85 113.64,145.03 113.84,144.83 113.84,144.78
PEG_ARX_C_GTX_N3: length 14.4
  BOTTOM w0.076: UV1.AD26 117.85,141.11 118.22,141.11 118.42,141.3 118.86,141.3 119.04,141.49 119.04,141.98 119.16,142.1 119.57,142.1 119.84,142.37 119.84,143.89 120.41,144.47 120.41,144.75 120.43,144.76 120.43,144.78
  BOTTOM w0.112: CV8.1 116.91,150.48 117.52,150.48 117.58,150.42 117.6,150.42 118.1,149.92 118.58,149.92 v2(119.32,149.18) 121.22,147.28 121.22,146.47 120.43,145.68 120.43,144.78
PEG_ARX_C_GTX_P0: length 6
  BOTTOM w0.076: UV1.AH30 114.83,143.69 114.83,144.15 114.88,144.19 114.88,144.62 114.86,144.64 114.86,144.78
  BOTTOM w0.112: 114.86,144.78 114.86,145.32 114.44,145.74 113.83,145.74 113.09,146.48 112.59,146.48 112.35,146.73 112.35,147.07 CV1.1
PEG_ARX_C_GTX_P1: length 5.8
  BOTTOM w0.076: 115.54,144.78 115.54,144.05 115.7,143.89 115.7,143.78 115.67,143.74 115.67,142.91 115.57,142.82 115.46,142.82 115.34,142.94 UV1.AG29
  BOTTOM w0.112: CV3.1 114.17,147.04 114.17,146.72 114.45,146.44 114.64,146.44 115.54,145.54 115.54,144.78
PEG_ARX_C_GTX_P2: length 10.1
  BOTTOM w0.089: UV1.AF27 116.14,141.8 116.23,141.71 116.23,141.54 116.14,141.45 115.71,141.45 115.67,141.49 115.19,141.49 114.25,142.43 114.25,144.46 114.07,144.64 114.07,144.78
  BOTTOM w0.112: 114.07,144.78 114.07,144.91 112.91,146.07 111.49,146.07 110.78,146.78 110.78,147.05 CV5.1
PEG_ARX_C_GTX_P3: length 14.3
  BOTTOM w0.076: 120.21,144.78 120.21,144.69 120.23,144.67 120.23,144.54 119.66,143.97 119.66,142.45 119.49,142.29 119.08,142.29 118.86,142.06 118.86,141.57 118.78,141.49 118.34,141.49 118.14,141.29 117.78,141.29 117.7,141.37 117.7,141.76 UV1.AD27
  BOTTOM w0.112: CV7.1 117.17,150.26 117.43,150.26 v2(117.73,149.95) 117.99,149.7 118.49,149.7 118.97,149.22 118.97,149.2 119.35,148.83 119.36,148.83 121,147.19 121,146.56 120.21,145.77 120.21,144.78
PEG_ARX_GTX_N0: length 121.8
  IN3 w0.099: v1(131.32,76.81) 131.32,77.88 131.85,78.41 132.39,78.41 133.06,79.09 134.04,79.09 134.57,79.61 134.57,82.22 133.17,83.61 133.17,85.16 133.48,85.47 133.48,85.87 133.38,85.97 133.35,85.97
  IN3 w0.135: v1(111.8,149.54) 111.68,149.42 111.37,149.42 111.04,149.1 111.04,148.18 110.77,147.9 109.05,147.9 108.87,148.08 105.94,148.08 104.94,147.08 104.94,144.57 101.92,141.55 101.92,135.65 105.25,132.32 105.25,128.37 101.4,124.51 101.4,122.39 100.19,121.19 100.19,115.05 107.63,107.62 118.17,107.62 119.6,109.05 123.78,109.05 124.3,109.57 125.42,109.57 126.63,110.79 129.67,110.79 131.85,108.61 131.85,106.82 132.49,106.18 132.49,105.27 131.85,104.64 131.85,97.64 133.98,95.51 133.98,90.9 133.56,90.48 133.56,88.64 132.86,87.94 132.86,86.46 133.35,85.97
  BOTTOM w0.089: UC1.P9 131.32,77 131.32,76.81 v1(131.32,76.81)
  BOTTOM w0.112: CV2.2 112.71,148.52 112.71,149.08 112.32,149.47 111.87,149.47 v1(111.8,149.54)
PEG_ARX_GTX_N1: length 121
  IN3 w0.099: v1(132.83,77.9) 133.02,78.09 133.02,78.32 133.39,78.69 134.65,78.69 135.69,79.73 135.69,82.78 134.12,84.35 134.12,85.99 134.11,86.01 134.11,86.06 134.08,86.09 134.08,86.1
  IN3 w0.135: v1(113.48,149.52) 113.33,149.36 113.07,149.36 112.7,148.99 112.7,147.36 112.51,147.18 108.81,147.18 108.59,147.4 106.54,147.4 105.62,146.48 105.62,144.29 102.6,141.27 102.6,135.93 105.93,132.6 105.93,128.09 102.15,124.31 102.15,122.02 100.87,120.74 100.87,115.33 107.83,108.38 115.78,108.38 116.53,109.13 118.46,109.13 119.06,109.73 123.49,109.73 124.02,110.25 125.13,110.25 126.35,111.47 129.95,111.47 130.76,110.66 132.57,108.85 132.57,107.23 133.17,106.64 133.17,104.99 132.53,104.35 132.53,98.36 134.66,96.23 134.66,90.31 134.24,89.89 134.24,88.03 133.97,87.75 133.97,86.32 134.08,86.21 134.08,86.1
  BOTTOM w0.089: v1(132.83,77.9) 132.89,77.96 132.89,77.96 UC1.N7
  BOTTOM w0.112: CV4.2 114.46,148.57 114.46,149.04 114.03,149.46 113.54,149.46 v1(113.48,149.52)
PEG_ARX_GTX_N2: length 115.7
  IN3 w0.099: 132.07,86.1 132.07,85.96 132.63,85.4 132.63,83.44 134,82.07 134,80.65 133.84,80.48 132.54,80.48 132.32,80.27 132.32,80.13 v1(132.04,79.84)
  IN3 w0.135: v1(108.77,149.41) 108.92,149.26 108.92,148.86 108.82,148.76 105.65,148.76 104.26,147.37 104.26,144.85 101.24,141.83 101.24,135.37 104.57,132.04 104.57,128.65 100.71,124.8 100.71,122.67 99.51,121.47 99.51,114.77 107.35,106.93 118.64,106.93 120.08,108.37 124.06,108.37 124.58,108.89 125.7,108.89 126.92,110.11 129.39,110.11 131.17,108.32 131.17,107.96 131.17,107.96 131.17,95.71 132.96,93.92 132.96,92.04 132.59,91.67 132.59,88.78 132.07,88.27 132.07,86.1
  BOTTOM w0.089: v1(132.04,79.84) 132.04,79.82 131.63,79.41 UC1.M9
  BOTTOM w0.112: v1(108.77,149.41) 108.95,149.23 108.95,149.02 109.19,148.78 110.46,148.78 110.57,148.67 110.57,148.49 110.38,148.31 CV6.2
