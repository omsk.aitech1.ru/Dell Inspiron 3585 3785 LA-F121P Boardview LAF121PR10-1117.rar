# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_SMB_CK2: length 246.3
  TOP w0.102: QV1.6 123.66,122.19
  TOP w0.112: v1(181.28,65.79) 182,65.79 182.29,65.5 Q11.3 ; RC616.1 v1(127.86,89.77) 127.86,90.29 127.75,90.41 RC24.2 ; 123.66,122.19 123.66,121.95 v1(123.42,121.71) ; v1(43.22,87.28) 43.41,87.09 43.73,87.09 43.99,86.84 43.99,84.72 44.07,84.64 44.07,84.29 44.15,84.21 UE1.79
  IN1 w0.119: v1(123.42,121.71) 124.12,121.01 125.21,121.01 125.48,120.73 125.48,118.45 126.86,117.08 126.86,114.93 125.82,113.89 125.82,111.68 128.48,109.02 128.48,106.28 v1(128.62,106.14) 128.51,106.02 128.51,105.79 128.7,105.6 131.08,105.6 131.58,105.1 133.7,105.1 135.51,106.91 139.22,106.91 140.23,105.9 143.37,105.9 144.77,104.5 163.06,104.5 167.67,99.9 167.67,97.82 169.26,96.23 169.26,87.43 171.49,85.2 171.49,75.62 174.55,72.56 177.36,72.56 181.52,68.4 181.52,66.58 181.15,66.22 181.15,65.92 v1(181.28,65.79)
  IN3 w0.135: v1(127.86,89.77) 127.62,90.01 127.62,91.92 128.45,92.76 128.45,103.84 128.24,104.06 128.24,104.68 128.43,104.87 128.43,105.95 v1(128.62,106.14) 128.39,106.37 128.39,106.73 128.1,107.02 127.45,107.02 126.24,105.81 121.14,105.81 119.56,104.23 106.43,104.23 100.3,110.36 96.92,110.36 95.66,111.62 95.66,112.05 95.66,113.09 93.74,115.01 92.02,115.01 91.84,114.82 87,114.82 82.9,118.92 75.1,118.92 74.43,118.25 73.85,118.25 73.06,117.46 71.47,117.46 71.32,117.31 67.5,117.31 67.28,117.09 65.4,117.09 64.08,115.77 62.35,115.77 55.97,109.39 55.97,93.37 51.19,88.59 45.5,88.59 44.08,87.17 43.33,87.17 v1(43.22,87.28)
EC_SMB_DA1: length 284.6
  TOP w0.112: RE509.2 44.75,85.02 44.75,84.78 v1(44.65,84.68) 44.55,84.58 UE1.78 ; PR37.2 168.08,41.78 PD5.2 167.21,41.78 166.76,41.32 v1(166.76,41.21) 166.39,40.84 166.39,40.44 166.14,40.19 161.97,40.19 161.78,40.01 161.78,37.65 161.01,36.88 v2(161.01,33.96) 161.01,32.28 161.57,31.72 161.57,31.21 v1(161.72,31.06)
  IN1 w0.119: v1(25.87,37.65) 25.7,37.48 25.7,36.9 25.56,36.76 25.56,35.85 26.43,34.98 33.02,34.98 34.36,33.64 39.4,33.64 40.65,32.4 45.94,32.4 46.77,33.22 52.14,33.22 52.39,32.97 54.22,32.97 54.79,32.4 55.89,32.4 57.92,30.37 57.92,29.62 58.18,29.36 58.62,29.36 59.72,28.25 59.72,27.83 62,25.56 99.56,25.56 100.48,26.47 133.08,26.47 138.58,31.97 144.98,31.97 145.81,31.14 147.19,31.14 147.81,30.53 157.6,30.53 159.14,32.06 161.14,32.06 161.55,31.66 161.55,31.23 v1(161.72,31.06)
  IN3 w0.135: v1(25.87,37.65) 25.7,37.81 25.7,37.94 25.88,38.11 29.51,38.11 30.36,38.95 30.41,38.95 33.56,42.1 33.56,44.79 34.32,45.56 34.32,47.18 34.71,47.56 34.71,49.54 34.59,49.65 34.59,52.73 33.52,53.81 33.52,57.16 32.26,58.42 32.26,60.23 34.4,62.37 34.4,69.22 35.21,70.04 35.21,72.47 35.13,72.56 35.13,82.4 38.15,85.42 44.36,85.42 44.81,84.97 44.81,84.84 v1(44.65,84.68) ; v1(205.3,51.25) 205.46,51.09 205.46,48.63 204.97,48.14 204.97,44.52 205.53,43.96 205.73,43.96 206.51,43.18 206.51,42.74 204.82,41.05 203.29,41.05 203.13,40.89 201.69,40.89 201.13,40.33 199.4,40.33 198.54,41.19 194.34,41.19 194.11,40.96 189.77,40.96 189.66,41.06 185.18,41.06 184.96,41.28 176.6,41.28 175.99,40.67 166.7,40.67 166.57,40.81 166.57,41.02 v1(166.76,41.21)
  BOTTOM w0.112: v1(205.3,51.25) 205.47,51.08 205.47,50.91 PRB14.1
EC_SMB_DA2: length 245.3
  TOP w0.112: QV1.3 124.96,120.24 v3(124.55,119.83) v1(124.18,119.47) ; v1(43.22,86.69) 43.38,86.85 43.63,86.85 43.75,86.74 43.75,84.63 43.83,84.54 43.83,84.24 43.75,84.16 UE1.80 ; Q11.6 180.99,66.8 v1(180.53,66.33) ; RC25.2 127.03,90.34 v1(127.03,89.78) RC617.1
  IN1 w0.119: v1(180.53,66.33) 180.91,66.33 181.27,66.69 181.27,68.3 177.25,72.32 174.44,72.32 171.25,75.51 171.25,85.1 169.02,87.33 169.02,96.13 167.42,97.72 167.42,99.8 162.96,104.26 144.67,104.26 143.27,105.65 140.13,105.65 139.12,106.66 135.61,106.66 133.8,104.86 131.48,104.86 130.98,105.35 128.6,105.35 128.26,105.69 128.26,105.92 v1(128.04,106.14) 128.23,106.33 128.23,108.92 125.57,111.57 125.57,113.99 126.61,115.03 126.61,116.97 125.24,118.35 125.24,120.63 125.1,120.77 124.47,120.77 124.18,120.48 v1(124.18,119.47)
  IN3 w0.135: v1(43.22,86.69) 43.43,86.9 44.18,86.9 45.61,88.33 51.3,88.33 56.23,93.26 56.23,109.28 62.46,115.51 64.19,115.51 65.51,116.83 67.39,116.83 67.61,117.04 71.43,117.04 71.58,117.19 73.17,117.19 73.96,117.99 74.54,117.99 75.21,118.66 82.79,118.66 86.89,114.56 91.94,114.56 92.13,114.75 93.63,114.75 95.4,112.98 95.4,112.15 95.4,112.15 95.4,111.51 96.81,110.1 100.19,110.1 106.32,103.97 119.67,103.97 121.25,105.55 126.35,105.55 127.56,106.76 128,106.76 128.13,106.62 128.13,106.23 v1(128.04,106.14) 128.17,106 128.17,104.98 127.97,104.78 127.97,103.95 128.19,103.73 128.19,92.86 127.36,92.03 127.36,90.11 v1(127.03,89.78)
EC_TP_INT#: length 129.9
  TOP w0.089: UE1.106 38.41,78.21 38.77,77.85 v1(38.77,77.46) ; v1(115.05,29.02) 115.18,28.88 115.18,28.3 114.32,27.44 R12.1 ; v1(64.59,28.1) v3(64,28.1)
  IN1 w0.089: v1(115.05,29.02) 113.67,29.02 113.26,29.44 109.83,29.44 109.63,29.23 97.23,29.23 96.1,28.1 v1(64.59,28.1)
  IN2 w0.089: v1(38.77,77.46) 38.7,77.39 38.7,73.46 36.58,71.35 36.58,69.53 35.91,68.85 35.91,68.39 36.05,68.25 36.05,66.81 35.82,66.58 35.82,61.88 36.69,61.02 36.69,58.1 40.61,54.18 40.61,52.68 43.7,49.59 43.7,38.76 48.46,34 52.03,34 52.51,33.52 54.95,33.52 57.58,30.89 57.58,29.2 58.54,28.24 58.54,26.68 59.17,26.05 63.08,26.05 64.59,27.56 v1(64.59,28.1)
EC_TX: length 73.1
  TOP w0.089: v1(49.13,68.98) 48.95,68.81 UE1.30
  IN2 w0.089: v1(68.86,113.84) 68.86,114.06 68.68,114.24 68.03,114.24 67.41,113.62 65.22,113.62 63.57,115.28 60.27,115.28 59.16,114.17 50.67,114.17 49.46,112.97 49.18,112.97 47.36,111.14 47.36,105.57 47.9,105.03 47.9,88.31 48.9,87.31 48.9,84.04 48.29,83.44 48.29,79.49 49.24,78.55 49.24,73.45 48.84,73.05 48.84,71.36 49.32,70.87 49.32,69.78 49.13,69.59 v1(49.13,68.98)
  BOTTOM w0.254: RW6.1 68.36,116.57 68.31,116.52 68.31,115.98 68.47,115.82 v3(68.47,115.57) 68.86,115.18 v1(68.86,113.84)
ECAGND: length 133
  TOP w0.089: v1(49.07,81.61) 49.04,81.63 48.72,81.63 48.15,82.19 UE1.69 48.15,84.16 48.51,84.52 48.51,84.78 48,85.29 CE8.2 ; v3(55.24,84.72) 54.57,84.04 LE2.2 53.67,83.03 CE11.1 51.17,82.76 49.57,81.16 v1(49.57,81.05)
  TOP w0.099: PH1.2 v1(120.75,49.21)
  IN2 w0.089: 58.89,44.92 53.82,49.98 53.82,54.62 51.04,57.41 51.04,66.92 49.5,68.46 49.5,71.27 49.79,71.56 49.79,80.83 v1(49.57,81.05) 49.07,81.55 v1(49.07,81.61) ; v1(120.75,49.21) 120.75,49.09 120.82,49.02 120.82,42.62 120.46,42.26 118.35,42.26 116.81,40.72 116.81,38.83 115.02,37.03 113.83,36.47 112.5,36.47 111.54,36.82 110.94,37.24 108.5,39.68 106.1,39.68 105.57,39.14 102.85,39.14 102.79,39.08 95.47,39.08 93.61,37.22 90.27,37.22 89.56,37.93 87.82,37.93 87.32,37.44 80.29,37.44 79.66,38.07 66.68,38.07 63.89,40.86 61.79,40.86 61.27,41.38
  IN2 w0.102: 61.27,41.38 61.27,42.88 59.24,44.92 58.89,44.92
EDP_AUXN: length 142.2
  IN3 w0.135: v1(138.2,88.63) 138.2,88.62 138.55,88.27 138.55,88.01 141.34,85.22 141.34,76.43 142.31,75.47 142.31,75.29 143.12,74.48 144.67,74.48 145.26,73.89 145.26,72.5 148.26,69.49 148.26,63.23 148.48,63.01 148.48,62.69 149.02,62.15 149.02,57.92 151.13,55.81 151.13,52.81 150.94,52.63 150.94,49.66 150.61,49.33 150.61,42.91 151.37,42.15 151.37,41.95 152.79,40.54 156.87,40.54 157.11,40.3 160.89,40.3 161,40.41 163.24,40.41 163.83,39.82 165.09,39.82 165.23,39.68 166.1,38.81 172.01,38.81 173.01,37.82 177.48,37.82 178.71,36.59 182.43,36.59 183.56,37.73 186.99,37.73 187.58,38.32 190.48,38.32 190.9,38.74 194.58,38.74 196.21,37.11 203.61,37.11 207.79,41.3 207.79,41.96 207.97,42.14 207.97,42.68 208.29,43 208.29,45.25 208.08,45.47 208.08,49.01 207.76,49.34 207.76,52.37 208.76,53.37 208.89,53.37 209.2,53.06 v1(209.21,53.06)
  BOTTOM w0.089: 134.25,89.68 134.27,89.68 134.28,89.69
  BOTTOM w0.1: 134.25,89.68 134.09,89.52 133.08,89.52 132.62,89.06 132.62,89.02 132.18,88.58 132.14,88.58 132.03,88.47 132.03,87.22 131.72,86.91 131.72,86.68 132.12,86.28 132.12,86.14 132.03,86.04 131.88,86.04 131.73,86.19 UC1.B9
  BOTTOM w0.112: 134.28,89.69 135.06,90.47 138.19,90.47 138.31,90.36 138.31,89.13 138.45,88.98 138.45,88.88 v1(138.2,88.63) ; v1(209.21,53.06) 209.38,53.22 209.71,53.22 209.89,53.04 C4322.2
EDP_AUXN_C: length 1.8
  BOTTOM w0.112: JEDP1.16 211.82,52.95 211.65,53.13 211.43,53.13 211.36,53.2 211.11,53.2 C4322.1
EDP_AUXP: length 142.2
  IN3 w0.135: v1(138.79,88.63) 138.79,88.11 141.58,85.32 141.58,76.53 142.55,75.57 142.55,75.39 143.22,74.72 144.77,74.72 145.5,73.99 145.5,72.6 148.5,69.59 148.5,63.33 148.72,63.11 148.72,62.79 149.26,62.25 149.26,58.02 151.37,55.91 151.37,52.71 151.18,52.53 151.18,49.56 150.85,49.23 150.85,43.01 151.62,42.25 151.62,42.05 152.89,40.78 156.97,40.78 157.21,40.54 160.79,40.54 160.9,40.65 163.34,40.65 163.93,40.06 165.19,40.06 165.33,39.92 166.2,39.05 172.11,39.05 173.11,38.06 177.58,38.06 178.81,36.83 182.33,36.83 183.46,37.97 186.89,37.97 187.48,38.56 190.38,38.56 190.8,38.98 194.68,38.98 196.31,37.35 203.51,37.35 207.55,41.4 207.55,42.06 207.73,42.24 207.73,42.78 208.05,43.1 208.05,45.15 207.84,45.37 207.84,48.91 207.51,49.24 207.51,52.47 208.66,53.61 209.18,53.61 v1(209.21,53.64)
  BOTTOM w0.089: 134.13,89.84 134.11,89.82
  BOTTOM w0.1: 134.11,89.82 134.01,89.72 133,89.72 v2(132.21,88.93) 131.83,88.55 131.83,87.3 131.52,87 131.52,86.47 131.44,86.26 131.44,86.08 UC1.D9
  BOTTOM w0.112: v1(138.79,88.63) 138.68,88.74 138.68,89.07 138.53,89.22 138.53,90.45 138.29,90.69 134.98,90.69 134.13,89.84 ; v1(209.21,53.64) 209.4,53.45 209.56,53.45 C4321.2
EDP_AUXP_C: length 1.8
  BOTTOM w0.112: C4321.1 211.17,53.42 211.45,53.42 211.52,53.35 211.74,53.35 211.84,53.45 JEDP1.15
EDP_HPD: length 148.2
  TOP w0.089: v1(131.96,106.11) v3(132.56,106.11)
  IN1 w0.119: v1(131.96,106.11) 132,106.07 132.79,106.07 134.73,108.01 143.45,108.01 145.79,105.66 163.54,105.66 168.75,100.44 168.75,98.25 170.95,96.05 170.95,87.91 172.46,86.4 172.46,76.69 173.07,76.09 175.38,73.77 179.32,73.77 186.12,66.97 193.49,66.97 194.17,66.29 194.17,65.34 194.7,64.81 194.71,64.81 195.16,64.36 195.16,58.66 199.28,54.53 199.28,54.01 199.74,53.55 201.7,53.55 204.79,50.46 207.62,50.46 209.02,49.06 209.63,49.06 210.18,49.6 210.18,54.12 209.7,54.61 v1(209.28,54.61)
  IN2 w0.124: v1(130.35,87.22) 130.35,87.73 131.58,88.97 131.58,104.1 132.39,104.91 132.39,105.68 v1(131.96,106.11)
  BOTTOM w0.089: UC1.C10 131.23,86.17 130.35,87.05 v1(130.35,87.22)
  BOTTOM w0.112: R3.2 v1(209.28,54.61)
EDP_HPD_R: length 2.6
  BOTTOM w0.089: JEDP1.12 212.02,54.95 211.49,54.41 210.99,54.41 R3.1 RP1.1
EDP_TXN0: length 139.9
  IN3 w0.135: v1(209.23,51.87) 209.21,51.87 208.87,51.53 208.5,51.53 208.21,51.24 208.21,49.5 208.52,49.19 208.52,45.71 208.73,45.5 208.73,44.42 210.34,42.82 210.34,42.49 210.02,42.16 210.02,41.88 209.71,41.57 209.38,41.57 204.84,37.03 204.36,37.03 203.99,36.66 192.47,36.66 192.33,36.8 188.72,36.8 187.32,35.4 186.53,35.4 186.14,35.8 180.3,35.8 179.94,36.15 178.52,36.15 177.3,37.38 173.54,37.38 173.49,37.33 166.96,37.33 164.91,39.38 163.65,39.38 163.06,39.97 161.19,39.97 161.02,39.81 156.98,39.81 156.69,40.1 152.61,40.1 150.93,41.77 150.93,41.97 150.17,42.73 150.17,49.52 150.5,49.85 150.5,52.82 150.69,53 150.69,55.63 148.58,57.74 148.58,61.97 148.04,62.51 148.04,62.83 147.34,63.53 147.34,69.8 144.82,72.31 144.82,73.66 144.45,74.04 142.94,74.04 141.64,75.34 141.64,75.52 140.9,76.25 140.9,85.03 138.02,87.92 137.71,87.92 137.37,88.26 137.37,88.39 v1(137.6,88.62)
  BOTTOM w0.1: UC1.A8 132.19,86.61 132.09,86.71 132.09,86.94 132.23,87.08 132.23,87.84 133.17,88.78 134.13,88.78 134.88,89.52
  BOTTOM w0.112: C4311.2 209.89,51.91 209.64,51.67 209.43,51.67 v1(209.23,51.87) ; 134.88,89.52 135.25,89.9 137,89.9 137.24,89.66 137.24,88.98 v1(137.6,88.62)
EDP_TXN0_C: length 1.8
  BOTTOM w0.112: JEDP1.18 211.82,51.95 211.65,51.79 211.32,51.79 211.25,51.71 211.09,51.71 C4311.1
EDP_TXN1: length 139
  IN3 w0.135: v1(135.85,88.62) 136.01,88.46 136.01,87.75 136.29,87.47 136.85,87.47 137.33,87 137.63,87 139.98,84.65 139.98,75.86 140.6,75.23 140.6,75.07 142.59,73.08 142.59,72.66 146.41,68.84 146.41,63.15 146.97,62.59 147.12,62.44 147.12,57.8 147.69,57.23 147.77,57.23 149.33,55.68 149.33,53.03 149.58,52.77 149.58,50.23 149.25,49.9 149.25,42.35 150.01,41.59 150.01,41.39 152.22,39.18 156.3,39.18 156.59,38.89 161.41,38.89 161.57,39.05 162.68,39.05 163.27,38.46 164.53,38.46 167.81,35.17 173.57,35.17 173.77,35.38 176.42,35.38 176.57,35.23 179.56,35.23 179.91,34.87 185.76,34.87 186.73,33.9 187.13,33.9 189.1,35.88 190.43,35.88 190.93,35.39 192.67,35.39 193.19,34.86 198.77,34.86 199.65,35.74 204.38,35.74 204.75,36.11 205.22,36.11 209.76,40.65 210.09,40.65 210.94,41.5 210.94,41.67 211.26,41.99 211.26,43.35 209.65,44.96 209.65,46.01 209.44,46.22 209.44,48.65 210.17,49.37 210.17,49.78 209.88,50.07 v1(209.2,50.07)
  BOTTOM w0.1: UC1.B8 132.73,87.58 133.19,88.03 135.78,88.03 135.96,88.22
  BOTTOM w0.112: C4313.2 209.58,49.91 209.36,49.91 v1(209.2,50.07) ; 135.96,88.22 135.96,88.51 v1(135.85,88.62)
EDP_TXN1_C: length 1.9
  BOTTOM w0.112: C4313.1 211.12,49.91 211.23,49.91 211.56,50.24 211.72,50.24 211.93,50.45 JEDP1.21
EDP_TXP0: length 139.9
  IN3 w0.135: v1(137.02,88.62) 137.13,88.51 137.13,88.16 137.61,87.68 137.92,87.68 140.66,84.93 140.66,76.15 141.39,75.42 141.39,75.24 142.84,73.8 144.35,73.8 144.58,73.56 144.58,72.21 147.09,69.7 147.09,63.43 147.8,62.73 147.8,62.41 148.34,61.87 148.34,57.64 150.44,55.53 150.44,53.1 150.26,52.92 150.26,49.95 149.93,49.62 149.93,42.63 150.69,41.87 150.69,41.67 152.51,39.86 156.59,39.86 156.88,39.57 161.12,39.57 161.29,39.73 162.96,39.73 163.55,39.14 164.81,39.14 166.86,37.09 173.59,37.09 173.64,37.14 177.2,37.14 178.42,35.91 179.84,35.91 180.2,35.55 186.04,35.55 186.43,35.16 187.42,35.16 188.82,36.56 192.23,36.56 192.37,36.42 204.09,36.42 204.46,36.79 204.94,36.79 209.48,41.33 209.81,41.33 210.26,41.78 210.26,42.06 210.58,42.39 210.58,42.92 208.97,44.52 208.97,45.6 208.76,45.81 208.76,49.29 208.45,49.6 208.45,51.14 208.6,51.29 v1(209.23,51.29)
  BOTTOM w0.1: 135.03,89.37 135.03,89.36 135.01,89.36 134.96,89.32 134.96,89.32 134.22,88.58 133.25,88.58 132.43,87.76 132.43,86.99 132.53,86.72 132.53,86.48 UC1.C8
  BOTTOM w0.112: v1(209.23,51.29) 209.38,51.45 209.55,51.45 C4312.2 ; v1(137.02,88.62) 137.02,89.57 136.91,89.68 135.34,89.68 135.03,89.37
EDP_TXP0_C: length 1.8
  BOTTOM w0.112: JEDP1.19 211.85,51.45 211.74,51.57 211.42,51.57 211.34,51.49 211.14,51.49 210.8,51.15 C4312.1
EDP_TXP1: length 139
  IN3 w0.135: v1(209.2,49.49) 209.22,49.49 209.56,49.83 209.78,49.83 209.93,49.68 209.93,49.47 209.2,48.75 209.2,46.12 209.41,45.91 209.41,44.86 211.02,43.25 211.02,42.09 210.7,41.77 210.7,41.6 209.99,40.89 209.66,40.89 205.12,36.35 204.65,36.35 204.28,35.98 199.55,35.98 198.67,35.1 193.29,35.1 192.77,35.63 191.03,35.63 190.53,36.12 189,36.12 187.03,34.14 186.83,34.14 185.86,35.11 180.01,35.11 179.66,35.47 176.67,35.47 176.52,35.62 173.67,35.62 173.47,35.42 167.91,35.42 164.63,38.7 163.37,38.7 162.78,39.29 161.47,39.29 161.3,39.13 156.69,39.13 156.41,39.42 152.32,39.42 150.25,41.49 150.25,41.69 149.49,42.45 149.49,49.8 149.82,50.13 149.82,52.87 149.57,53.13 149.57,55.78 147.87,57.48 147.79,57.48 147.36,57.9 147.36,62.54 147.21,62.69 146.65,63.25 146.65,68.94 142.83,72.76 142.83,73.18 140.84,75.17 140.84,75.33 140.22,75.96 140.22,84.75 137.74,87.24 137.43,87.24 136.95,87.71 136.39,87.71 136.25,87.85 136.25,88.39 136.43,88.57 v1(136.43,88.62)
  BOTTOM w0.1: UC1.D8 132.81,85.81 133.03,86.04 133.03,86.38 132.93,86.48 132.93,87.49 133.27,87.83 135.86,87.83 136.19,88.15
  BOTTOM w0.112: 136.19,88.15 136.19,88.37 v1(136.43,88.62) ; C4314.2 209.89,49.39 209.59,49.69 209.41,49.69 v1(209.2,49.49)
EDP_TXP1_C: length 1.9
  BOTTOM w0.112: C4314.1 211.15,49.69 211.32,49.69 211.65,50.02 211.81,50.02 211.88,49.95 JEDP1.22
EN_0.6VSP: length 6.5
  TOP w0.089: v3(31.97,32.67) 32.27,32.37 PRM13.2
  TOP w0.203: PRM12.2 34.22,30.25 34.22,29.71 34.71,29.22 34.71,29.21 PUM01.7
  TOP w0.254: PRM09.2 32.73,31.26 PRM13.2 ; PRM09.2 32.78,30.87 PRM12.2 ; PRM09.2 32.73,30.06 PCM16.1
EN_0.95V: length 2.7
  TOP w0.254: PUF01.2 79.69,115.24 79.19,115.73 PRF01.2 77.88,115.73 PCF03.1
EN_1.2V: length 3.5
  TOP w0.203: PRM08.2 33.63,28.28 PCM15.1 34.08,29.13 34.4,28.81 PUM01.8
  TOP w0.254: PRM12.1 33.6,29.16 PCM15.1
EN_1.8VALW:
  vias: v3(174.67,55.89)
EN_2.5V: length 7.7
  TOP w0.254: PR2501.2 76.54,110.17 v3(76.54,111.06) 76.54,111.59 75.88,112.25 74.53,112.25 73.29,111.01 PC2503.1 73.06,111.01 72.37,111.69 PU2501.2
EN_3V: length 53.9
  TOP w0.089: v3(18.31,45.59) 18.44,45.46 v1(18.88,45.46)
  IN3 w0.089: v1(18.88,45.46) 20.42,47 20.42,47.3 20.83,47.72 20.83,52.91 23.21,55.29 26.1,55.29 26.93,56.12 26.93,61.24 29.31,63.63 29.31,65.72 29.11,65.92 29.11,69.68 28.94,69.84 28.94,78.62 27.12,80.44 27.12,84.67 25.48,86.32 25.48,87.91 26.49,88.93 v1(26.49,88.97)
  BOTTOM w0.089: PU301.12 19.44,44.9 v1(18.88,45.46)
  BOTTOM w0.254: v1(26.49,88.97) 26.56,89.03 PR502.1
EN_5V: length 2.6
  BOTTOM w0.203: PR503.1 27.34,94.03 26.87,94.49 26.46,94.49 26.01,94.95 PU501.12
EN_+1.35VGPU: length 6
  BOTTOM w0.089: PCW09.1 v3(137.26,111.51)
  BOTTOM w0.254: PCW09.1 139.04,111.51 139.07,111.48 PRW02.1 PRW01.2 139.86,111.18 140.56,110.49 141.12,110.49 141.55,110.06 PUW01.6
EN_+VDDP: length 4.4
  TOP w0.254: v1(166.16,47.68) 167.1,47.68 PCH09.1 167.11,46.92 PRH02.1
  BOTTOM w0.254: PUH01.6 164.85,47.43 165.11,47.68 v1(166.16,47.68) PRH01.2
ENABLE_APU: length 3.6
  TOP w0.203: PRZ19.2 152.98,92.36 152.98,91.2 153.1,91.07 v3(153.1,91.04) 153.1,91.03 153.57,90.57 PUZ01.8
  TOP w0.254: PRZ19.2 PRZ47.2
ENABLE_VGA: length 6.4
  TOP w0.089: v3(66.95,130.21) 67.06,130.09 PCV37.1
  TOP w0.203: PUV01.8 71.09,128.64 70.92,128.81 70.15,128.81 69.64,129.31 PRV15.2 69.61,129.34 69.13,129.83 67.66,129.83 PCV37.1
ENLDO_3V5V: length 67.1
  TOP w0.089: v1(27.26,94.76) v3(26.69,94.76)
  IN3 w0.089: v1(27.26,94.76) 27.26,90.87 26.21,89.82 25.29,89.82 24.51,89.04 24.51,86.76 26.76,84.51 26.76,80.29 28.58,78.47 28.58,69.69 28.74,69.53 28.74,65.38 27.03,63.67 27.03,61.86 26.56,61.4 26.56,56.27 25.95,55.66 23.06,55.66 20.47,53.07 20.47,51.35 v1(19.85,50.73)
  BOTTOM w0.089: PR302.1 16.99,46.09 16.48,46.6 16.48,47.62 17.24,48.38 19.91,48.38 20.61,49.08 20.61,49.97 v1(19.85,50.73) ; PR302.1 18.16,45.41 PU301.11 ; PR302.1 18.99,46.09 PR303.1
  BOTTOM w0.203: PU501.11 26.46,95.17 26.66,94.97 27.05,94.97 v1(27.26,94.76)
ENVDD: length 166.6
  TOP w0.089: v1(217.95,41.01) 217.97,41.02 217.97,42.17 218.45,42.65 218.45,43.28 217.8,43.92 RX8.2 ; v1(162.81,38.25) 162.81,38.08 161.58,36.85 161.58,32.87 162.87,31.58 165.76,31.58 165.92,31.42 165.92,29.57 166.99,28.51 v1(167.12,28.51) ; RC4.1 131.94,94.35 132,94.29 132,93.86 132.09,93.77 UC5.4 v4(144.5,93.77) 147.39,93.77 v1(147.95,93.21)
  IN1 w0.089: v1(162.81,38.25) 162.63,38.07 162.03,38.07 161.5,38.6 161.5,38.7 161.01,39.18 156.37,39.18 156.07,39.48 154.8,39.48 154.44,39.85 154.22,39.85 153.41,40.66 152.51,41.56 152.51,42.2 150.63,44.07 150.63,49.3 150.96,49.63 150.96,51.35 152.57,52.95 152.57,62.58 151.95,63.19 151.95,68.35 152.76,69.16 152.76,76.29 150.95,78.1 150.95,80.15 150.07,81.03 149.37,81.03 148.91,81.49 148.91,83.14 148.73,83.33 148.73,86.33 147.35,87.71 147.35,92.62 v1(147.95,93.21)
  IN2 w0.089: v1(217.95,41.01) 217.95,40.99 218.2,40.75 218.2,35.93 217.66,35.4 217.66,34.81 215.22,32.36 214.37,32.36 213.87,31.86 212.08,31.86 210.63,30.41 205.03,30.41 204.13,31.31 203.47,31.31 203.09,31.69 202.77,31.69 202.59,31.52 197.96,31.52 197.04,30.59 191.72,30.59 191.16,31.16 187.74,31.16 187.34,30.75 181.83,30.75 180.11,29.03 176.03,29.03 175.41,28.41 173.29,28.41 172.75,28.95 169.23,28.95 168.95,28.67 167.29,28.67 v1(167.12,28.51)
ENVDD_R: length 54.4
  TOP w0.089: v1(127.6,108.2) 125.44,106.04 125.44,103.4 122.03,99.98 122.03,94.84 122.15,94.72 124.48,94.72 125.75,93.44 125.75,93.1 126.15,92.7 127.61,92.7 128.26,92.06 v1(128.36,92.06) 129,92.06 129.54,91.51 130.29,91.51 130.48,91.31 RPC1.7 132.05,91.31 132.18,91.44 132.18,92.96 131.42,93.72 131.42,94.23 131.23,94.42 UC5.2
  IN2 w0.089: v1(128.36,92.06) 128.33,92.03 128.33,91.15 129.03,90.46 129.03,89.27 127.12,87.36 127.12,84.82 126.73,84.43 v1(126.73,84.31)
  BOTTOM w0.089: v1(127.6,108.2) 126.76,107.36 116.34,107.36 115.38,108.33 D5.2
  BOTTOM w0.1: v1(126.73,84.31) 126.43,84.01 UC1.F15
ENVDD_RE: length 4.6
  TOP w0.089: v3(216.94,45.69) 217.71,44.93 RX8.1 RX9.1 218.68,44.93 219.75,43.86 U2.4
FAN_PWM: length 227.2
  TOP w0.089: RF2.1 180.22,68.49 v1(180.22,67.25) 179.32,67.25 178.77,67.8 v3(177.01,67.8) 174.1,67.8 v1(172.71,66.42) ; UE1.26 47.35,69.37 v1(47.64,69.66)
  IN2 w0.089: v1(172.71,66.42) 172.71,67.92 170.66,69.97 170.66,70.89 170.66,71.19 169.63,72.22 169.63,86.88 169.14,87.37 169.14,91.5 168.82,91.82 168.82,96.85 168.04,97.62 168.04,100.96 163.73,105.27 157.39,105.27 156.75,104.64 145.28,104.64 144.03,105.89 143.73,105.89 143.58,105.89 143.58,105.89 139.75,105.89 139.51,106.13 137.27,106.13 134.62,108.78 126.29,108.78 125.28,107.78 117.33,107.78 117.26,107.7 106.35,107.7 101.03,113.02 91.41,113.02 90.24,114.2 86.36,114.2 85.58,114.97 81.54,114.97 80.04,113.47 77.59,113.47 76.46,114.6 73.89,114.6 73.59,114.9 67.59,114.9 66.87,114.18 65.46,114.18 63.8,115.84 60.03,115.84 58.93,114.74 50.44,114.74 49.23,113.53 48.95,113.53 46.8,111.38 46.8,105.34 47.34,104.8 47.34,88.08 47.51,87.91 47.51,86.47 47.34,86.31 47.34,83.33 47.55,83.12 47.55,81.2 46.96,80.61 46.96,76.47 47.22,76.22 47.22,74.25 47.29,74.17 47.78,73.68 47.78,70.63 47.64,70.49 v1(47.64,69.66)
  BOTTOM w0.089: v1(180.22,67.25) 181.16,67.25 181.9,67.99 181.9,68.41 181.22,69.09 JFAN1.2
FAN_SPEED1: length 223.9
  TOP w0.089: v1(48.39,69.98) 48.43,69.93 48.43,69.43 48.15,69.15 UE1.28 48.15,66.48 47.61,65.94 46.22,65.94 RF1.1 ; v1(172.13,66.36) v3(174.93,69.16) 176.17,70.4 176.3,70.4 176.95,71.05 DF1.2
  IN2 w0.089: v1(48.39,69.98) 48.39,71.01 47.97,71.43 47.97,73.76 47.4,74.33 47.4,76.29 47.14,76.55 47.14,80.53 47.73,81.12 47.73,83.2 47.52,83.4 47.52,86.23 47.69,86.4 47.69,87.98 47.52,88.15 47.52,104.87 46.98,105.42 46.98,111.3 48.96,113.28 49.02,113.34 49.3,113.34 50.51,114.55 59.01,114.55 60.11,115.65 63.73,115.65 65.38,114 66.95,114 67.66,114.71 73.52,114.71 73.82,114.41 76.38,114.41 77.51,113.29 80.11,113.29 80.87,114.04 86.25,114.04 86.28,114.01 90.16,114.01 91.34,112.84 95.25,112.84 95.87,112.22 101.57,112.22 106.28,107.52 117.34,107.52 117.41,107.59 125.36,107.59 126.37,108.6 134.54,108.6 137.2,105.94 139.44,105.94 139.68,105.7 143.65,105.7 143.65,105.7 143.8,105.7 143.95,105.7 145.2,104.46 156.83,104.46 157.47,105.09 163.66,105.09 167.86,100.89 167.86,97.47 168.56,96.77 168.56,91.81 168.89,91.49 168.89,87.24 169.44,86.68 169.44,72.15 170.48,71.11 170.48,70.96 170.48,70.96 170.48,69.89 172.13,68.24 v1(172.13,66.36)
FB_1.2V: length 6.3
  TOP w0.089: v3(33.68,34.06) 34.04,33.69 PRM10.1
  TOP w0.203: PCM17.1 PRM10.1 ; PCM17.1 33.23,32.25 PRM11.1 ; PCM17.1 34.51,31.77 34.51,29.83 34.74,29.61 PUM01.6
FB_1.8VALW: length 0.9
  BOTTOM w0.089: PR1807.2 v3(174.73,61.44)
FB_+VDDP: length 3.7
  TOP w0.089: v3(166.2,45.86) 166.58,45.47 v1(166.58,45.31)
  TOP w0.254: v1(166.58,45.31) 166.74,45.15 PRH08.1 167.19,45.5 167.16,45.52 PRH12.2
  BOTTOM w0.254: PRH09.1 167.01,45.31 v1(166.58,45.31) 166.51,45.38 PUH01.10
FB__+1.35VGPU: length 9.3
  BOTTOM w0.089: v3(140.25,113.56) 141.42,113.56 142.55,112.43 PRW10.1
  BOTTOM w0.254: PRW12.2 145.35,113.62 144.66,113.62 144.41,113.37 143.75,113.37 143.44,113.06 142.73,113.06 142.55,112.88 142.55,112.37 PRW10.1 142.58,112.37 PRW09.1 143.35,111.38 PUW01.10
FB_GND: length 2.4
  TOP w0.381: v1(117.26,136.91) 117.26,137.09 116.78,137.58 116.72,137.58 116.31,137.99 RV158.2
  BOTTOM w0.305: v1(117.26,136.91) 117.26,136.88 UV1.AD20
FB_VDDC: length 4.7
  TOP w0.102: RV159.2 117.21,138.3 117.67,138.77 117.67,139.52 v3(117.15,140.04)
  TOP w0.381: v1(117.89,136.98) 117.89,137.2 117.21,137.88 RV159.2
  BOTTOM w0.305: v1(117.89,136.98) 117.89,136.95 118.44,136.4 UV1.AC20
FB_VDDCI: length 2.4
  BOTTOM w0.102: UV1.W1 121.74,121.86 121.33,121.45 121.33,121.38 121,121.05 T64.1
FFS_INT1: length 126.1
  TOP w0.089: v1(203.34,30.9) 203.4,30.96 203.4,31.04 203.73,31.38 203.92,31.38 204.22,31.69 US4.12 ; v1(149.92,28.01) v3(149.4,28.01)
  IN2 w0.089: v1(203.34,30.9) 203.22,30.78 202.94,30.78 202.39,31.33 198.04,31.33 197.11,30.41 191,30.41 190.43,30.97 187.82,30.97 187.41,30.57 181.91,30.57 180.16,28.82 176.08,28.82 175.49,28.23 173.18,28.23 172.57,27.62 171.12,27.62 170.61,28.13 166.29,28.13 165.65,27.5 150.43,27.5 v1(149.92,28.01)
  IN3 w0.089: 123.3,54.16 122.83,53.69 122.83,51.8 123.4,51.23 123.4,50.02 123.38,50 123.38,47.73 123.5,47.61 123.5,44.93 122.91,44.33 122.91,42.56 122.05,41.7 v1(121.26,41.7)
  IN3 w0.099: 123.3,54.16 123.7,54.56 123.7,55.59 124.11,56 124.11,58.92 124.5,59.31 v1(124.73,59.31)
  BOTTOM w0.089: v1(121.26,41.7) 120.77,41.21 RC6123.1 120.58,41.21 119.82,41.97 118.87,41.97 117.99,41.09 117.99,38.29 117.99,38.28 117.99,34.23 118.08,34.14 120.85,34.14 122.41,35.71 124.38,35.71 127.22,32.87 128.9,32.87 129.82,31.95 139.54,31.95 139.63,31.85 144.58,31.85 148.42,28.01 v1(149.92,28.01)
  BOTTOM w0.1: v1(124.73,59.31) 124.33,59.71 UC1.AR18
FFS_INT2: length 122.8
  TOP w0.089: US4.11 204.14,32.19 203.91,32.42 v1(203.91,32.44) ; QS1.2 206.46,34.67 206.69,34.44 206.69,33.58 v1(206.43,33.32) ; v1(127.87,34.81) v3(128.41,34.81)
  TOP w0.099: RC6124.1 126.2,46.88 125.77,46.88 125.38,47.28 v1(124.96,47.28)
  IN2 w0.089: v1(127.87,34.81) 127.95,34.88 128.22,34.88 129.04,35.7 129.67,35.7 131.14,37.17 134.88,37.17 135.68,36.36 144.54,36.36 145.62,37.44 146.81,37.44 147.54,36.71 147.73,36.71 150.38,36.71 151.15,35.94 152.98,34.12 160.79,34.12 161.06,33.86 161.9,33.01 163.02,33.01 163.15,32.88 167.89,32.88 167.99,32.98 168.74,32.98 169.66,32.06 172.51,32.06 172.64,32.19 174.61,32.19 175.52,31.28 177.89,31.28 178.68,32.07 179.07,32.07 180.28,33.28 182.18,33.28 182.28,33.38 184.37,33.38 184.47,33.28 184.89,33.28 185.1,33.49 186.78,33.49 189.05,35.75 190.62,35.75 191.51,34.87 193.93,34.87 195.37,33.43 201.84,33.43 202.28,33.87 203.53,33.87 204.02,33.38 204.19,33.38 204.81,32.76 205.87,32.76 v1(206.43,33.32)
  IN3 w0.089: 125.31,55.05 125.31,54.76 124.35,53.81 124.35,52.66 124.84,52.17 124.84,47.39 v1(124.96,47.28)
  IN3 w0.099: v1(124.76,58.57) 124.76,58.55 125.31,58 125.31,55.05
  BOTTOM w0.089: v1(124.96,47.28) 124.96,46.29 124.24,45.58 124.24,44.45 124.42,44.26 124.42,43.41 126.03,41.81 126.03,41.42 126.54,40.91 126.54,38.85 125.97,38.28 125.97,36.73 127.28,35.42 127.28,35.12 127.59,34.81 v1(127.87,34.81) ; UC1.AT18 124.41,58.91 124.66,58.66 124.68,58.66 ; v1(206.43,33.32) 206.43,33.07 206.29,32.93 204.39,32.93 v1(203.91,32.44)
  BOTTOM w0.1: 124.68,58.66 v1(124.76,58.57)
FFS_INT2_Q: length 26.2
  TOP w0.089: QS1.3 205.86,35.32 205.55,35.62 v1(205.55,35.67) v3(205.55,37.34)
  IN2 w0.089: v1(205.55,35.67) 205.22,35.34 204.39,35.34 203.99,35.73 201.82,35.73 201.67,35.89 199.14,35.89 198.56,35.3 195.83,35.3 193.6,37.53 192.34,37.53 191.96,37.91 190.28,37.91 189.94,37.58 188.29,37.58 188.09,37.38 187.22,37.38 186.88,37.04 186.42,37.04 185.98,36.6 v1(185.76,36.6)
  BOTTOM w0.089: JHDD1.9 186.2,36.07 185.76,36.5 v1(185.76,36.6) 185.79,36.63 185.79,37.15 RS28.2
FPR_SCAN#: length 250.5
  TOP w0.089: v1(37.16,73.57) 37.16,73.5 37.08,73.41 UE1.118 34.6,73.41 34.45,73.26 34.45,72.94 RE507.1 ; v1(220.96,32.69) 218.16,29.89 EU4012.3 217.51,27.07 v4(216.89,26.45)
  IN1 w0.089: v1(56.99,26.2) 59.63,23.56 100.86,23.56 101.81,24.51 133.9,24.51 139.3,29.91 142.72,29.91 146.48,26.15 174.55,26.15 178.07,29.67 181.75,29.67 182.08,30 198.96,30 199.04,29.92 213.24,29.92 214.84,28.33 217.11,28.33 220.56,31.77 220.56,32.28 v1(220.96,32.69)
  IN2 w0.089: v1(37.16,73.57) 37.04,73.57 35.54,72.07 35.54,70.02 34.26,68.74 34.26,62.15 35.71,60.7 35.71,57.59 39.45,53.85 39.45,52.5 40.88,51.07 40.88,50.21 41.61,49.48 42.13,49.48 42.79,48.83 42.79,38.04 47.74,33.09 51.65,33.09 52.13,32.6 54.26,32.6 56.67,30.2 56.67,26.52 v1(56.99,26.2)
  BOTTOM w0.089: JFP1.2 220.5,31.42 220.52,31.44 220.52,32.24 v1(220.96,32.69)
GPIO19_CTF: length 7.3
  BOTTOM w0.089: RV152.1 125.83,119.34 126.4,118.77 v3(126.4,117.55)
  BOTTOM w0.102: UV1.M2 127.29,122.95 127.29,120.83 127.51,120.62 127.51,119.72 RV151.2 127.25,119.45 RV152.1
GPIO28: length 7.8
  BOTTOM w0.089: v3(122.94,118.17) 123.67,118.17 123.93,118.43 RV21.2
  BOTTOM w0.102: UV1.R5 125.33,123.81 125.33,121.51 124.01,120.19 124.01,119.95 123.68,119.62 123.68,118.87 RV21.2
GPIO89: length 149.1
  TOP w0.089: v1(125.13,40.57) 124.68,40.57 123.31,39.2 123.31,37.43 123.79,36.95 123.79,33.88 123.23,33.32 121.86,33.32 121.64,33.54 121.31,33.88 110.4,33.88 107.94,31.42 100.49,31.42 98.81,33.1 97.89,33.1 v3(96.51,31.73) 91.58,26.8 61.29,26.8 60.59,26.1 59.15,26.1 58.88,26.37 58.88,30.57 58.44,31.01 56.05,31.01 54.5,32.56 52.68,32.56 48.99,36.25 32.19,36.25 30.65,34.72 30.65,30.56 30.19,30.1 30.19,29.24 29.56,28.61 29.56,28.21 29.79,27.97 29.79,26.89 28.85,25.95 23.94,25.95 23.63,25.65 UC21.2
  IN2 w0.089: v1(125.13,40.57) 125.92,41.36 125.92,41.95 127.3,43.34 127.4,43.34 128.65,44.59 128.65,45.58 125.26,48.97 125.26,51.11 123.59,52.79 123.59,53.95 124.73,55.1 v1(124.73,56.23)
  BOTTOM w0.089: UC1.AW16 125.11,56.61 v1(124.73,56.23)
GPU_AC_LIGHT: length 1.9
  TOP w0.089: RE36.1 48.74,84.44 48.55,84.25 UE1.68
H_PROCHOT#: length 467.6
  TOP w0.112: v1(35.65,67.04) 35.6,67.09 31.8,67.09 29.96,68.93 29.96,76.04 31.15,77.23 31.15,77.91 32.04,78.8 32.6,78.8 RE43.2 ; RC26.2 123.73,90.46 123.1,91.09 123.1,91.88 v1(123.26,92.04) ; v1(156.22,92.16) 156.04,92.34 PRZ15.2 155.48,91.85 155.17,91.54 PUZ01.4 ; v1(62.72,114.26) 62.71,114.26 62.71,114.48 63.1,114.87 63.1,116.11 63.36,116.37 65.48,116.37 65.88,116.77 65.88,118.15 64.19,119.83 64.19,120.71 64.67,121.18 PQS10.3 ; v1(174.38,29.59) 174.39,29.59 174.39,30.05 PQ11.1 173.79,30.65 172.67,30.65 172.56,30.55 PQ12.3 ; v1(129.8,41.55) 129.83,41.52 129.94,41.52 130.75,40.71 132.44,40.71 133.59,41.86 133.59,42.1 135.87,44.38 139.42,44.38 v3(141.16,42.64) 142.17,41.63 v1(142.8,41.63)
  IN3 w0.099: 123.72,86.1 123.72,85 123,84.27 123,81.06 123.54,80.51 v1(123.76,80.51)
  IN3 w0.135: v1(142.8,41.63) 143.11,41.63 143.95,40.79 144.69,40.79 149.61,35.86 150.48,35.86 154.92,31.42 156.05,31.42 157.21,30.26 163.08,30.26 163.23,30.11 173.86,30.11 v1(174.38,29.59) ; v1(206.85,51.18) 206.85,48.57 206.11,47.83 206.11,44.68 207.29,43.5 207.29,42.42 205.14,40.27 203.86,40.27 203.61,40.27 203.45,40.12 202.01,40.12 201.45,39.55 199.08,39.55 198.48,40.15 189.37,40.15 189.23,40.29 184.86,40.29 184.7,40.44 176.86,40.44 175.64,39.22 174.21,39.22 174,39.43 v1(174,39.43) ; v1(129.8,41.55) 129.8,41.53 129.75,41.48 129.75,41.3 129.61,41.17 129.61,35.19 128.46,34.03 124.49,34.03 123.92,34.6 121.76,34.6 120.08,32.93 117.01,32.93 116.52,32.44 108.92,32.44 108.38,31.9 104.36,31.9 103.82,32.44 102.49,32.44 102.14,32.8 67.96,32.8 64.01,36.75 62.33,36.75 61.89,37.19 61.06,37.19 55.68,42.57 42.48,42.57 37.46,47.58 37.46,49.45 36.68,50.23 36.68,57.81 35.65,58.84 v1(35.65,67.04) 35.65,67.65 36.05,68.04 36.05,68.8 36.53,69.29 36.53,73.02 36.5,73.05 36.5,80.03 36.55,80.08 36.55,81.7 38.41,83.56 41.03,83.56 41.7,84.23 46.06,84.23 49.56,87.73 51.84,87.73 56.67,92.57 56.67,109.1 61.03,113.45 62.11,113.45 62.72,114.06 v1(62.72,114.26) ; v1(123.26,92.04) 123.75,92.04 124.98,90.81 124.98,88.66 123.72,87.4 123.72,86.1
  BOTTOM w0.1: v1(123.76,80.51) 123.35,80.11 UC1.L19
  BOTTOM w0.112: v1(206.85,51.18) 206.78,51.1 PRB19.1 ; v1(156.22,92.16) 155.65,92.16 152.66,95.15 143.28,95.15 140.82,92.69 127.97,92.69 126.68,91.4 123.81,91.4 123.26,91.95 v1(123.26,92.04) 124.3,93.08 124.3,96.35 108.86,111.79 96.05,111.79 93.31,114.54 84.11,114.54 81.89,112.32 81.01,112.32 79.4,113.93 73.53,113.93 71.95,112.36 69.8,112.36 69.41,112.74 65.5,112.74 63.49,114.75 63.2,114.75 62.72,114.26 v1(62.72,114.26) ; v1(129.8,41.55) 129.83,41.53 130.39,41.53 130.58,41.72 130.58,42.43 130.83,42.68 RC661.2 ; v1(174.38,29.59) 174.39,29.59 174.39,30.05 173.69,30.75 173.69,33.92 174.1,34.33 174.1,39.33 v1(174,39.43)
HDA_BIT_CLK: length 20.6
  TOP w0.112: v1(142.01,61.5) 141.92,61.41 141.26,61.41 140.55,60.69 140.55,59.77 140.86,59.45 142.84,59.45 v1(143.36,58.94) 143.37,58.93 143.52,58.93 143.78,59.19 144.68,59.19 RPC4.8 144.91,59.32 145.5,58.73 145.95,58.73 v3(146.65,58.03) 146.77,57.9 146.77,57.3 147.91,56.16 148.18,56.16 148.56,55.77 RC62.2
  BOTTOM w0.112: v1(143.36,58.94) 143.42,58.94 143.8,59.32 RPC5.5 ; UC1.AR2 136.15,59.79 136.71,59.79 136.85,59.92 139.67,59.92 141.15,61.41 141.92,61.41 v1(142.01,61.5)
HDA_BIT_CLK_R: length 175.2
  TOP w0.112: UA1.6 31.07,13.07 v1(31.1,13.04) 31.93,13.04 32.16,13.27 RA44.1 ; v1(146.43,58.91) 146.38,58.96 146.38,59.07 146.14,59.32 RPC4.1
  IN3 w0.135: v1(31.1,13.04) 31.1,12.45 31.35,12.2 32.35,12.2 32.95,12.79 32.95,15.67 34.2,16.92 34.2,22.54 33.44,23.31 33.44,26.75 37.82,31.13 38.2,31.13 38.95,31.88 46.41,31.88 46.62,31.67 55.22,31.67 55.62,31.28 55.62,31.17 56.69,30.09 56.69,29.25 57.71,28.23 61.32,28.23 64.45,25.1 82.35,25.1 82.58,24.87 96.43,24.87 96.84,24.47 101.81,24.47 101.82,24.48 134.38,24.48 145.28,35.39 145.28,37.36 144.62,38.02 v1(144.61,38.02)
  BOTTOM w0.112: v1(146.43,58.91) 146.43,58.84 146.48,58.79 146.48,57.12 147.56,56.04 150.08,56.04 151.53,54.6 151.53,51.55 151.99,51.09 151.99,49.75 152.02,49.72 152.02,49.28 151.28,48.53 151.28,44.11 150.92,43.76 147.7,43.76 144.93,40.99 v3(144.93,39.67) 144.93,38.34 v1(144.61,38.02)
HDA_RST#: length 19.3
  TOP w0.112: v1(143.18,61.32) 143.77,61.32 144.27,60.82 RPC4.5 145.32,60.82 145.68,61.18 146.79,61.18 147.33,60.64 147.33,57.45 v3(147.65,57.12) 148.1,56.68 148.52,56.68 C1.1
  BOTTOM w0.112: UC1.AP3 136.1,60.31 136.42,59.99 136.63,59.99 136.77,60.12 139.58,60.12 141.19,61.73 141.64,61.73 141.78,61.87 142.25,61.87 142.8,61.32 v1(143.18,61.32) 143.18,61.22 143.58,60.82 RPC5.8
HDA_RST#_R: length 172.7
  TOP w0.089: RA14.1 33.84,16.52 33.84,17.31 v1(33,18.15)
  TOP w0.112: v1(146.67,60.72) 146.57,60.82 RPC4.4
  IN3 w0.089: v1(143.88,36.97) 143.88,35.69 133.82,25.63 101.35,25.63 101.33,25.61 97.31,25.61 96.91,26.02 83.06,26.02 82.82,26.25 64.92,26.25 61.79,29.37 58.19,29.37 57.83,29.73 57.83,30.57 56.76,31.64 56.76,31.75 55.42,33.09 52.53,33.09 52.28,33.35 48.14,33.35 47.4,34.09 41.18,34.09 40.81,33.73 39.18,33.73 37.73,32.27 36.32,32.27 35.26,31.21 35.26,30.3 31.61,26.65 31.61,19.54 v1(33,18.15)
  BOTTOM w0.089: v1(143.88,36.97) 144.21,36.65 145.09,36.65 146.03,37.58 146.03,40.46 148.24,42.68 151.37,42.68 152.36,43.66 152.36,48.07 153.11,48.81 153.11,50.17 153.08,50.2 153.08,51.54 152.61,52 152.61,55.05 150.53,57.13 148.01,57.13 147.56,57.57 147.56,60.03 146.88,60.72 v1(146.67,60.72)
HDA_SDIN0: length 149.1
  TOP w0.099: RC60.2 132.83,60.43 v1(132.18,59.78)
  TOP w0.112: v1(31.75,14.28) 31.8,14.28 32.15,14.63 32.98,14.63 33.32,14.28 RA43.2 ; v1(68.42,33.24) 67.56,32.37 v3(61.12,32.37) 56.4,32.37 55,33.77 53.25,33.77 v1(52.92,34.1)
  IN3 w0.099: 132.61,55.05 132.61,55.63 132.27,55.98 132.27,59.69 v1(132.18,59.78)
  IN3 w0.135: v1(31.75,14.28) 31.69,14.28 30.18,15.79 30.18,25.73 34.9,30.45 34.9,31.36 36.34,32.81 37.13,32.81 38.41,34.09 40.66,34.09 41.02,34.45 47.55,34.45 48.29,33.71 52.54,33.71 v1(52.92,34.1) ; 132.61,55.05 132.61,54.21 133.11,53.7 133.11,51.04 131.67,49.59 131.67,48.59 131.5,48.42 131.5,46.88 130.77,46.15 130.77,44.71 130.38,44.32 129.17,43.11 129.17,41.71 129.17,41.71 129.17,36.11 128.37,35.31 126.26,35.31 126.26,35.3 121.83,35.3 119.9,33.37 116.83,33.37 116.33,32.88 108.74,32.88 108.19,32.34 104.54,32.34 104,32.88 102.68,32.88 102.05,33.51 68.77,33.51 68.5,33.24 v1(68.42,33.24)
  BOTTOM w0.089: UC1.AP7 133.23,60.29 132.72,59.78 v1(132.18,59.78)
HDA_SDIN0_R: length 2.2
  TOP w0.112: RA43.1 32.18,13.87 v3(31.43,13.87) 31.14,13.87 UA1.8
HDA_SDIN1: length 8.3
  BOTTOM w0.089: 142.31,62.24 141.74,62.24 141.64,62.14 v3(141.33,62.14) 141.14,62.14 139.31,60.31 UC1.AP1
  BOTTOM w0.112: 142.31,62.24 142.4,62.24 142.73,61.91 RC58.2
HDA_SDIN2: length 9.9
  BOTTOM w0.089: 142.31,62.6 142.08,62.6 141.97,62.5 141.26,62.5 139.29,60.53 136.71,60.53 136.65,60.59 136.41,60.59 136.34,60.52 136.01,60.52 135.73,60.81 UC1.AP4
  BOTTOM w0.112: 142.31,62.6 v3(142.55,62.6) 142.83,62.32 143.47,62.32 143.85,62.71 RC59.2
HDA_SDOUT: length 13.2
  TOP w0.112: v1(140.96,60.16) 140.97,60.16 141.31,59.82 v3(141.89,59.82) RPC4.7
  BOTTOM w0.102: UC1.AR3 135.73,59.3 136.11,59.3 136.24,59.18 136.25,59.18 136.41,59.01 136.82,59.01 136.98,58.86 139.58,58.86 140.86,60.14 140.95,60.14 v1(140.96,60.16)
  BOTTOM w0.112: v1(140.96,60.16) 140.97,60.16 141.3,59.82 RPC5.6
HDA_SDOUT_R: length 173.5
  TOP w0.112: v1(31.52,12.62) 30.94,12.62 30.9,12.67 UA1.5 ; RPC4.2 146.37,59.82 146.63,59.55 v1(146.67,59.55)
  IN3 w0.135: v1(144.63,37.41) 144.9,37.15 144.9,35.64 134.13,24.87 101.66,24.87 101.65,24.86 97,24.86 96.59,25.26 82.74,25.26 82.51,25.49 64.61,25.49 61.48,28.62 57.87,28.62 57.08,29.41 57.08,30.25 56,31.33 56,31.44 55.39,32.06 46.78,32.06 46.58,32.27 38.79,32.27 38.04,31.52 37.65,31.52 32.43,26.29 32.43,23.65 33.81,22.26 33.81,17.08 32.56,15.83 32.56,13.57 32.01,13.02 31.73,13.02 31.52,12.81 v1(31.52,12.62)
  BOTTOM w0.112: v1(144.63,37.41) 144.84,37.41 145.29,37.87 145.29,40.75 v3(145.73,41.18) 147.94,43.4 151.08,43.4 151.64,43.96 151.64,48.38 152.39,49.12 152.39,49.88 152.36,49.91 152.36,51.24 151.89,51.7 151.89,54.75 150.24,56.41 147.71,56.41 146.84,57.27 146.84,59.44 146.73,59.55 v1(146.67,59.55)
HDA_SYNC: length 13.1
  TOP w0.112: v1(141.36,60.61) 141.4,60.65 141.55,60.65 141.9,60.3 v3(143.35,60.3) 143.62,60.3 143.63,60.32 RPC4.6
  BOTTOM w0.098: v1(141.36,60.61) 141.32,60.65 140.66,60.65 139.95,59.93 139.75,59.73 136.93,59.73 136.79,59.6 136.41,59.6 136.32,59.51 135.94,59.51 135.64,59.81 UC1.AR4
  BOTTOM w0.112: v1(141.36,60.61) 141.66,60.32 RPC5.7
HDA_SYNC_R: length 174.9
  TOP w0.112: RPC4.3 146.48,60.32 v1(146.67,60.13) ; v1(31.7,15.46) 31.51,15.46 30.72,14.67 UA1.10
  IN3 w0.135: v1(144.01,38.01) 144.01,37.44 144.29,37.16 144.29,37.15 144.51,36.94 144.51,35.8 133.97,25.26 101.5,25.26 101.48,25.24 97.16,25.24 96.76,25.65 82.9,25.65 82.67,25.88 64.77,25.88 61.64,29.01 58.03,29.01 57.47,29.57 57.47,30.41 56.39,31.49 56.39,31.6 55.27,32.73 52.38,32.73 52.13,32.98 46.9,32.98 46.58,32.66 38.63,32.66 37.88,31.91 36.85,31.91 36.32,31.38 36.32,31.06 35.63,30.37 35.63,30.15 32.04,26.56 32.04,23.49 33.43,22.1 33.43,17.24 31.7,15.51 v1(31.7,15.46)
  BOTTOM w0.112: v1(146.67,60.13) 146.92,60.13 147.21,59.84 147.21,57.43 147.86,56.77 150.39,56.77 152.26,54.9 152.26,51.86 152.72,51.39 152.72,50.06 152.75,50.03 152.75,48.96 152.01,48.22 152.01,43.81 151.23,43.03 148.09,43.03 v3(147.05,41.99) 145.66,40.6 145.66,37.72 144.95,37 144.46,37 144.01,37.45 v1(144.01,38.01)
HDD_A0_PRE0: length 9.2
  TOP w0.089: US1.9 185.13,30.55 v3(185.16,30.51) 185.53,30.15 187.78,30.15 RS7.2 188.17,30.53 188.68,30.02 191.84,30.02 RS23.1
HDD_A0_PRE1: length 3.1
  TOP w0.089: RS21.1 RS11.2 182.85,37.16 183.7,36.3 183.74,36.3 183.94,36.1 184.01,36.1 184.13,35.98 US1.19
HDD_B0_EQ: length 15.9
  TOP w0.089: US1.13 187.01,33.65 187.71,32.95 187.71,32.94 187.85,32.8 192.21,32.8 192.72,33.31 v1(192.72,33.7)
  BOTTOM w0.089: v1(192.72,33.7) 192.72,37.09 192.55,37.26 v3(192.24,37.26) RS16.1 RS15.1
HDD_B0_PRE0: length 10
  TOP w0.089: RS8.2 RS19.1 178.15,29.1 179.19,29.1 179.65,28.65 180.57,28.65 181.91,29.99 v3(182.28,29.99) 183.39,29.99 184.63,31.23 US1.8
HDD_B0_PRE1: length 2.5
  TOP w0.089: US1.17 185.13,37.25 RS20.1 RS10.2
HDD_EN#: length 80
  TOP w0.089: US5.4 191.37,35.49 191.19,35.67 191.19,36.04 v1(191.2,36.05)
  TOP w0.099: v3(133.24,57.37) v1(132.88,57.73)
  IN2 w0.089: v1(132.88,57.73) 133.25,57.36 135.07,57.36 135.16,57.27 135.16,54 136.5,52.66 136.5,52.18 137.46,51.22 137.46,47.85 137.22,47.61 137.22,45.47 139.56,43.12 143.15,43.12 148.78,37.5 150.78,37.5 153.34,34.94 160.23,34.94 161.98,33.2 163.1,33.2 163.23,33.06 167.82,33.06 167.91,33.16 168.82,33.16 169.74,32.25 172.43,32.25 172.56,32.38 175.46,32.38 178.29,35.21 179.41,35.21 180.13,34.48 183.01,34.48 183.57,33.92 184.06,33.92 184.39,34.25 184.89,34.25 185.22,33.92 186.96,33.92 188.97,35.94 191.09,35.94 v1(191.2,36.05)
  BOTTOM w0.1: v1(132.88,57.73) 132.88,57.95 UC1.AU7
HDD_REXT_SATA0: length 4.2
  TOP w0.254: RS6.2 RS24.1 181.33,36.97 181.59,36.7 182.93,36.7 183.63,36 US1.20
HDMI_CLKN: length 2.6
  TOP w0.112: RI23.1 CI1.1 18.56,94.3 18.23,93.96 18.07,93.96 17.93,94.1 LI1.2 17.26,94.27 RI1.1
HDMI_CLKP: length 2.5
  TOP w0.112: RI24.1 CI2.1 18.29,93.74 18.07,93.74 17.93,93.6 LI1.3 17.26,93.43 RI3.1
HDMI_CTRL_CLK: length 16.2
  IN3 w0.135: v1(12.39,110.2) 12.56,110.03 12.56,109.58 13.14,109 13.14,108.18 13.16,108.16 13.16,105.78 14.02,104.92 14.02,103.51 11.68,101.16 11.68,99.98 JHDMI1.15
  BOTTOM w0.112: QI3.6 12.24,109.67 12.69,109.23 12.8,109.23 12.89,109.33 12.89,109.51 12.57,109.83 12.57,110.02 v1(12.39,110.2) 12.51,110.32 12.51,110.44 12.36,110.59 12.36,110.72 12.17,110.91 RPI3.4
HDMI_CTRL_DATA: length 16.3
  IN3 w0.135: v1(12.98,110.2) 12.81,110.03 12.81,109.68 13.38,109.1 13.38,108.28 13.4,108.26 13.4,105.88 14.27,105.02 14.27,103.41 11.92,101.06 11.92,100.02 12.09,99.85 JHDMI1.16
  BOTTOM w0.112: QI3.3 13.04,108.9 12.99,108.95 12.99,109.11 13.12,109.24 13.12,109.6 12.8,109.92 12.8,110.02 v1(12.98,110.2) 12.73,110.45 12.73,110.53 12.58,110.68 12.58,110.84 12.67,110.93 RPI3.3
HDMI_HPD: length 19.5
  TOP w0.089: RI15.2 v3(23.4,110.38) 20.53,107.51 18.73,107.51 CI10.1 RI16.1 14.84,106.47 14.11,105.74 14.11,102.93 13.72,102.55 12.25,102.55 JHDMI1.19
HDMI_L_CLKN: length 7.2
  TOP w0.112: JHDMI1.12 12.99,97.46 13.32,97.46 13.56,97.22 13.56,95.25 13.62,95.18 v2(13.85,94.96) 14.26,94.55 14.26,94.12 14.37,94.01 14.58,94.01 RI2.1 15.32,93.96 15.53,93.96 15.67,94.1 LI1.1 16.34,94.27 RI1.2
HDMI_L_CLKP: length 7.2
  TOP w0.112: JHDMI1.10 12.99,97.24 13.23,97.24 13.34,97.13 13.34,95.15 13.44,95.05 13.44,95.03 13.87,94.61 13.89,94.61 14.04,94.46 14.04,94.03 14.28,93.78 14.58,93.78 RI2.2 15.22,93.74 15.53,93.74 15.67,93.6 LI1.4 16.34,93.43 RI3.2
HDMI_L_TX_N0: length 16.3
  TOP w0.112: JHDMI1.9 11.44,95.96 11.57,95.96 11.68,96.07 11.68,101.3 12.04,101.66 13.05,101.66 13.87,100.84 v2(13.87,99.79) 13.87,98.61 14.21,98.27 14.21,97.58 14.2,97.57 14.2,96.05 14.31,95.94 14.6,95.94 RI6.1 15.27,95.91 15.53,95.91 15.65,95.8 15.71,95.8 15.85,95.94 LI2.1 16.34,96.11 RI4.2
HDMI_L_TX_N1: length 6.1
  TOP w0.112: RI8.2 16.34,92.55 LI3.1 15.18,92.38 RI9.1 14.58,92.29 14.27,92.29 14.26,92.3 13.8,92.3 13.56,92.54 13.56,94.21 13.32,94.45 13,94.45 JHDMI1.6
HDMI_L_TX_N2: length 7.4
  TOP w0.112: RI14.2 16.34,90.46 LI4.1 15.67,90.29 15.53,90.15 15.32,90.15 RI13.2 14.58,90.2 14.28,90.2 13.48,91 13.16,91 12.77,91.39 12.77,91.42 12.31,91.89 12.28,91.89 11.9,92.26 11.9,92.62 11.56,92.96 11.16,92.96 11.05,93.07 JHDMI1.3
HDMI_L_TX_P0: length 16.4
  TOP w0.112: JHDMI1.7 11.44,95.74 11.66,95.74 11.9,95.98 11.9,101.21 12.13,101.44 12.95,101.44 13.65,100.74 13.65,100.07 13.64,100.06 13.64,99.53 13.65,99.51 13.65,98.52 13.98,98.19 v2(13.98,97.85) 13.98,95.96 14.22,95.72 14.55,95.72 RI6.2 15.27,95.69 15.44,95.69 15.55,95.58 15.74,95.58 15.88,95.44 LI2.4 16.34,95.27 RI7.2
HDMI_L_TX_P1: length 6.1
  TOP w0.112: JHDMI1.4 12.98,94.23 13.23,94.23 13.34,94.12 13.34,92.45 13.72,92.07 v2(13.94,92.07) 14.58,92.07 RI9.2 15.09,91.88 LI3.4 16.34,91.72 RI10.2
HDMI_L_TX_P2: length 7.4
  TOP w0.112: RI12.2 16.34,89.62 LI4.4 15.67,89.79 15.53,89.93 15.22,89.93 RI13.1 14.58,89.97 14.19,89.97 13.38,90.78 13.07,90.78 12.92,90.93 v2(12.42,91.43) 11.68,92.17 11.68,92.53 11.47,92.74 11.16,92.74 11.05,92.63 JHDMI1.1
HDMI_TX_N0: length 5.3
  TOP w0.112: RI4.1 17.26,96.11 LI2.2 17.73,95.94 17.85,95.82 18.01,95.82 18.53,96.34 v2(19.44,96.34) 20.17,96.34 20.62,95.89 20.8,95.89 20.91,96 CI4.1 RI21.1
HDMI_TX_N1: length 4.9
  TOP w0.112: RI28.1 CI6.1 20.52,92.06 18.14,92.06 17.82,92.38 LI3.2 17.26,92.55 RI8.1
HDMI_TX_N2: length 2.3
  TOP w0.112: RI26.1 CI8.1 18.43,90.29 LI4.2 17.26,90.46 RI14.1
HDMI_TX_P0: length 5.4
  TOP w0.112: RI7.1 17.26,95.27 LI2.3 17.7,95.44 17.85,95.6 18.1,95.6 18.62,96.12 19.16,96.12 19.17,96.1 19.71,96.1 19.72,96.12 20.08,96.12 20.53,95.66 20.72,95.66 20.91,95.47 CI5.1 RI22.1
HDMI_TX_P1: length 4.9
  TOP w0.112: RI10.1 17.26,91.72 LI3.3 17.63,91.88 17.74,91.99 17.9,91.99 18.05,91.84 20.63,91.84 CI7.1 RI27.1
HDMI_TX_P2: length 2.4
  TOP w0.112: RI25.1 CI9.1 18.31,89.79 LI4.3 17.26,89.62 RI12.1
HPOUT-L: length 3.8
  TOP w0.203: RA24.1 21.15,11.43 v3(21.89,12.16) 22.4,12.67 UA1.32
HPOUT-R: length 4
  TOP w0.203: RA27.1 21.03,10.66 22.63,12.27 UA1.33
HUB_BUSJ: length 9.2
  TOP w0.089: v3(220.95,60.74) 220.07,60.74 219.87,60.94 R64.2 R63.2 219.02,61.7 215.49,58.17 215.49,57.91 215.11,57.53 U58.19
HUB_OVCJ: length 3.1
  TOP w0.203: U58.26 213.7,53.08 212.92,53.86 C61.1 R58.2
HUB_VBUSM: length 5.5
  TOP w0.089: R61.2 218.19,61.7 217.82,61.33 217.82,60.87 215.11,58.16 U58.18
HUB_XIN: length 8.6
  TOP w0.203: C66.1 RC104.2 ; RC104.2 218.09,49.64 218.09,48.06 Y1.3 ; RC104.2 217.7,51.81 218.08,52.19 218.23,52.19 219.12,53.08 U58.3
HUB_XOUT: length 6
  TOP w0.203: U58.2 218.91,52.45 218.35,51.89 218.2,51.89 218,51.69 218,50.65 RC104.1 C65.1 219.41,48.88 Y1.1
HUB_XRSTJ: length 5.2
  TOP w0.089: U58.17 215.11,58.8 216.01,59.7 216.01,61.49 v3(216.23,61.7) R59.2
HW_ACAV_IN: length 268.4
  TOP w0.089: v1(40.42,75.84) 40.42,75.84 39.65,76.61 UE1.110 34.18,76.61 CE14.2 ; UV8.1 48.06,87.6 46.71,87.6 46.65,87.54 44.38,87.54 43.53,88.39 41.37,88.39 v1(40.63,87.65)
  TOP w0.254: PRB42.2 167.18,31.03 167.51,30.7 168.14,30.7 168.45,31.01 v1(168.45,31.22) 168.55,31.32 168.55,31.93 168.8,32.18 173.56,32.18 173.58,32.21 PR31.1 ; PUS02.2 56.8,126.44 56.27,126.97 v3(56.19,126.97) 55.43,126.97 54.8,127.61 v1(51,127.61)
  IN2 w0.089: v1(168.45,31.22) 168.39,31.15 168.39,31.03 168.17,30.82 167.46,30.82 166.9,31.38 163.5,31.38 162.51,30.39 162.3,30.39 162.05,30.13 154.59,30.13 149.69,35.03 147.04,35.03 146.58,34.58 146.56,34.58 146.3,34.32 135.76,34.32 135.45,34.01 134.34,34.01 134.14,34.21 131.08,34.21 130.52,33.66 129.89,33.66 124.88,28.65 121.41,28.65 120.55,29.51 117.12,29.51 116.26,28.65 114.89,28.65 114.32,29.21 110.31,29.21 109.74,28.65 100.06,28.65 99.83,28.87 97.34,28.87 96.82,28.35 84.32,28.35 83.16,29.52 67.26,29.52 66.54,30.24 62.41,30.24 61.67,29.51 61,29.51 60.49,30.03 60.49,31.16 54.31,37.33 50.68,37.33 47.62,40.39 47.62,44.21 45.9,45.93 45.9,50.99 43.82,53.07 43.82,54.11 39.57,58.36 39.57,59.16 39.37,59.36 39.37,65.68 39.33,65.72 39.33,67.46 39.94,68.07 39.94,69.47 40.94,70.47 40.94,71.19 40.77,71.36 40.77,72.88 41.01,73.12 41.01,74.94 40.42,75.53 v1(40.42,75.84) 40.42,76.67 40.73,76.98 40.73,78.21 41.39,78.87 41.39,80.48 40.74,81.13 40.74,81.69 39.6,82.84 38.77,82.84 38.08,83.53 38.08,86.61 39.04,87.56 40.54,87.56 v1(40.63,87.65) 40.83,87.65 40.93,87.76 40.93,88.65 42.09,89.81 42.09,94.44 41.71,94.83 41.71,96.64 42.09,97.02 42.09,111.18 42.57,111.66 42.57,114.93 45.99,118.35 46.62,118.35 48.74,120.47 48.74,122.6 50.49,124.35 50.49,126.11 50.33,126.27 50.33,126.94 v1(51,127.61)
HW_ACAVIN_NB: length 317.6
  TOP w0.089: UE1.108 36.6,77.41 36.91,77.09 40.16,77.09 40.93,76.32 v1(41.18,76.32)
  TOP w0.254: PRB40.1 164.6,37.01 163.87,37.75 162.9,37.75 162.07,36.91 v3(162.07,36.47) 161.85,36.24 161.85,33.14 v1(163,31.98) ; v1(50.39,119.38) 50.44,119.32 51.95,119.32 52.21,119.58 52.21,120.36 52.21,120.37 PRS40.1 52.21,121.1 52.15,121.15 PRS23.1 ; v1(48.03,116.45) 47.86,116.45 PRS39.2 ; PU2.2 v1(94.74,148.38) 92.81,148.38 PR46.1
  IN2 w0.089: v1(48.03,116.45) 46.64,117.85 46.01,117.85 42.94,114.78 42.94,111.51 42.46,111.03 42.46,96.87 42.07,96.49 42.07,94.98 42.46,94.6 42.46,89.66 41.3,88.5 41.3,87.52 41.18,87.4 41.18,86.4 41,86.22 38.82,86.22 38.44,85.84 38.44,83.68 38.92,83.2 39.75,83.2 41.11,81.84 41.11,81.28 41.76,80.63 41.76,78.71 41.1,78.06 41.1,76.4 v1(41.18,76.32) 41.28,76.32 41.37,76.23 41.37,72.96 41.14,72.73 41.14,71.52 41.31,71.34 41.31,70.31 40.92,69.93 40.92,68.18 40.78,68.03 40.78,64.83 39.82,63.87 39.82,63.04 39.74,62.95 39.74,59.51 40.04,59.21 40.04,58.41 44.19,54.27 44.19,53.22 46.27,51.15 46.27,46.09 47.99,44.36 47.99,40.54 50.76,37.77 54.39,37.77 60.85,31.31 60.85,30.18 61.16,29.87 61.52,29.87 62.25,30.61 66.76,30.61 67.4,29.96 84.57,29.96 85.74,28.79 96.74,28.79 97.18,29.23 99.99,29.23 100.21,29.01 109.59,29.01 110.16,29.58 116.41,29.58 116.89,30.06 120.77,30.06 121.07,29.76 125.48,29.76 129.74,34.02 130.37,34.02 130.93,34.58 134.29,34.58 134.49,34.38 135.3,34.38 135.6,34.68 146.15,34.68 146.86,35.4 146.88,35.4 149.84,35.4 154.74,30.49 161.89,30.49 163,31.6 v1(163,31.98)
  IN2 w0.254: v1(88.64,147.11) 88.64,147.7 87.84,148.5 87.05,148.5 86.31,147.75 82.85,147.75 80.64,145.54 78.18,145.54 74.32,141.68 72.25,141.68 71.08,140.5 62.82,140.5 60.3,137.98 56.25,137.98 54.61,136.35 54.61,132.83 53.39,131.61 53.39,128.3 50.82,125.74 50.82,119.81 v1(50.39,119.38) ; v1(94.74,148.38) 94.74,146.96 92.87,145.1 v1(92.87,143.34)
  IN3 w0.254: v1(88.64,147.11) 89.91,148.38 v1(94.74,148.38)
  BOTTOM w0.089: v1(50.39,119.38) 49.37,119.38 48.03,118.03 v1(48.03,116.45)
  BOTTOM w0.254: PR53.1 92.87,143.28 v1(92.87,143.34)
I2C_3_SCL: length 47.2
  TOP w0.089: v1(124.01,38.58) 124.15,38.44 124.15,33.7 123.01,32.56 123.01,29.73 123.14,29.6 v1(123.14,29.05) 123.14,28.03 v3(122.49,27.38) 122.37,27.26 120.52,27.26 120.31,27.47 RP4.2
  IN3 w0.089: 131.31,55.05 131.31,54.65 130.09,53.42 130.09,51.84 128.68,50.43 128.68,48.56 128.06,47.94 128.06,45.42 127.64,45 127.64,44.25 126.47,43.09 126.47,40.8 125.39,39.73 124.75,39.73 124.01,38.99 v1(124.01,38.58)
  IN3 w0.099: v1(132.1,61.75) 132.1,60.93 131.23,60.05 131.23,59.22 131.31,59.13 131.31,55.05
  BOTTOM w0.089: v1(123.14,29.05) 122.58,28.49 120.86,28.49 120.05,29.31 JTP1.6
  BOTTOM w0.102: v1(132.1,61.75) 132.1,61.84 UC1.AM9
I2C_3_SDA: length 44.8
  TOP w0.089: v1(119.32,27.74) 119.81,27.74 RP4.1 119.81,28.1 120.12,28.41 121.9,28.41 121.99,28.5 121.99,29.82 122.64,30.46 122.64,32.45 123.97,33.78 123.97,37.81 v1(123.68,38.1)
  IN3 w0.089: v1(123.68,38.1) 123.68,38.17 123.57,38.29 123.57,38.8 124.67,39.91 125.32,39.91 126.29,40.88 126.29,43.16 127.45,44.33 127.45,45.07 127.88,45.5 127.88,48.01 128.5,48.63 128.5,50.5 129.9,51.91 129.9,53.55 129.76,53.69 129.76,55.05
  IN3 w0.099: 129.76,55.05 129.76,55.77 130.23,56.24 130.23,59.75 130.63,60.14 130.63,61.07 v1(131.31,61.75)
  BOTTOM w0.089: JTP1.7 119.05,28.55 119.32,28.28 v1(119.32,27.74)
  BOTTOM w0.102: UC1.AM10 130.83,62.22 v1(131.31,61.75)
