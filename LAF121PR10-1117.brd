# Allegro board LAF121PR10-1117.brd (continued)
## Nets (continued)
DDR_B_DQ15: JDIMM2.37 UC1.B27
DDR_B_DQ16: JDIMM2.50 UC1.C30
DDR_B_DQ17: JDIMM2.49 UC1.E29
DDR_B_DQ18: JDIMM2.62 UC1.H29
DDR_B_DQ19: JDIMM2.63 UC1.H31
DDR_B_DQ20: JDIMM2.46 UC1.A28
DDR_B_DQ21: JDIMM2.45 UC1.D28
DDR_B_DQ22: JDIMM2.58 UC1.F31
DDR_B_DQ23: JDIMM2.59 UC1.G30
DDR_B_DQ24: JDIMM2.70 UC1.J29
DDR_B_DQ25: JDIMM2.71 UC1.J31
DDR_B_DQ26: JDIMM2.83 UC1.L29
DDR_B_DQ27: JDIMM2.84 UC1.L31
DDR_B_DQ28: JDIMM2.66 UC1.H30
DDR_B_DQ29: JDIMM2.67 UC1.H32
DDR_B_DQ30: JDIMM2.79 UC1.L30
DDR_B_DQ31: JDIMM2.80 UC1.L32
DDR_B_DQ32: JDIMM2.174 UC1.AP29
DDR_B_DQ33: JDIMM2.173 UC1.AP32
DDR_B_DQ34: JDIMM2.187 UC1.AT29
DDR_B_DQ35: JDIMM2.186 UC1.AU32
DDR_B_DQ36: JDIMM2.170 UC1.AN30
DDR_B_DQ37: JDIMM2.169 UC1.AP31
DDR_B_DQ38: JDIMM2.183 UC1.AR30
DDR_B_DQ39: JDIMM2.182 UC1.AT31
DDR_B_DQ40: JDIMM2.195 UC1.AU29
DDR_B_DQ41: JDIMM2.194 UC1.AV30
DDR_B_DQ42: JDIMM2.207 UC1.BB30
DDR_B_DQ43: JDIMM2.208 UC1.BA28
DDR_B_DQ44: JDIMM2.191 UC1.AU30
DDR_B_DQ45: JDIMM2.190 UC1.AU31
DDR_B_DQ46: JDIMM2.203 UC1.AY32
DDR_B_DQ47: JDIMM2.204 UC1.AY29
DDR_B_DQ48: JDIMM2.216 UC1.BA27
DDR_B_DQ49: JDIMM2.215 UC1.BC27
DDR_B_DQ50: JDIMM2.228 UC1.BA24
DDR_B_DQ51: JDIMM2.229 UC1.BC24
DDR_B_DQ52: JDIMM2.211 UC1.BD28
DDR_B_DQ53: JDIMM2.212 UC1.BB27
DDR_B_DQ54: JDIMM2.224 UC1.BB25
DDR_B_DQ55: JDIMM2.225 UC1.BD25
DDR_B_DQ56: JDIMM2.237 UC1.BC23
DDR_B_DQ57: JDIMM2.236 UC1.BB22
DDR_B_DQ58: JDIMM2.249 UC1.BC21
DDR_B_DQ59: JDIMM2.250 UC1.BD20
DDR_B_DQ60: JDIMM2.232 UC1.BB23
DDR_B_DQ61: JDIMM2.233 UC1.BA23
DDR_B_DQ62: JDIMM2.245 UC1.BB21
DDR_B_DQ63: JDIMM2.246 UC1.BA21
DDR_B_DQS0: JDIMM2.13 UC1.D22
DDR_B_DQS0#: JDIMM2.11 UC1.B22
DDR_B_DQS1: JDIMM2.34 UC1.D25
DDR_B_DQS1#: JDIMM2.32 UC1.B25
DDR_B_DQS2: JDIMM2.55 UC1.F29
DDR_B_DQS2#: JDIMM2.53 UC1.F30
DDR_B_DQS3: JDIMM2.76 UC1.K31
DDR_B_DQS3#: JDIMM2.74 UC1.K29
DDR_B_DQS4: JDIMM2.179 UC1.AR29
DDR_B_DQS4#: JDIMM2.177 UC1.AR31
DDR_B_DQS5: JDIMM2.200 UC1.AW30
DDR_B_DQS5#: JDIMM2.198 UC1.AW29
DDR_B_DQS6: JDIMM2.221 UC1.BC25
DDR_B_DQS6#: JDIMM2.219 UC1.BA25
DDR_B_DQS7: JDIMM2.242 UC1.BC22
DDR_B_DQS7#: JDIMM2.240 UC1.BA22
DDR_B_EVENT#: JDIMM2.134 RC1.2 UC1.AG29
DDR_B_MA0: JDIMM2.144 UC1.AG30
DDR_B_MA1: JDIMM2.133 UC1.AC32
DDR_B_MA2: JDIMM2.132 UC1.AC30
DDR_B_MA3: JDIMM2.131 UC1.AB29
DDR_B_MA4: JDIMM2.128 UC1.AB31
DDR_B_MA5: JDIMM2.126 UC1.AA30
DDR_B_MA6: JDIMM2.127 UC1.AA29
DDR_B_MA7: JDIMM2.122 UC1.Y30
DDR_B_MA8: JDIMM2.125 UC1.AA31
DDR_B_MA9: JDIMM2.121 UC1.W29
DDR_B_MA10: JDIMM2.146 UC1.AH29
DDR_B_MA11: JDIMM2.120 UC1.Y32
DDR_B_MA12: JDIMM2.119 UC1.W31
DDR_B_MA13: JDIMM2.158 UC1.AL30
DDR_B_MA14_WE#: JDIMM2.151 UC1.AK30
DDR_B_MA15_CAS#: JDIMM2.156 UC1.AK32
DDR_B_MA16_RAS#: JDIMM2.152 UC1.AJ30
DDR_B_ODT0: JDIMM2.155 UC1.AL31
DDR_B_ODT1: JDIMM2.161 UC1.AM32
DDR_B_PAR: JDIMM2.143 UC1.AG31
DDR_B_RST#: CD40.1 JDIMM2.108 UC1.T31
DEVSLP0_HDD: RC620.2 RS61.1 UC1.AP9
DEW1: RS4.1 RS18.1 US1.16
DEW2: RS3.1 RS17.1 US1.6
DGPU_PWROK: PRV20.2 PRW01.1 UE1.18
DISPOFF#: DX1.1 JEDP1.28 RP2.1
DP_STEREOSYNC: RC10.1 RC16.1 UC1.K15
DP_VSSR: UV1.AF19 UV1.AF20 UV1.AF23 UV1.AG14 UV1.AG23 UV1.AH14 UV1.AM14 UV1.AM16 UV1.AM18 UV1.AM20 UV1.AM22 UV1.AM24
DRAM_RST: RV36.1 UV12.J2 UV13.J2 UV14.J2 UV15.J2
DRAM_RST_G: CV97.1 RV37.1 RV38.1 UV1.L10
E51_RX1: JWLAN1.40 RW7.2
E51_TX1: JWLAN1.38 RW6.2 RW12.1
EC_ENVDD: RX9.2 UE1.71
EC_MUTE#: RA8.1 UA1.47 UE1.83
EC_ON: PR506.1 UE1.112
EC_PME#: RE23.2 RE37.2 UE1.29
EC_RSMRST#: CC12.1 CC15.1 CC16.1 CE16.1 RC54.2 RC61.2 UC1.AT16 UE1.100
EC_RST#: CE13.1 UE1.37
EC_RX: RW7.1 UE1.31
EC_SCI#: RE24.2 RE25.2 UC1.BA13 UE1.20
EC_SMB_CK1: PD5.3 PR42.2 PRB16.1 RE510.2 UE1.77
EC_SMB_CK2: Q11.3 QV1.6 RC24.2 RC616.1 UE1.79
EC_SMB_DA1: PD5.2 PR37.2 PRB14.1 RE509.2 UE1.78
EC_SMB_DA2: Q11.6 QV1.3 RC25.2 RC617.1 UE1.80
EC_TP_INT#: R12.1 UE1.106
EC_TX: RW6.1 UE1.30
ECAGND: CE8.2 CE11.1 LE2.2 PH1.2 UE1.69
EDP_AUXN: C4322.2 UC1.B9
EDP_AUXN_C: C4322.1 JEDP1.16
EDP_AUXP: C4321.2 UC1.D9
EDP_AUXP_C: C4321.1 JEDP1.15
EDP_HPD: R3.2 UC1.C10
EDP_HPD_R: JEDP1.12 R3.1 RP1.1
EDP_TXN0: C4311.2 UC1.A8
EDP_TXN0_C: C4311.1 JEDP1.18
EDP_TXN1: C4313.2 UC1.B8
EDP_TXN1_C: C4313.1 JEDP1.21
EDP_TXP0: C4312.2 UC1.C8
EDP_TXP0_C: C4312.1 JEDP1.19
EDP_TXP1: C4314.2 UC1.D8
EDP_TXP1_C: C4314.1 JEDP1.22
EN_0.6VSP: PCM16.1 PRM09.2 PRM12.2 PRM13.2 PUM01.7
EN_0.95V: PCF03.1 PRF01.2 PUF01.2
EN_1.2V: PCM15.1 PRM08.2 PRM12.1 PUM01.8
EN_1.8VALW: PC1805.1 PR1801.2 PR1802.1 PU1801.5
EN_2.5V: PC2503.1 PR2501.2 PU2501.2
EN_3V: PR502.1 PU301.12
EN_5V: PR503.1 PU501.12
EN_+1.35VGPU: PCW09.1 PRW01.2 PRW02.1 PUW01.6
EN_+VDDP: PCH09.1 PRH01.2 PRH02.1 PUH01.6
ENABLE_APU: PRZ19.2 PRZ47.2 PUZ01.8
ENABLE_VGA: PCV37.1 PRV15.2 PUV01.8
ENLDO_3V5V: PR302.1 PR303.1 PU301.11 PU501.11
ENVDD: RC4.1 RX8.2 UC5.4
ENVDD_R: D5.2 RPC1.7 UC1.F15 UC5.2
ENVDD_RE: RX8.1 RX9.1 U2.4
FAN_PWM: JFAN1.2 RF2.1 UE1.26
FAN_SPEED1: DF1.2 RF1.1 UE1.28
FB_1.2V: PCM17.1 PRM10.1 PRM11.1 PUM01.6
FB_1.8VALW: PC1807.2 PR1805.1 PR1807.2 PU1801.6
FB_+VDDP: PRH08.1 PRH09.1 PRH12.2 PUH01.10
FB__+1.35VGPU: PRW09.1 PRW10.1 PRW12.2 PUW01.10
FB_GND: RV158.2 UV1.AD20
FB_VDDC: RV159.2 UV1.AC20
FB_VDDCI: T64.1(TP-1) UV1.W1
FFS_INT1: RC6123.1 UC1.AR18 US4.12
FFS_INT2: QS1.2 RC6124.1 UC1.AT18 US4.11
FFS_INT2_Q: JHDD1.9 QS1.3 RS28.2
FPR_SCAN#: EU4012.3 JFP1.2 RE507.1 UE1.118
GPIO19_CTF: RV151.2 RV152.1 UV1.M2
GPIO28: RV21.2 UV1.R5
GPIO89: UC1.AW16 UC21.2
GPU_AC_LIGHT: RE36.1 UE1.68
H_PROCHOT#: PQ11.1 PQ12.3 PQS10.3 PRB19.1 PRZ15.2 PUZ01.4 RC26.2 RC661.2 RE43.2 UC1.L19
HDA_BIT_CLK: RC62.2 RPC4.8 RPC5.5 UC1.AR2
HDA_BIT_CLK_R: RA44.1 RPC4.1 UA1.6
HDA_RST#: C1.1 RPC4.5 RPC5.8 UC1.AP3
HDA_RST#_R: RA14.1 RPC4.4
HDA_SDIN0: RA43.2 RC60.2 UC1.AP7
HDA_SDIN0_R: RA43.1 UA1.8
HDA_SDIN1: RC58.2 UC1.AP1
HDA_SDIN2: RC59.2 UC1.AP4
HDA_SDOUT: RPC4.7 RPC5.6 UC1.AR3
HDA_SDOUT_R: RPC4.2 UA1.5
HDA_SYNC: RPC4.6 RPC5.7 UC1.AR4
HDA_SYNC_R: RPC4.3 UA1.10
HDD_A0_PRE0: RS7.2 RS23.1 US1.9
HDD_A0_PRE1: RS11.2 RS21.1 US1.19
HDD_B0_EQ: RS15.1 RS16.1 US1.13
HDD_B0_PRE0: RS8.2 RS19.1 US1.8
HDD_B0_PRE1: RS10.2 RS20.1 US1.17
HDD_EN#: UC1.AU7 US5.4
HDD_REXT_SATA0: RS6.2 RS24.1 US1.20
HDMI_CLKN: CI1.1 LI1.2 RI1.1 RI23.1
HDMI_CLKP: CI2.1 LI1.3 RI3.1 RI24.1
HDMI_CTRL_CLK: JHDMI1.15 QI3.6 RPI3.4
HDMI_CTRL_DATA: JHDMI1.16 QI3.3 RPI3.3
HDMI_HPD: CI10.1 JHDMI1.19 RI15.2 RI16.1
HDMI_L_CLKN: JHDMI1.12 LI1.1 RI1.2 RI2.1
HDMI_L_CLKP: JHDMI1.10 LI1.4 RI2.2 RI3.2
HDMI_L_TX_N0: JHDMI1.9 LI2.1 RI4.2 RI6.1
HDMI_L_TX_N1: JHDMI1.6 LI3.1 RI8.2 RI9.1
HDMI_L_TX_N2: JHDMI1.3 LI4.1 RI13.2 RI14.2
HDMI_L_TX_P0: JHDMI1.7 LI2.4 RI6.2 RI7.2
HDMI_L_TX_P1: JHDMI1.4 LI3.4 RI9.2 RI10.2
HDMI_L_TX_P2: JHDMI1.1 LI4.4 RI12.2 RI13.1
HDMI_TX_N0: CI4.1 LI2.2 RI4.1 RI21.1
HDMI_TX_N1: CI6.1 LI3.2 RI8.1 RI28.1
HDMI_TX_N2: CI8.1 LI4.2 RI14.1 RI26.1
HDMI_TX_P0: CI5.1 LI2.3 RI7.1 RI22.1
HDMI_TX_P1: CI7.1 LI3.3 RI10.1 RI27.1
HDMI_TX_P2: CI9.1 LI4.3 RI12.1 RI25.1
HPOUT-L: RA24.1 UA1.32
HPOUT-R: RA27.1 UA1.33
HUB_BUSJ: R63.2 R64.2 U58.19
HUB_OVCJ: C61.1 R58.2 U58.26
HUB_VBUSM: R61.2 U58.18
HUB_XIN: C66.1 RC104.2 U58.3 Y1.3
HUB_XOUT: C65.1 RC104.1 U58.2 Y1.1
HUB_XRSTJ: R59.2 U58.17
HW_ACAV_IN: CE14.2 PR31.1 PRB42.2 PUS02.2 UE1.110 UV8.1
HW_ACAVIN_NB: PR46.1 PR53.1 PRB40.1 PRS23.1 PRS39.2 PRS40.1 PU2.2 UE1.108
I2C_3_SCL: JTP1.6 RP4.2 UC1.AM9
I2C_3_SDA: JTP1.7 RP4.1 UC1.AM10
ILMT_+VDDP: PRH03.2 PRH04.1 PUH01.12
IMON_APU: PCZ25.2 PRZ20.2 PUZ01.10
IMON_NB: PCZ11.2 PRZ14.2 PUZ01.2
IMON_VGA: PCV20.1 PRV16.1 PUV01.10
INT#_TYPEC: RE506.1 UE1.102 UT1.15
INT-SPK-L+: LA3.1 UA1.42
INT-SPK-L-: LA4.1 UA1.43
INT-SPK-R+: LA1.1 UA1.45
INT-SPK-R-: LA2.1 UA1.44
INVTPWM: JEDP1.27 RC5.1 RP3.1 UC2.4
INVTPWM_R: UC1.L14 UC2.2
ISEN1_APU: PCZ28.1 PRZ42.2 PUZ01.13
ISEN1_VGA: PCV23.1 PRV22.2 PUV01.13
ISEN2_APU: PCZ27.1 PRZ22.2 PUZ01.12
ISEN2_VGA: PCV22.1 PRV03.2 PUV01.12
ISOLATEB: RL12.2 RL14.1 UL1.20
JACK_PLUG_DET: JHP1.6 RA30.1
JACK_SENSE#: JHP1.5 RA57.1
JACK_SENSE_1#: RA41.2 RA57.2
JHDD_P10: JHDD1.8 RS61.2
JTAG_TCK: RV369.1 UV1.L3
JTAG_TDI_GPU: RPV34.7 UV1.L5
JTAG_TDO_GPU: RPV34.8 UV1.K4
JTAG_TMS_GPU: RPV34.6 UV1.L1
JTAG_TRSTB: RPV34.5 UV1.L6
KB_BL_PWM: JKBBL1.4 Q3.1
KB_DET: JKBBL1.2 QE1.2 RE3.1
KB_DET#: QE1.1 RE2.1 UC1.BD15
KB_LED_PWM: Q3.2 UE1.25
KB_RST#: RC1707.2 UC1.BB11 UE1.2
KSI0: JKB1.22 UE1.55
KSI1: JKB1.24 UE1.56
KSI2: JKB1.26 UE1.57
KSI3: JKB1.23 UE1.58
KSI4: JKB1.27 UE1.59
KSI5: JKB1.25 UE1.60
KSI6: JKB1.28 UE1.61
KSI7: JKB1.29 UE1.62
KSO0: JKB1.13 UE1.39
KSO1: JKB1.15 UE1.40
KSO2: JKB1.14 UE1.41
KSO3: JKB1.16 UE1.42
KSO4: JKB1.20 UE1.43
KSO5: JKB1.21 UE1.44
KSO6: JKB1.18 UE1.45
KSO7: JKB1.19 UE1.46
KSO8: JKB1.17 UE1.47
KSO9: JKB1.7 UE1.48
KSO10: JKB1.5 UE1.49
KSO11: JKB1.6 UE1.50
KSO12: JKB1.12 UE1.51
KSO13: JKB1.9 UE1.52
KSO14: JKB1.8 UE1.53
KSO15: JKB1.10 UE1.54
KSO16: JKB1.11 UE1.81
LAN_MDIN0: TL1.9 UL1.2
LAN_MDIN1: TL1.15 UL1.5
LAN_MDIN2: TL2.15 UL1.7
LAN_MDIN3: TL2.9 UL1.10
LAN_MDIP0: TL1.10 UL1.1
LAN_MDIP1: TL1.16 UL1.4
LAN_MDIP2: TL2.16 UL1.6
LAN_MDIP3: TL2.10 UL1.9
LCD_TEST: RX15.1 UE1.72
LCD_TST_C: JEDP1.10 RX15.2
LG1_APU: PQZ03.6 PQZ04.6 PUZ01.24
LG1_CHG: PQB01.6 PUB01.9
LG1_VGA: PQV01.6 PQV02.6 PUV01.24
LG2_APU: PQZ01.6 PQZ02.6 PUZ01.27
LG2_CHG: PQB02.6 PUB01.7
LG2_VGA: PQV03.6 PQV04.6 PUV01.27
LG_1.2V: PQM01.8 PUM01.15
LG_NB: PQA01.6 PUZ01.34
LID_SW#: D1.1 EC1.1 JPWR1.3 RE17.2 UE1.115
LIMT_+1.35VGPU: PRW03.2 PRW04.1 PUW01.12
LINE1-L: CA37.1 UA1.22
LINE1-L_C: CA37.2 RA25.1
LINE1-L_R: CA38.2 RA28.1
LINE1-R: CA38.1 UA1.21
LM393_P: PC21.1 PCB44.2 PCS01.2 PDS01.1 PR21.1 PR50.1 PRB37.2 PRS43.1 PU2.5 PUB02.5 PUS01.8
LPC_AD0: RX29.1 T104.1(TP-1) UC1.BB12 UE1.10
LPC_AD1: RX30.1 T105.1(TP-1) UC1.BC11 UE1.8
LPC_AD2: RX31.1 T106.1(TP-1) UC1.BB15 UE1.7
LPC_AD3: RX32.1 T107.1(TP-1) UC1.BC15 UE1.5
LPC_CLK0_EC: RC449.1 RE14.1 T113.1(TP-1) UE1.12
LPC_FRAME#: RX34.1 T109.1(TP-1) UC1.BA12 UE1.4
LPC_RST_A#: RC602.1 UC1.BD11
LPCI_CLK_TPM: RX33.1 UC1.BB13
LPCPD#: RX37.1 T103.1(TP-1) UC1.BB14
LPCPD#_R: RX37.2 RX39.2 UX1.28
LX1_APU: PCZ48.2 PLZ03.1 PQZ03.7 PQZ04.7 PRZ44.1 PUZ01.23
LX1_CHG: PCB25.2 PLB01.1 PQB01.7 PRB17.1 PUB01.10
LX1_VGA: PCV21.2 PLV01.4 PQV01.7 PQV02.7 PRV23.1 PUV01.23
LX2_APU: PCZ24.2 PLZ02.1 PQZ01.7 PQZ02.7 PRZ23.1 PUZ01.28
LX2_CHG: PLB01.2 PQB02.7 PRB15.2 PRB18.1 PUB01.6
LX2_VGA: PCV08.2 PLV02.4 PQV03.7 PQV04.7 PRV06.1 PUV01.28
LX_1.2V: PCM12.2 PLM01.2 PQM01.9 PRM01.1 PUM01.16
LX_1.8VALW: PL1801.1 PR1804.1 PU1801.2 PU1801.3
LX_3V: PC307.2 PL301.1 PR305.1 PU301.6 PU301.19 PU301.20
LX_5V: PC507.2 PL501.1 PR505.1 PU501.6 PU501.19 PU501.20
LX_+1.35VGPU: PCW12.2 PLW01.1 PRW07.1 PUW01.2 PUW01.3
LX_+VDDP: PCH12.2 PLH01.1 PRH07.1 PUH01.2 PUH01.3
LX_NB: PCA07.2 PLA01.1 PQA01.7 PRA02.1 PUZ01.33
M0_MA0: UV1.K17 UV12.H4 UV13.K4
M0_MA1: UV1.J20 UV12.H5 UV13.K5
M0_MA2: UV1.H23 UV12.H11 UV13.K11
M0_MA3: UV1.G23 UV12.H10 UV13.K10
M0_MA4: UV1.G24 UV12.K11 UV13.H11
M0_MA5: UV1.H24 UV12.K10 UV13.H10
M0_MA6: UV1.J19 UV12.K5 UV13.H5
M0_MA7: UV1.K19 UV12.K4 UV13.H4
M0_MA8: UV1.G20 UV12.J5 UV13.J5
M1_MA0: UV1.J14 UV14.H4 UV15.K4
M1_MA1: UV1.K14 UV14.H5 UV15.K5
M1_MA2: UV1.J11 UV14.H11 UV15.K11
M1_MA3: UV1.J13 UV14.H10 UV15.K10
M1_MA4: UV1.H11 UV14.K11 UV15.H11
M1_MA5: UV1.G11 UV14.K10 UV15.H10
M1_MA6: UV1.J16 UV14.K5 UV15.H5
M1_MA7: UV1.L15 UV14.K4 UV15.H4
M1_MA8: UV1.G14 UV14.J5 UV15.J5
M_ADBI0: UV1.L18 UV12.J4 UV13.J4
M_ADBI1: UV1.K16 UV14.J4 UV15.J4
M_CAS#0: UV1.G19 UV12.L3 UV13.G3
M_CAS#1: UV1.G16 UV14.L3 UV15.G3
M_CKE0: UV1.K20 UV12.J3 UV13.J3
M_CKE1: UV1.J17 UV14.J3 UV15.J3
M_CLK0: RV79.2 UV1.H26 UV12.J12 UV13.J12
M_CLK1: RV85.2 UV1.G9 UV14.J12 UV15.J12
M_CLK#0: RV80.2 UV1.H25 UV12.J11 UV13.J11
M_CLK#1: RV86.2 UV1.H9 UV14.J11 UV15.J11
M_CS0B#0: UV1.H22 UV12.G12 UV13.L12
M_CS1B#0: UV1.G13 UV14.G12 UV15.L12
M_DA0: UV1.K27 UV13.A2
M_DA1: UV1.J29 UV13.B2
M_DA2: UV1.H30 UV13.A4
M_DA3: UV1.H32 UV13.B4
M_DA4: UV1.G29 UV13.F2
M_DA5: UV1.F28 UV13.F4
M_DA6: UV1.F32 UV13.E4
M_DA7: UV1.F30 UV13.E2
M_DA8: UV1.C30 UV12.M11
M_DA9: UV1.F27 UV12.T13
M_DA10: UV1.A28 UV12.N11
M_DA11: UV1.C28 UV12.T11
M_DA12: UV1.E27 UV12.N13
M_DA13: UV1.G26 UV12.U13
M_DA14: UV1.D26 UV12.M13
M_DA15: UV1.F25 UV12.U11
M_DA16: UV1.A25 UV12.F4
M_DA17: UV1.C25 UV12.B4
M_DA18: UV1.E25 UV12.E4
M_DA19: UV1.D24 UV12.A4
M_DA20: UV1.E23 UV12.B2
M_DA21: UV1.F23 UV12.E2
M_DA22: UV1.D22 UV12.A2
M_DA23: UV1.F21 UV12.F2
M_DA24: UV1.E21 UV13.M11
M_DA25: UV1.D20 UV13.M13
M_DA26: UV1.F19 UV13.N13
M_DA27: UV1.A19 UV13.N11
M_DA28: UV1.D18 UV13.U13
M_DA29: UV1.F17 UV13.T13
M_DA30: UV1.A17 UV13.U11
M_DA31: UV1.C17 UV13.T11
M_DA32: UV1.E17 UV15.U13
M_DA33: UV1.D16 UV15.U11
M_DA34: UV1.F15 UV15.T11
M_DA35: UV1.A15 UV15.T13
M_DA36: UV1.D14 UV15.N11
M_DA37: UV1.F13 UV15.M13
M_DA38: UV1.A13 UV15.M11
M_DA39: UV1.C13 UV15.N13
M_DA40: UV1.E11 UV14.B2
M_DA41: UV1.A11 UV14.A4
M_DA42: UV1.C11 UV14.A2
M_DA43: UV1.F11 UV14.B4
M_DA44: UV1.A9 UV14.E2
M_DA45: UV1.C9 UV14.F2
M_DA46: UV1.F9 UV14.F4
M_DA47: UV1.D8 UV14.E4
M_DA48: UV1.E7 UV14.M11
M_DA49: UV1.A7 UV14.N11
M_DA50: UV1.C7 UV14.T11
M_DA51: UV1.F7 UV14.M13
M_DA52: UV1.A5 UV14.U11
M_DA53: UV1.E5 UV14.N13
M_DA54: UV1.C3 UV14.U13
M_DA55: UV1.E1 UV14.T13
M_DA56: UV1.G7 UV15.F4
M_DA57: UV1.G6 UV15.E4
M_DA58: UV1.G1 UV15.E2
M_DA59: UV1.G3 UV15.F2
M_DA60: UV1.J6 UV15.A4
M_DA61: UV1.J1 UV15.B2
M_DA62: UV1.J3 UV15.A2
M_DA63: UV1.J5 UV15.B4
M_DBI0#: UV1.H27 UV13.D2
M_DBI1#: UV1.A27 UV12.P13
M_DBI2#: UV1.C23 UV12.D2
M_DBI3#: UV1.C19 UV13.P13
M_DBI4#: UV1.C15 UV15.P13
M_DBI5#: UV1.E9 UV14.D2
M_DBI6#: UV1.C5 UV14.P13
M_DBI7#: UV1.H4 UV15.D2
M_EDC_0: UV1.H28 UV13.C2
M_EDC_1: UV1.C27 UV12.R13
M_EDC_2: UV1.A23 UV12.C2
M_EDC_3: UV1.E19 UV13.R13
M_EDC_4: UV1.E15 UV15.R13
M_EDC_5: UV1.D10 UV14.C2
M_EDC_6: UV1.D6 UV14.R13
M_EDC_7: UV1.G5 UV15.C2
M_RAS#0: UV1.G22 UV12.G3 UV13.L3
M_RAS#1: UV1.G17 UV14.G3 UV15.L3
M_WCKA0_0: UV1.E32 UV12.P4 UV13.D4
M_WCKA0_0#: UV1.E30 UV12.P5 UV13.D5
M_WCKA0_1: UV1.A21 UV12.D4 UV13.P4
M_WCKA0_1#: UV1.C21 UV12.D5 UV13.P5
M_WCKA1_0: UV1.E13 UV14.D4 UV15.P4
M_WCKA1_0#: UV1.D12 UV14.D5 UV15.P5
M_WCKA1_1: UV1.E3 UV14.P4 UV15.D4
M_WCKA1_1#: UV1.F4 UV14.P5 UV15.D5
M_WE#0: UV1.G25 UV12.L12 UV13.G12
M_WE#1: UV1.H10 UV14.L12 UV15.G12
MCT0: RL9.1 TL2.3
MCT1: RL7.1 TL2.6
MCT2: RL19.1 TL1.3
MCT3: RL20.1 TL1.6
MEM_ERROR_A: UC1.AV8 UE1.1
MEM_ERROR_B: UC1.AN6 UE1.64
MIC1-L: CA56.1 UA1.19
MIC_CLK_C: LA10.2 RA19.1 UA1.3
MIC_DATA_C: RA55.2 UA1.2
MUX_SBU1: EU8.2 EU8.8 JUSBC1.A8 RT34.2 UT9.27
MUX_SBU2: EU8.4 EU8.7 JUSBC1.B8 RT60.2 UT9.26
MUX_USB2_FILP: UT1.5 UT10.9
NCT7718_DXN: C55.2 C56.2 Q10.3 U8.3
NCT7718_DXP: C55.1 C56.1 Q10.1 Q10.2 U8.2
ODD_DA#: JODD1.23 JODD1.24 T46.1(TP-1)
ON/OFF#: CE19.1 EC2.1 ED2.3 JPWR1.2 RE44.2 SW1.2 SW2.2 UE1.114
OTGEN/CMIN_CHG: PRB10.1 PRB13.1 PUB01.20
OVP_TRIP_P1: PQS03.2 QT5.2 RT63.1 UT1.14
PANEL_BKLEN: QC1.1 RC3.1 UE1.76
PANEL_BKLEN_EC: D6.2 QC1.3 RPC1.8 UC1.G15
PBTN_OUT#: RC53.2 UC1.AR15 UE1.122
PC_BEEP: DA3.1 RA49.2
PC_BEEP_C: CA47.1 CA57.2 RA45.2 RA49.1
PCH_PWR_EN: CC1193.1 UC20.4 UE1.107
PCIE_ARX_C_DTX_N4: CL8.2 UL1.18
PCIE_ARX_C_DTX_P4: CL7.2 UL1.17
PCIE_ARX_DTX_N0: JSSD1.41 UC1.N9
PCIE_ARX_DTX_N1: JSSD1.29 UC1.L9
PCIE_ARX_DTX_N2: JSSD1.17 UC1.M11
PCIE_ARX_DTX_N3: JSSD1.5 UC1.P11
PCIE_ARX_DTX_N4: CL8.1 UC1.V7
PCIE_ARX_DTX_N5: JWLAN1.43 UC1.T9
PCIE_ARX_DTX_P0: JSSD1.43 UC1.N10
PCIE_ARX_DTX_P1: JSSD1.31 UC1.L10
PCIE_ARX_DTX_P2: JSSD1.19 UC1.L12
PCIE_ARX_DTX_P3: JSSD1.7 UC1.P12
PCIE_ARX_DTX_P4: CL7.1 UC1.V6
PCIE_ARX_DTX_P5: JWLAN1.41 UC1.T8
PCIE_ATX_C_DRX_N0: CS46.2 JSSD1.47
PCIE_ATX_C_DRX_N1: CS45.2 JSSD1.35
PCIE_ATX_C_DRX_N2: CS48.2 JSSD1.23
PCIE_ATX_C_DRX_N3: CS51.2 JSSD1.11
PCIE_ATX_C_DRX_N4: CC2.2 UL1.14
PCIE_ATX_C_DRX_N5: CC4.2 JWLAN1.37
PCIE_ATX_C_DRX_P0: CS44.2 JSSD1.49
PCIE_ATX_C_DRX_P1: CS47.2 JSSD1.37
PCIE_ATX_C_DRX_P2: CS49.2 JSSD1.25
PCIE_ATX_C_DRX_P3: CS50.2 JSSD1.13
PCIE_ATX_C_DRX_P4: CC1.2 UL1.13
PCIE_ATX_C_DRX_P5: CC3.2 JWLAN1.35
PCIE_ATX_DRX_N0: CS46.1 UC1.P3
PCIE_ATX_DRX_N1: CS45.1 UC1.P2
PCIE_ATX_DRX_N2: CS48.1 UC1.R1
PCIE_ATX_DRX_N3: CS51.1 UC1.T2
PCIE_ATX_DRX_N4: CC2.1 UC1.W4
PCIE_ATX_DRX_N5: CC4.1 UC1.V2
PCIE_ATX_DRX_P0: CS44.1 UC1.N2
PCIE_ATX_DRX_P1: CS47.1 UC1.P4
PCIE_ATX_DRX_P2: CS49.1 UC1.R3
PCIE_ATX_DRX_P3: CS50.1 UC1.T4
PCIE_ATX_DRX_P4: CC1.1 UC1.W2
PCIE_ATX_DRX_P5: CC3.1 UC1.W3
PEG_ARX_C_GTX_N0: CV2.1 UV1.AG31
PEG_ARX_C_GTX_N1: CV4.1 UV1.AF28
PEG_ARX_C_GTX_N2: CV6.1 UV1.AF26
PEG_ARX_C_GTX_N3: CV8.1 UV1.AD26
PEG_ARX_C_GTX_P0: CV1.1 UV1.AH30
PEG_ARX_C_GTX_P1: CV3.1 UV1.AG29
PEG_ARX_C_GTX_P2: CV5.1 UV1.AF27
PEG_ARX_C_GTX_P3: CV7.1 UV1.AD27
PEG_ARX_GTX_N0: CV2.2 UC1.P9
PEG_ARX_GTX_N1: CV4.2 UC1.N7
PEG_ARX_GTX_N2: CV6.2 UC1.M9
PEG_ARX_GTX_N3: CV8.2 UC1.L7
PEG_ARX_GTX_P0: CV1.2 UC1.P8
PEG_ARX_GTX_P1: CV3.2 UC1.N6
PEG_ARX_GTX_P2: CV5.2 UC1.M8
PEG_ARX_GTX_P3: CV7.2 UC1.L6
PEG_ATX_C_GRX_N0: CV306.2 UV1.AE31
PEG_ATX_C_GRX_N1: CV305.2 UV1.AD28
PEG_ATX_C_GRX_N2: CV309.2 UV1.AC31
PEG_ATX_C_GRX_N3: CV304.2 UV1.AB28
PEG_ATX_C_GRX_P0: CV312.2 UV1.AF30
PEG_ATX_C_GRX_P1: CV308.2 UV1.AE29
PEG_ATX_C_GRX_P2: CV307.2 UV1.AD30
PEG_ATX_C_GRX_P3: CV313.2 UV1.AC29
PEG_ATX_GRX_N0: CV306.1 UC1.N3
PEG_ATX_GRX_N1: CV305.1 UC1.M4
PEG_ATX_GRX_N2: CV309.1 UC1.L4
PEG_ATX_GRX_N3: CV304.1 UC1.L3
PEG_ATX_GRX_P0: CV312.1 UC1.N1
PEG_ATX_GRX_P1: CV308.1 UC1.M2
PEG_ATX_GRX_P2: CV307.1 UC1.L2
PEG_ATX_GRX_P3: CV313.1 UC1.L1
PLL_ANALOG_IN: T65.1(TP-1) UV1.AA1
PLL_ANALOG_OUT: RV83.1 UV1.AA3
PLT_RST#: CC615.2 RC49.2 RC602.2 RC681.1 RL4.1 RW10.2 T114.1(TP-1) UE1.13 UX1.17
PLT_RST#_R: RL4.2 RL5.2 UL1.19
PLT_RST#_RW: JWLAN1.52 RW10.1 RW11.2
PLT_RST_VGA#: RV4.1 UV1.AL27 UV2.4
PM_SLP_S3#: RC618.2 RC631.2 UC1.AV13
PM_SLP_S3#_EC: RE30.2 UE1.6
PM_SLP_S3#_R: CE18.1 RC631.1 RE30.1
PM_SLP_S5#: CE17.1 RE50.1 T115.1(TP-1) UC1.AT14
PM_SLP_S5#_R: RE50.2 UE1.123
POK: PR35.1 PR304.2 PR504.2 PU301.9 PU501.9 RT113.2 UE1.34
PS_0: CV29.1 RV8.2 RV9.1 UV1.AC19
PS_1: CV28.1 RV11.2 RV12.1 UV1.AD19
PS_2: CV11.1 RV13.1 RV28.2 UV1.AE17
PS_3: CV15.1 RV15.2 RV16.1 UV1.AE20
PS_ID: PD2.1 PR1.2 PR5.1 UE1.16
PSID: PJPDC1.3 PL3.1
PSID-1: PQ2.2 PR3.2 PR6.1
PSID-3: PQ1.3 PR1.1
PTP_DIS#: JTP1.3 R11.2 UE1.19
PWR_SE2: PQS30.5 PQS30.6 PR63.2 PRS45.1
PWR_SELECT: PR64.2 PR65.2 PR66.1 UE1.14
PWR_SELECT1: PQS30.2 PR65.1 PU2.1
PWR_SELECT2: PQ15.2 PR21.2 PR46.2 PR49.1 PU2.4
PWRGD_VGA: PRV17.2 PRV20.1 PUV01.9 PUV01.20 UC1.BA17
PX_EN: T69.1(TP-1) UV1.AB16
PXS_PWREN: PRF01.1 PRV15.1 R23.1 R438.1 RC938.2 UC1.BC18
PXS_RST#: UC1.BB19 UV2.1
REGOUT: CL15.1 RL18.1 UL1.24
RING2: LA6.1 RA23.2 UA1.17
RING2_R: CA41.1 CA68.1 DA5.2 JHP1.4 LA6.2
RJ45_MDIN0: JRJ45.2 TL1.8
RJ45_MDIN1: JRJ45.6 TL1.2
RJ45_MDIN2: JRJ45.5 TL2.2
RJ45_MDIN3: JRJ45.8 TL2.8
RJ45_MDIP0: JRJ45.1 TL1.7
RJ45_MDIP1: JRJ45.3 TL1.1
RJ45_MDIP2: JRJ45.4 TL2.1
RJ45_MDIP3: JRJ45.7 TL2.7
RTC_CLK: RC1689.1 UC1.AW14
RTC_DET#: QC27.1 RC6130.2 UC1.AR6
RTC_DIS: Q9.2 R30.1 UE1.36
S0A3: CC94.1 RC619.1 UC1.AR8 UC9.1
S0A3_GPIO: PRM13.1 PRZ47.1 R702.1 R703.1 R704.1 R705.1 RC630.2 RW15.1 UC9.4 UE1.15
SATA_ACT#: Q26.2 R800.1 RC621.2 RE41.2 RS62.2 UC1.AV15
SATA_ACT#_R: Q17.3 Q26.3 R83.2 R800.2
SATA_ACT#_RR: RE39.2 RE41.1 UE1.117
SATA_ARX_C_DTX_N0: CS10.2 CS17.2 JHDD1.5
SATA_ARX_C_DTX_N1: CS23.2 JODD1.9 JODD1.10
SATA_ARX_C_DTX_P0: CS9.2 CS16.2 JHDD1.6
SATA_ARX_C_DTX_P1: CS22.2 JODD1.11 JODD1.12
SATA_ARX_C_RD_DTX_N0: CS6.2 US1.4
SATA_ARX_C_RD_DTX_P0: CS5.2 US1.5
SATA_ARX_DTX_N0: CS6.1 RS27.1 UC1.R7
SATA_ARX_DTX_N1: CS23.1 UC1.R10
SATA_ARX_DTX_P0: CS5.1 RS26.1 UC1.R6
SATA_ARX_DTX_P1: CS22.1 UC1.R9
SATA_ARX_RD_DTX_N0: CS10.1 US1.12
SATA_ARX_RD_DTX_P0: CS9.1 US1.11
SATA_ATX_C_DRX_N0: CS8.2 CS15.2 JHDD1.3
SATA_ATX_C_DRX_N1: CS19.2 JODD1.5 JODD1.6
SATA_ATX_C_DRX_P0: CS7.2 CS11.2 JHDD1.2
SATA_ATX_C_DRX_P1: CS18.2 JODD1.3 JODD1.4
SATA_ATX_C_RD_DRX_N0: CS4.2 US1.2
SATA_ATX_C_RD_DRX_P0: CS3.2 US1.1
SATA_ATX_DRX_N0: CS4.1 RS25.1 UC1.V3
SATA_ATX_DRX_N1: CS19.1 UC1.U4
SATA_ATX_DRX_P0: CS3.1 RS22.1 UC1.V1
SATA_ATX_DRX_P1: CS18.1 UC1.U2
SATA_ATX_RD_DRX_N0: CS8.1 US1.14
SATA_ATX_RD_DRX_P0: CS7.1 US1.15
SATA_LED#_R: Q17.2 R36.1 RE39.1
SATA_ODD_PRSNT#: JODD1.15 JODD1.16 RC6122.2 UC1.AW8 UE1.101
SATA_RX_N0: CS17.1 RS27.2
SATA_RX_P0: CS16.1 RS26.2
SATA_TX_N0: CS15.1 RS25.2
SATA_TX_P0: CS11.1 RS22.2
SERIRQ: RX35.1 T108.1(TP-1) UC1.BC12 UE1.3
SKU_ID: RC41.1 RC42.2 UC1.AU6
SLEEVE: LA9.1 RA22.2 UA1.18
SLEEVE_R: CA42.1 CA67.1 DA5.3 JHP1.3 LA9.2
SMU_ZVDDP: RC13.1 UC1.V4
SNUB1_CHG: PCB36.1 PRB17.2
SNUB2_CHG: PCB37.1 PRB18.2
SNUB_+1.35VGPU: PCW13.1 PRW07.2
SNUB_+VDDP: PCH13.1 PRH07.2
SPI_IRQ#: RX3.1 RX16.2 UC1.BA8
SPK_L+_CONN: CA55.1 DA1.2 JSPK1.3 LA3.2
SPK_L-_CONN: CA52.1 DA1.3 JSPK1.4 LA4.2
SPK_R+_CONN: CA30.1 DA2.2 JSPK1.1 LA1.2
SPK_R-_CONN: CA66.1 DA2.3 JSPK1.2 LA2.2
SSD_DEVSLP: JSSD1.38 RC663.2 UC1.AU10
SUSCLK_WLAN: JWLAN1.50 RC1689.2
SUSP#: PRM09.1 R24.1 R26.1 R27.1 UE1.116
SVI2_SVC: PUV01.3 RV84.1 RV89.2 RV157.2
SVI2_SVD: PUV01.5 RV87.1 RV88.2 RV155.2
SVI2_SVT: PUV01.7 RV156.2
SYS_RESET_L: CC14.1 RC48.1 RC52.1 UC1.AP10
SYSON: PR2501.1 PRM08.1 UE1.95
T-GND_L: CL10.1 RL7.2 RL9.2 RL19.2 RL20.2
T_CRIT#: R34.2 U8.4
TESTEN: RV17.2 RV154.2 UV1.K7
THERMTRIP#: RC664.2 UC1.AP16 UE1.17
THM_SML1_CLK: C57.1 Q11.4 R32.2 U8.8
THM_SML1_DATA: C58.1 Q11.1 R31.2 U8.7
TON_1.2V: PRM07.2 PUM01.9
TOP_MUX_N: EU7.1 EU7.9 LT1.3 RT10.1 UT10.4
TOP_MUX_N_R: JUSBC1.A7 LT1.4 RT10.2
TOP_MUX_P: EU7.2 EU7.8 LT1.2 RT9.1 UT10.3
TOP_MUX_P_R: JUSBC1.A6 LT1.1 RT9.2
TP_CLK: C20.1 JTP1.1 R13.1 UE1.87
TP_DATA: C21.1 JTP1.2 R14.1 UE1.88
TP_EN: R17.1 UE1.82
TP_I2C_INT#: JTP1.4 Q1.3 R10.2 R12.2 RP4.3
TP_I2C_INT#_APU: Q1.1 R10.1 RC36.1
TP_ON#_GATE: C22.2 Q2.2 Q4.2 R17.2
TPM_20: RX5.2 RX13.2 RX34.2 UX1.20
TPM_24: RX1.2 RX14.2 RX29.2 UX1.24
TS_EN_R: D1.2 RX25.2
TS_EN_RR: JEDP1.39 RX25.1
TYPEC_CFG0: RT22.2 RT45.1 UT9.3
TYPEC_CFG1: RT21.2 RT44.1 UT9.4
TYPEC_CLK: RT72.2 UE1.85 UT1.17
TYPEC_CTL0: RT30.2 RT53.1 RT55.1 UT9.22
TYPEC_CTL1: RT20.2 RT43.1 UT9.23
TYPEC_DEQ0: RT25.2 RT48.1 UT9.38
TYPEC_DEQ1: RT24.2 RT47.1 UT9.29
TYPEC_DIR0: RT28.2 RT51.1 UT9.8
TYPEC_DIR1: RT27.2 RT50.1 UT9.11
TYPEC_FLIP: RT29.2 RT52.1 RT54.1 UT9.21
TYPEC_I2C_EN#: RT17.2 RT40.1 UT9.17
TYPEC_ID: RE8.1 RE11.2 UE1.97
TYPEC_SDA: RT73.2 UE1.86 UT1.16
TYPEC_SWAP: RT26.2 RT49.1 UT9.5
TYPEC_TI_EN#: CT46.1 RT31.1 RT61.1 UT9.7
TYPEC_UEQ0/A0: RT19.2 RT42.1 UT9.35
TYPEC_UEQ1/A1: RT18.2 RT41.1 UT9.2
TYPEC_USBC_SCL: QT6.1 RT36.2 RT54.2
TYPEC_USBC_SDA: QT6.4 RT37.2 RT55.2
TYPEC_VIO_SEL: RT23.2 RT46.1 UT9.14
UART0_CTS#: T118.1(TP-1) UC1.BA18
UART0_INTR: T119.1(TP-1) UC1.BD18
UART0_RTS#: T117.1(TP-1) UC1.BC17
UART0_RXD: T101.1(TP-1) UC1.BA16
UART0_TXD: T102.1(TP-1) UC1.BB18
UG1_APU: PQZ03.1 PQZ04.1 PUZ01.22
UG1_CHG: PQB01.1 PUB01.11
UG1_VGA: PQV01.1 PQV02.1 PUV01.22
UG2_APU: PQZ01.1 PQZ02.1 PUZ01.29
UG2_CHG: PQB02.1 PUB01.5
UG2_VGA: PQV03.1 PQV04.1 PUV01.29
UG_1.2V: PQM01.1 PUM01.17
UG_NB: PQA01.1 PUZ01.32
USB3_ARX_C_DTX_0_N1: CU39.1 LU1.3 RU2.1
USB3_ARX_C_DTX_0_N2: CU40.1 LU4.3 RU7.1
USB3_ARX_C_DTX_0_P1: CU38.1 LU1.2 RU1.1
USB3_ARX_C_DTX_0_P2: CU41.1 LU4.2 RU8.1
USB3_ARX_DTX_0_N1: CU39.2 UC1.AJ8
USB3_ARX_DTX_0_N1_R: EU3.1 EU3.9 JUSB1.5 LU1.4 RU2.2
USB3_ARX_DTX_0_N2: CU40.2 UC1.AG6
USB3_ARX_DTX_0_N2_R: EU5.1 EU5.9 JUSB2.5 LU4.4 RU7.2
USB3_ARX_DTX_0_P1: CU38.2 UC1.AJ9
USB3_ARX_DTX_0_P1_R: EU3.2 EU3.8 JUSB1.6 LU1.1 RU1.2
USB3_ARX_DTX_0_P2: CU41.2 UC1.AG7
USB3_ARX_DTX_0_P2_R: EU5.2 EU5.8 JUSB2.6 LU4.1 RU8.2
USB3_ATX_C_DRX_0_N1: CU7.1 LU2.3 RU3.1
USB3_ATX_C_DRX_0_N2: CU15.1 LU5.3 RU9.1
USB3_ATX_C_DRX_0_P1: CU8.1 LU2.2 RU4.1
USB3_ATX_C_DRX_0_P2: CU16.1 LU5.2 RU10.1
USB3_ATX_DRX_0_N1: CU7.2 UC1.AG1
USB3_ATX_DRX_0_N2: CU15.2 UC1.AG2
USB3_ATX_DRX_0_P1: CU8.2 UC1.AG3
USB3_ATX_DRX_0_P2: CU16.2 UC1.AG4
USB3_ATX_L_DRX_0_N1: EU3.4 EU3.7 JUSB1.8 LU2.4 RU3.2
USB3_ATX_L_DRX_0_N2: EU5.4 EU5.7 JUSB2.8 LU5.4 RU9.2
USB3_ATX_L_DRX_0_P1: EU3.5 EU3.6 JUSB1.9 LU2.1 RU4.2
USB3_ATX_L_DRX_0_P2: EU5.5 EU5.6 JUSB2.9 LU5.1 RU10.2
USB3_DP3_MRX_C_RD_DTX_N0: CT38.2 UT9.10
USB3_DP3_MRX_C_RD_DTX_N3: CT40.2 UT9.18
USB3_DP3_MRX_C_RD_DTX_P0: CT37.2 UT9.9
USB3_DP3_MRX_C_RD_DTX_P3: CT39.2 UT9.19
USB3_DP3_MRX_DTX_N0: CT38.1 UC1.AE1
USB3_DP3_MRX_DTX_N3: CT40.1 UC1.AC4
USB3_DP3_MRX_DTX_P0: CT37.1 UC1.AE3
USB3_DP3_MRX_DTX_P3: CT39.1 UC1.AC2
USB3_DP3_MRX_L_DTX_N0: DT5.1 JUSBC1.A10 LU16.3 RT111.1
USB3_DP3_MRX_L_DTX_N3: DT8.1 JUSBC1.B10 LU15.2 RT109.1
USB3_DP3_MRX_L_DTX_P0: DT6.1 JUSBC1.A11 LU16.2 RT110.1
USB3_DP3_MRX_L_DTX_P3: DT7.1 JUSBC1.B11 LU15.3 RT108.1
USB3_DP3_MRX_RD_DTX_N0: LU16.4 RT111.2 UT9.39
USB3_DP3_MRX_RD_DTX_N3: LU15.1 RT109.2 UT9.31
USB3_DP3_MRX_RD_DTX_P0: LU16.1 RT110.2 UT9.40
USB3_DP3_MRX_RD_DTX_P3: LU15.4 RT108.2 UT9.30
USB3_DP3_MTX_C_DRX_N1: CT60.2 LU14.2 RT106.1
USB3_DP3_MTX_C_DRX_N2: CT59.2 LU13.3 RT105.1
USB3_DP3_MTX_C_DRX_P1: CT61.2 LU14.3 RT107.1
USB3_DP3_MTX_C_DRX_P2: CT58.2 LU13.2 RT104.1
USB3_DP3_MTX_C_RD_DRX_N1: CT42.2 UT9.13
USB3_DP3_MTX_C_RD_DRX_N2: CT44.2 UT9.15
USB3_DP3_MTX_C_RD_DRX_P1: CT41.2 UT9.12
USB3_DP3_MTX_C_RD_DRX_P2: CT43.2 UT9.16
USB3_DP3_MTX_DRX_N1: CT42.1 UC1.AF2
USB3_DP3_MTX_DRX_N2: CT44.1 UC1.AD4
USB3_DP3_MTX_DRX_P1: CT41.1 UC1.AF4
USB3_DP3_MTX_DRX_P2: CT43.1 UC1.AD2
USB3_DP3_MTX_L_DRX_N1: DT9.1 JUSBC1.B3 LU14.1 RT106.2
USB3_DP3_MTX_L_DRX_N2: DT4.1 JUSBC1.A3 LU13.4 RT105.2
USB3_DP3_MTX_L_DRX_P1: DT10.1 JUSBC1.B2 LU14.4 RT107.2
USB3_DP3_MTX_L_DRX_P2: DT3.1 JUSBC1.A2 LU13.1 RT104.2
USB3_DP3_MTX_RD_DRX_N1: CT60.1 UT9.36
USB3_DP3_MTX_RD_DRX_N2: CT59.1 UT9.34
USB3_DP3_MTX_RD_DRX_P1: CT61.1 UT9.37
USB3_DP3_MTX_RD_DRX_P2: CT58.1 UT9.33
USB20_0_N0: UC1.AE6 UT10.7
USB20_0_N1: LU3.2 RU6.1 UC1.AG9
USB20_0_N1_R: EU2.3 JUSB1.2 LU3.1 RU6.2
USB20_0_N2: LU6.3 RU12.1 UC1.AF11
USB20_0_N2_R: EU4.3 JUSB2.2 LU6.4 RU12.2
USB20_0_N3: L1.4 R8.1 UC1.AE9
USB20_0_N3_R: JEDP1.33 L1.3 R8.2
USB20_0_P0: UC1.AE7 UT10.8
USB20_0_P1: LU3.3 RU5.1 UC1.AG10
USB20_0_P1_R: EU2.2 JUSB1.3 LU3.4 RU5.2
USB20_0_P2: LU6.2 RU11.1 UC1.AF12
USB20_0_P2_R: EU4.2 JUSB2.3 LU6.1 RU11.2
USB20_0_P3: L1.1 R7.1 UC1.AE10
USB20_0_P3_R: JEDP1.34 L1.2 R7.2
USB20_1_N0: LU8.3 RU16.1 UC1.AJ11
USB20_1_N0_R: JIOB1.7 LU8.4 RU16.2
USB20_1_N1: RC103.2 UC1.AD8
USB20_1_N1_R: RC103.1 U58.15
USB20_1_P0: LU8.2 RU15.1 UC1.AJ12
USB20_1_P0_R: JIOB1.6 LU8.1 RU15.2
USB20_1_P1: RC102.2 UC1.AD9
USB20_1_P1_R: RC102.1 U58.16
USB20_CR_N1: LU7.3 RU14.1 U58.10
USB20_CR_N1_R: JIOB1.4 LU7.4 RU14.2
USB20_CR_P1: LU7.2 RU13.1 U58.11
USB20_CR_P1_R: JIOB1.3 LU7.1 RU13.2
USB20_FP_N3: DU2.3 JFP.4 JFP1.6 U58.6
USB20_FP_P3: DU2.2 JFP.3 JFP1.5 U58.7
USB20_MINI1_N4: JWLAN1.5 U58.4
USB20_MINI1_P4: JWLAN1.3 U58.5
USB20_TOUCH_N2: DX3.3 JEDP1.36 U58.8
USB20_TOUCH_P2: DX3.2 JEDP1.37 U58.9
USB_EN#: CU9.1 CU20.1 RE18.1 UE1.84 UI1.4 UU1.4
USB_OC0#: CU10.1 RC905.2 UC1.AK10 UI1.3
USB_OC1#: CU19.1 RC906.2 UC1.AK9 UU1.3
USB_OC2#: RC6121.2 UC1.AL9 UT8.3
USBC_B2B_OVP: PQS03.5 PQS03.6 PRS13.2
USBC_B2B_S1: PDS04.1 PDS05.1 PDS06.1 PQS08.2 PRS42.1
USBC_B2B_S1_A: PCS11.1 PQS03.3 PQS04.2 PQS08.1 PRS12.2 PRS14.1
USBC_B2B_S2: PCS12.1 PQS05.2 PQS05.3 PQS62.2 PRS25.1 PUS02.4
USBC_B2B_S2_G: PCS10.2 PQS02.4 PQS06.1 PRS09.2 PRS16.1
USBC_B2B_S3: PCS17.1 PQS07.2 PRS18.1
USBC_SW_PROCHOT: PCS19.1 PCS20.1 PQS10.6 PRS28.2
VBIOS_ID1: RC711.2 RC712.1 UC1.BD13
VCIN0_PH: PH1.1 PR52.1 UE1.109
VCOUT0: RE35.1 UE1.104
VCOUT0_PH#: PR507.1 RE35.2
VCOUT1_PH: RE43.1 UE1.103
VGA_AC__BATT: RV150.1 RV260.2 UV1.T9 UV8.4
VGA_SMB_CK3: QV1.1 RV6.2 UV1.U7
VGA_SMB_DA3: QV1.4 RV5.2 UV1.U8
VGATE: PRH19.1 PRZ24.2 PUZ01.20 RC28.1 UE1.74
VL: PC515.1 PU501.15
VR_ON: PRZ19.1 UE1.121
VSUM+_APU: PCZ32.1 PCZ34.1 PRZ27.1 PRZ32.1 PRZ33.1 PRZ45.1 PUZ01.14
VSUM+_VGA: PCV28.1 PCV30.1 PRV07.2 PRV24.2 PRV28.1 PRV30.1 PUV01.14
VSUM-_APU: PCZ27.2 PCZ28.2 PCZ32.2 PCZ34.2 PCZ46.1 PHZ02.2 PRZ28.1 PRZ33.2 PRZ36.1 PRZ39.1 PRZ46.1
VSUM-_VGA: PCV22.2 PCV23.2 PCV28.2 PCV30.2 PCV32.1 PHV02.2 PRV08.2 PRV25.2 PRV30.2 PRV33.1 PRV35.1
VSUMN_NB: PCZ06.2 PCZ07.2 PCZ08.1 PHA01.2 PRA04.1 PRZ09.2 PRZ10.1 PRZ11.1
VSUMP_NB: PCZ06.1 PCZ07.1 PRA03.1 PRZ08.1 PRZ09.1 PUZ01.40
VTTREF_1.2V: PCM19.1 PUM01.4
WAKEB: RV162.2 RV163.1 UV1.AJ27
WL_OFF#: QW1.3 RC46.2 UC1.BB16
WL_OFF#_R: JWLAN1.56 QW1.1 RW8.2
WLAN_EN: RW14.2 UE1.73 UW1.4
WLAN_WAKE#: JWLAN1.55 RE19.2 RW15.2 UE1.90
WOL_EN: RL2.2 RL16.1 RL17.1 UE1.98 UL2.4
XTALIN: CV17.1 RV24.1 UV1.AM28 YV1.1
XTALOUT: CV18.1 RV24.2 UV1.AK28 YV1.3
XTLI: CL11.1 UL1.28 YL1.1
XTLO: CL12.1 UL1.29 YL1.3
N16741477: T49.1(TP-1) UV1.AB8
N16741489: T56.1(TP-1) UV1.AD7
N16741505: T60.1(TP-1) UV1.AB4
N16741517: T55.1(TP-1) UV1.AD9
N16741525: T62.1(TP-1) UV1.Y8
N16741803: RV29.2 UV1.AC22
N16741825: RV59.2 UV1.AB22
N16751828: T48.1(TP-1) UV1.AC8
N16751830: T54.1(TP-1) UV1.AE8
N16751834: T52.1(TP-1) UV1.AE9
N16751836: T50.1(TP-1) UV1.N9
N16751838: T61.1(TP-1) UV1.AB2
N16751842: T58.1(TP-1) UV1.AB9
N16751844: T47.1(TP-1) UV1.AC10
N16751848: T51.1(TP-1) UV1.L9
N16751852: T59.1(TP-1) UV1.AB7
N16751854: T57.1(TP-1) UV1.AC7
N16751856: T53.1(TP-1) UV1.Y11
N16751858: T63.1(TP-1) UV1.Y7
N16808781: RV157.1 UV1.AJ11
N16808782: RV155.1 UV1.AK12
N16808783: RV156.1 UV1.AL11
N16813004: RV71.2 RV84.2 RV87.2
N17072999: C28.1 U4.12
N17205184: RS9.2 US1.7
N17205187: RS12.2 RS13.2 US1.18
N17205206: RS5.2 US1.10
N17213597: CT8.1 UT1.33
N17389450: PC516.1 PD501.2 PR502.2 PR503.2 PR506.2 PR508.1
N17847259: T68.1(TP-1) UV1.AL9
N17877344: T66.1(TP-1) UV1.R1
N17877347: T67.1(TP-1) UV1.R3
N19609367: QI2.2 RI15.1
N20141258: PRZ13.2 PUZ01.1
N20141272: PHZ01.2 PRZ25.2 PRZ26.1
N20141325: PCZ03.2 PRZ07.1
N20141337: PCZ04.1 PRZ01.2 PRZ03.2 PRZ04.1 PRZ07.2 PUZ01.37
N20141361: PCZ03.1 PCZ05.2 PRZ03.1 PRZ06.2 PUZ01.38
N20141372: PCZ47.2 PRZ36.2 PUZ01.15
N20141380: PCZ09.1 PRZ11.2
N20141402: PCZ47.1 PRZ39.2
N20141406: PCZ22.1 PRZ17.1 PUZ01.25
N20141448: PCZ09.2 PRZ10.2 PUZ01.39
N20141457: PLA01.2 PRA03.2
N20141459: PLA01.3 PRA04.2
N20141467: PLZ03.3 PRZ46.2
N20141469: PLZ03.2 PRZ42.1 PRZ45.2
N20141477: PCA08.1 PRA02.2
N20141501: PRZ26.2 PUZ01.11
N20141511: PCZ29.1 PCZ31.1 PRZ31.1 PRZ38.1 PUZ01.16
N20141517: PCZ49.1 PRZ40.1 PUZ01.17
N20141713: PCZ02.2 PCZ04.2 PRZ05.1 PUZ01.36
N20141719: PCZ50.1 PRZ44.2
N20141862: PCZ02.1 PRZ04.2
N20141864: PCZ01.2 PRZ01.1
N20141906: PCZ30.1 PRZ29.2 PRZ31.2 PRZ34.1 PRZ35.1 PUZ01.18
N20141912: PCZ29.2 PRZ29.1
N20141916: PCZ42.1 PRZ35.2
N20141920: PCZ30.2 PCZ33.2 PRZ30.1 PUZ01.19
N20141926: PCZ33.1 PRZ34.2
N20142021: PHA01.1 PRZ08.2
N20142108: PHZ02.1 PRZ32.2
N20142189: PHA02.2 PRZ12.2 PRZ13.1
N21022260: PCA07.1 PRA01.2
N21022300: PCZ48.1 PRZ41.2
N21379353: PC508.1 PU501.16 PU501.17
N21513882: PD10.3 PR14.2 PR16.1
N21533617: PQS05.5 PUS03.4
N21533620: PQS06.2 PRS10.2 PRS15.1
N21537645: PQ17.1 PR48.2
N21556764: PCS19.2 PQS10.5 PRS29.1
N21558641: PCS20.2 PQS11.2 PRS30.1
N21562486: PDS06.2 PRS23.2
N21562772: PDB05.2 PRB44.2
N21562775: PDB04.1 PDB05.1 PUB02.1
N21563532: PDS05.2 PRS33.2
N21563639: PDS04.2 PRS32.2
N21741311: PQS12.1 PRS37.2
N21741314: PQS13.2 PRS36.2 PRS37.1
N21741394: PQS12.2 PRS38.2
N21741482: PCS09.1 PCS61.1 PJPS01.2 PQS01.1 PQS01.2 PQS01.3 PQS13.3 PQS61.1 PQS61.2 PQS61.3 PQS63.3 PRS08.1 PRS36.1 PRS62.1 PRS63.1
N21741739: PCS09.2 PQS01.4 PQS13.1 PRS08.2 PRS11.1
N22643329: T43.1(TP-1) UL1.27
N22643331: T44.1(TP-1) UL1.25
N22643429: RL8.2 UL1.31
N22643935: RL6.2 RL17.2 UL1.26
N22649665: JKB1.30 RE4.2
N22657623: CA17.1 RA56.1 UA1.9
N22661096: CA19.2 RA13.1 UA1.27
N22661869: CA20.2 UA1.39
N22662054: CA21.2 UA1.7
N22663765: CA23.1 UA1.28
N22664360: CA24.2 UA1.37
N22664751: CA24.1 UA1.35
N22664968: CA54.2 UA1.34
N22673637: QA1.3 RA53.2 RA58.1
N22675171: CA31.1 RA44.2
N22737223: RL1.2 UL2.3
N23465138: CV25.1 RV164.2 RV165.1 UV8.5
N23821471: C38.1 U6.12
N23827049: JKB1.1 R20.2 R21.1
N24106209: C22.1 Q2.3 R15.2
N24106231: Q4.1 R16.1
N24142380: DF1.1 JFAN1.3 RF3.1
N24551788: C41.2 U6.10
N24554309: C27.1 U3.10
N24718506: RA14.2 UA1.11
N24718549: CA47.2 UA1.12
N24988789: RT119.1 UT10.6
N25136253: RX7.2 U2.3
N26502042: RC17.1 UC1.AW11
N26503230: T2.1(TP-1) UC1.F14
N26503233: T3.1(TP-1) UC1.F12
N26503236: T4.1(TP-1) UC1.F10
N26513758: RC449.2 UC1.BA15
N26545373: U58.12 U58.28
N26545412: R65.1 U58.14
N26926732: RX2.2 RX30.2 UX1.21
N26926735: RX4.2 RX33.2 UX1.19
N26926835: RX3.2 RX31.2 UX1.18
N26926873: RX6.2 RX35.2 UX1.27
N26928013: QS1.5 QS1.6 RS29.2
N26936819: RT130.1 UT10.10
N27108733: CT45.2 RT101.2 UT9.24
N27108736: CT47.2 RT35.2 UT9.25
N27221272: CA49.1 RA19.2
N27367990: C636.1 RC680.2
N27535100: RE12.2 UE1.111
N27535635: CE12.1 RE14.2
N27633672: CT17.1 DT2.2 RT134.1 UT4.5
N27633678: CT53.1 QT4.1 RT112.2 UT4.3 UT4.4
N27633690: CT54.1 QT4.2 RT113.1
N27634822: QT3.1 RT33.2
N27636003: QT5.3 RT62.1 UT8.4
N27700832: QI1.1 RI21.2 RI22.2 RI23.2 RI24.2 RI25.2 RI26.2 RI27.2 RI28.2
N27708054: C24.1 U3.12
N27906658: RH22.2 T120.1(TP-1)
N27906903: RH23.2 T121.1(TP-1)
N27907005: RH24.2 T122.1(TP-1)
N27917496: T112.1(TP-1) UC1.BC6
N28062813: CA57.1 UA1.16
N28203970: LED1.4 R68.1
N28203972: LED1.2 R69.1
N28205898: RS60.1 US5.3
N28206848: RW13.2 UW1.3
N28207892: R300.1 U5.3
N28296708: CC95.1 RC618.1 UC9.2
N28502853: PDS03.2 PRS40.2
N28502856: PDS03.3 PRS41.2
N28577025: RX28.2 UX1.3
N28577921: RX32.2 UX1.15
N28579184: T116.1(TP-1) UX1.29
N28580789: PD11.1 PR63.1
N28580920: PQS30.3 PR61.2 PR62.1 PU1.4
N28582416: PRS02.1 PRS43.2 PRS44.1
N28583343: PDS03.1 PRS42.2 PUS03.2
N28583360: PQS14.1 PRS18.2 PRS34.2 PRS45.2
N28583366: PQS14.2 PRS35.1
N28592761: PRH08.2 PRH10.2 PRH13.1
N28593397: PCH18.2 PCH19.2 PQH01.2 PRH15.1
N28593401: PCH18.1 PQH01.1 PRH13.2
N28593455: PQH02.3 PRH15.2 PRH16.2 PRH17.1
N28618638: PCS61.2 PQS61.4 PQS63.1 PRS61.1 PRS62.2
N28618644: PQS63.2 PRS63.2 PRS66.1
N28618652: PRS64.2 PRS65.2
N28618683: PQS64.1 PRS66.2
N28618685: PQS62.1 PRS61.2
N28618689: PCS62.1 PQS64.2 PRS64.1
N28639206: PRB41.2 PUB02.2
N28737012: PCH20.1 PQH02.2 PRH19.2
N28737022: PQH02.5 PQH02.6 PRH18.2
N29197780: RC6127.1 UC20.3
N30021424: JSSD1.10 RS62.1
N30021591: Q26.5 Q26.6 R82.2
N30684242: CT45.1 RT132.1
N30684245: CT47.1 RT133.1
N32433695: RV120.1 UV14.J13
N32433703: RV116.1 UV14.J1
N32433714: RV118.1 UV14.J10
N32434049: RV121.1 UV15.J13
N32434050: RV117.1 UV15.J1
N32434053: RV119.1 UV15.J10
N32437553: RV123.1 UV12.J13
N32437559: RV132.1 UV13.J13
N32437560: RV131.1 UV13.J1
N32437563: RV133.1 UV13.J10
N37640332: RV2.2 UV1.N10
N37640410: RV3.1 UV1.AA22
N37828209: RV1.1 UV1.Y22
N38038746: CV96.1 RV36.2 RV37.2
N38038992: CV98.2 UV1.K8
N38038994: CV99.2 UV1.L7
N38038995: CV98.1 RV40.2
N38038996: CV99.1 RV41.2
N38349725: RV39.2 UV1.K25
N38996077: RV134.1 UV12.J1
N38996080: RV135.1 UV12.J10
N40598435: PC307.1 PR301.2
N40598500: PC507.1 PR501.2
N40598503: PC315.2 PR306.1
N40598539: PC517.2 PR509.1
N40598619: PD501.1 PR507.2
N42785906: PCB35.1 PRB21.1 PUB01.3
N42785908: PDB01.1 PDB02.1 PDB03.1 PRB08.1
N42785925: PRB01.3 PRB03.1
N42785929: PRB28.1 PUB01.29
N42785931: PCB40.1 PRB28.2 PRB34.1 PRB35.1
N42785953: PRB31.1 PRB33.1 PUB01.30
N42785972: PDB04.3 PRB37.1 PRB38.2
N42786037: PRB12.3 PRB36.2
N42786187: PRB42.1 PUB02.4
N42786230: PRB31.2 ZTB03.1(TP-1)
N42786400: PRB12.2 PRB32.2
N42787418: PDB04.2 PRB40.2
N42787433: PRB27.2 PRB29.2 PUB01.26
N42787440: PCB42.1 PRB30.2
N42787460: PCB25.1 PRB06.2
N42787464: PRB29.1 ZTB01.1(TP-1)
N42787500: PCB30.2 PRB15.1
N42787538: PRB01.2 PRB02.1
N42787589: PRB14.2 PUB01.21
N42787591: PRB16.2 PUB01.22
N42787599: PRB19.2 PUB01.23 ZTB02.1(TP-1)
N45824609: PCS03.1 PRS01.1 PRS03.2 PRS05.1 PUS01.3
N45824635: PCS04.1 PRS01.2 PRS02.2 PRS39.1 PUS01.1
N45824651: PCS02.1 PRS04.2 PRS06.1 PUS01.2
N45824918: PQS04.1 PRS11.2
N45824978: PQS07.1 PRS15.2
N45824994: PQS05.6 PRS16.2
N47697054: PRH05.2 PUH01.7
N47701287: PCH11.1 PRH11.1 PUH01.11
N47701297: PCH10.1 PUH01.9
N47703049: PCH14.2 PRH12.1
N47710281: PCF04.1 PRF04.2 PUF01.4
N47727861: PCW11.1 PRW11.1 PUW01.11
N47727869: PCW10.1 PUW01.9
N47735962: PRW05.2 PUW01.7
N47737171: PCW14.2 PRW12.1
N48536383: PLZ02.3 PRZ28.2
N48536385: PLZ02.2 PRZ22.1 PRZ27.2
N48536391: PCZ26.1 PRZ23.2
N48536437: PCZ24.1 PRZ21.2
N48542989: PC2504.1 PR2504.2 PU2501.4
N48611923: PCM11.1 PRM01.2
N48611968: PCM13.1 PRM05.1 PUM01.12
N48611974: PRM06.2 PUM01.10
N48613026: PR1803.2 PU1801.4
N48613121: PC1806.1 PR1804.2
N48614351: PCV33.2 PRV33.2 PUV01.15
N48614360: PCV33.1 PRV35.2
N48614362: PCV11.1 PRV13.2 PUV01.25
N48614371: PRV19.1 PUV01.11
N48614372: PCV25.1 PCV27.1 PRV29.1 PRV34.2 PUV01.16
N48614375: PCV34.1 PRV36.2 PUV01.17
N48614395: PCV24.1 PRV23.2
N48614410: PCV21.1 PRV21.2
N48614414: PLV01.3 PRV22.1 PRV24.1
N48614416: PLV01.2 PRV25.1
N48614440: PHV01.1 PRV18.1 PRV19.2
N48614448: PCV26.1 PRV26.2 PRV29.2 PRV31.1 PRV32.1 PUV01.18
N48614451: PCV25.2 PRV26.1
N48614453: PCV31.1 PRV32.2
N48614455: PCV26.2 PCV29.2 PRV27.1 PUV01.19
N48614458: PCV29.1 PRV31.2
N48614482: PHV02.1 PRV28.2
N48614490: PLV02.3 PRV03.1 PRV07.1
N48614492: PCV09.1 PRV06.2
N48614505: PCV08.1 PRV01.2
N48614510: PLV02.2 PRV08.1
N48614536: PUV01.39 PUV01.40
N48614539: PRV02.1 PUV01.36 PUV01.37 PUV01.38
N48614544: PRV10.1 PUV01.1
N48614545: PRV09.1 PUV01.2
N48614550: PRV04.1 PUV01.34
N48614551: PRV05.1 PUV01.32 PUV01.33
N48637343: PQ1.2 PQ2.1 PR4.2 PR7.1
N48637352: PD1.2 PL3.2 PQ1.1 PR3.1
N48637376: PQ13.2 PR31.2 PR35.2 PR45.1
N48637377: PQ13.3 PR32.2
N48637383: PC13.2 PQ12.5 PR40.1
N48637390: PQ12.2 PR36.2 PR44.2
N48637396: PC14.2 PQ11.2 PR43.1
N48637398: PQ13.5 PQ13.6 PR34.2 PR38.1
N48637416: PJP2.1 PJPDC1.1 PJPDC1.2 PL2.1
N48637453: PD3.1 PR7.2
N48637469: PQ6.1 PR12.2
N48637473: PC5.2 PQ3.4 PR8.2 PR10.1
N48637478: PQ5.1 PR10.2
N48637524: PBATT1.5 PR39.1
N48637560: PQS10.2 PRS26.2 PRS27.2
N309648960: PRB26.1 PUB01.27

Pads without a net: ED2 2; EU4012 2; FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 87 88 91 92 95 96 97 100 101 104 105 162 165; JDIMM2 87 88 91 92 95 96 97 100 101 104 105 162 165; JEDP1 5 6 9 14 24 25 26; JHDMI1 13 14; JKB1 2 3; JKBBL1 3; JSSD1 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67 68 69; JWLAN1 6 16 17 19 20 21 22 23 24 25 27 28 29 30 31 32 34 36 42 44 46 48 58 59 60 61 62 64 65 66 67 68 70 71 73; PD1 3; PD6 3; PJPDC1 4; PU1 3; PU301 10 15; PU501 10; PU1801 1 7; PU2501 1 5; PUB01 13; PUF01 1 5; PUS01 5 6 7; PUV01 4 35; PUZ01 35; RP4 4 5; RPC1 3 4 5 6; RPC3 4 5; RPC64 3 4 5 6; TL1 4 5 12 13; TL2 4 5 12 13; U4 5 6 7 8 9 10; U58 20 22 23 24 25 27; UA1 4 14 15 23 24 48; UC1 A11 A13 A15 A18 AA2 AA3 AA4 AA6 AA8 AA9 AA11 AA12 AC6 AC7 AC9 AC10 AC29 AD3 AD6 AD11 AD12 AE30 AE32 AF3 AF6 AF8 AF9 AF29 AF30 AF31 AH2 AH4 AJ2 AJ3 AJ4 AJ6 AJ24 AJ29 AK6 AK7 AK23 AK27 AL3 AL6 AL8 AL11 AL29 AM29 AM30 AN2 AN3 AN4 AN8 AN9 AN16 AN29 AN31 AP2 AR13 AT2 AT4 AT10 AT12 AT13 AU12 AU14 AU19 AW7 AW10 AW12 AW15 AW19 B6 B10 B11 B12 B13 B15 B16 B17 B18 B20 BA6 BB8 BC8 BC16 C6 C7 C11 C12 C13 C14 C15 C16 C18 C19 D6 D10 D11 D12 D13 D15 D17 F7 F8 G3 G6 G8 H1 H2 H3 H4 H6 H7 J2 J4 J11 J13 J20 K2 K3 K4 K6 K11 K20 L16 M3 M6 M13 M14 M16 M29 M30 M31 N29 N30 N31 N32 P6 P22 P29 P30 P31 R26 R27 R32 T3 T6 T11 T12 T24 T25 T27 T29 U31 V9 V10 V23 V24 V26 V27 V32 W6 W8 W9 W11 W12 W21 W22 W25 W27 Y1 Y3 Y6 Y7 Y9 Y10 Y21 Y27; UC2 1; UC3 1; UC5 1; UE1 70 92 119 120 126 128; UT1 3 4 6 19 21 22 23 24 26 30 34 35 36 37 38 39 40; UV1 AA5 AA6 AA29 AA31 AB23 AB25 AB26 AB27 AB30 AC1 AC3 AC5 AC6 AC16 AC23 AC25 AD2 AD4 AD10 AD11 AD13 AD16 AD22 AD23 AD24 AE1 AE3 AE5 AE6 AE10 AE11 AE13 AE16 AE19 AE22 AE23 AE24 AE25 AE26 AF2 AF4 AF6 AF7 AF8 AF9 AF10 AF11 AF13 AF16 AF17 AF22 AF24 AF25 AG1 AG3 AG5 AG6 AG7 AG8 AG9 AG10 AG11 AG13 AG15 AG16 AG17 AG18 AG19 AG20 AG21 AG22 AG24 AG25 AG26 AH1 AH3 AH5 AH6 AH8 AH12 AH16 AH18 AH20 AH22 AH24 AH26 AJ7 AJ9 AJ13 AJ15 AJ17 AJ19 AJ21 AJ23 AJ25 AK1 AK3 AK5 AK6 AK8 AK10 AK14 AK16 AK18 AK20 AK22 AK24 AK26 AL7 AL13 AL15 AL17 AL19 AL21 AL23 AL25 AM3 AM5 AM6 AM8 AM10 AM12 AM26 J8 J22 J25 K13 K30 L16 L17 L29 L31 M4 M27 M28 M30 N1 N3 N5 N6 N8 N26 N29 N31 P2 P4 P7 P8 P10 P23 P24 P26 P27 P28 P30 R6 R29 R31 T2 T4 T7 T8 T23 T24 T26 T27 T28 T30 U5 U6 U23 U24 U26 U29 U31 V2 V4 V6 V27 V28 V30 W3 W5 W6 W7 W8 W23 W24 W29 W31 Y2 Y4 Y6 Y23 Y24 Y26 Y27 Y28 Y30; UV12 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV13 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV14 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV15 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UX1 2 4 5 6 7 10 11 12 25 26 30 31; Y1 2 4; YC2 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 6327 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 69 vias
v3: diameter 0.305, hole 0.152, TOP to BOTTOM, 624 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 165 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.9VS_GATE:
  vias: v4(147.23,40.95)
0.9VS_PWR_EN#: length 161.1
  TOP w0.089: RE31.1 34.29,81.01 UE1.99 36.46,81.01 36.68,80.78 36.68,80.77 36.99,80.47 37.48,80.47 39.17,78.77 40.38,78.77 41.19,77.97 41.54,77.97 v1(41.57,77.99) ; Q7.2 144.93,34.86 R702.2 145.55,34.71 145.55,35.65 v1(145.83,35.94)
  IN2 w0.089: v1(41.57,77.99) 41.28,77.71 41.28,76.75 41.56,76.47 41.56,72.89 41.32,72.65 41.32,71.59 41.49,71.42 41.49,70.23 41.11,69.85 41.11,68.1 40.96,67.96 40.96,63.83 39.92,62.78 39.92,59.59 40.23,59.28 40.23,58.49 44.37,54.34 44.37,53.3 46.45,51.22 46.45,46.16 48.17,44.44 48.17,40.62 50.83,37.96 54.47,37.96 61.03,31.39 67.08,31.39 67.73,30.75 96.65,30.75 97.38,30.02 98.69,30.02 99.26,30.58 101.22,30.58 102,29.81 109.28,29.81 109.83,30.36 116.09,30.36 116.57,30.84 121.1,30.84 121.4,30.55 125.15,30.55 129.41,34.81 130.04,34.81 130.6,35.36 133.13,35.36 133.51,35.74 135.04,35.74 135.31,35.47 145.36,35.47 v1(145.83,35.94)
  BOTTOM w0.089: v1(145.83,35.94) 145.83,35.47 v3(145.75,35.39)
0.95V_VIN:
  vias: v3(77.76,111.63)
1.8VALW_VIN:
  vias: v1(178.7,59.62) v1(179.33,59.62) v3(178.47,60.08)
1.8VSDGPU_ON: length 4.1
  BOTTOM w0.089: U3.5 124.1,113.7 124.39,113.41 124.39,112.86 124.67,112.58 C31.2 R23.2 v3(125.31,110.71)
2.5V_VIN: length 0.5
  TOP w0.089: v3(76.62,112.39) 76.42,112.58 76.42,112.83
3.3V_TS_EN: length 119.7
  TOP w0.089: v1(130.12,33.1) v3(130.12,32.57) ; v1(213.41,32.96) 213.53,33.08 U5.4
  IN2 w0.089: v1(128.64,56.22) 128.94,55.92 128.94,54.98 129.81,54.11 129.81,51.65 131.45,50.01 131.51,50.01 v1(132.09,49.42) ; v1(213.41,32.96) 211.35,32.96 210.39,32.01 207.33,32.01 206.57,32.76 206.43,32.76 205.89,32.23 204.65,32.23 203.84,33.04 203.56,33.04 203.2,32.67 202.45,32.67 202.21,32.43 191.93,32.43 190.81,33.55 190.81,34.06 190.09,34.79 189.45,34.79 186.51,31.85 181.82,31.85 181.72,31.96 180.39,31.96 178.68,30.24 173.81,30.24 173.62,30.05 168.77,30.05 168.56,29.84 163.56,29.84 163.13,29.42 151.54,29.42 151.22,29.75 149.14,29.75 147.07,31.82 147.07,33 146.13,33.95 137.48,33.95 135.76,32.23 130.95,32.23 130.12,33.05 v1(130.12,33.1)
  IN3 w0.089: v1(130.12,33.1) 130.12,33.1 130.03,33.19 130.03,40.99 130.18,41.15 130.18,41.37 130.55,41.73 130.55,42.48 130.88,42.81 130.88,44.31 131.14,44.56 131.14,45.59 132.32,46.77 132.32,49.2 v1(132.09,49.42)
  BOTTOM w0.1: UC1.AW13 128.25,56.61 v1(128.64,56.22)
3V_FB: length 3.3
  BOTTOM w0.254: PU301.13 19.89,45.2 19.97,45.28 19.97,45.68 19.83,45.82 PR308.1 PR307.2 21.48,46.08 PC315.1
3V_SN: length 1.1
  TOP w0.089: PC309.1 v3(22.65,45.46)
3V_VIN:
  vias: v1(16.24,40) v1(16.24,39.42) v4(16.96,39.98)
3VS: length 0.5
  TOP w0.089: 39.51,52.31 v4(39.99,52.31)
3VS_GATE: length 6
  TOP w0.089: U6.3 36.26,50.88 36.04,51.1 35.07,51.1 C35.2 34.64,49.93 34.55,49.84 33.33,49.84 33,49.51 R704.2 R26.2
3VSDGPU_ON: length 8
  TOP w0.089: v1(128.11,112.94) 128.03,112.94 127.37,113.6 v3(125.7,113.6) 125.4,113.6 124.57,114.43 v1(124.57,114.69)
  BOTTOM w0.089: C26.2 125.31,113.73 124.7,114.34 124.7,114.56 v1(124.57,114.69) 124.38,114.5 U3.3 ; v1(128.11,112.94) 128.11,111.93 R438.2
5V_FB: length 3.8
  BOTTOM w0.203: 26.55,93.86 26.55,93.96 25.56,94.96 PU501.13 ; 26.55,93.86 PR511.1 ; 26.55,93.86 25.78,93.86 PR510.2 25.69,93.77 PC517.1
5V_SN: length 1.8
  TOP w0.089: PR505.2 20.4,102.41 v3(21.11,103.11)
5V_VIN: length 1.3
  TOP w0.089: PC503.1 v4(28.97,100.37)
  vias: v1(30.07,99.18) v1(30.07,98.55)
5VS:
  vias: v3(43.28,99.37)
5VS_GATE: length 5
  TOP w0.089: v3(36.55,96.01) 36.55,96.02 36.75,96.21 R705.2
  TOP w0.102: R705.2 R24.2 38.32,96.45 38.2,96.58 C23.2 38.85,97.87 U4.3
+0.6V_DDR_VTT: length 3.4
  TOP w0.102: v1(42.36,47.54) v4(43.06,47.54)
  TOP w0.508: CD22.1 CD16.1 58.85,43.21 59.36,42.7 v1(59.83,42.7)
  vias: v1(39.35,35.49) v1(39.96,35.58) v1(40.59,35.58) v1(41.78,47.54) v1(42.07,46.99) v1(60.26,42.29) v1(73.87,42.17) v1(74.05,42.76)
+0.6VSP: length 2
  TOP w0.102: v3(40.93,31.75) 40.8,31.62 39.02,31.62
+0.9VALW: length 57.7
  TOP w0.254: v1(127.92,61.92) 127.68,62.16 RC6128.2
  IN2 w0.305: 126.92,63.95 129.24,63.95 129.55,64.26 134.45,64.26 136.64,66.45 141.26,66.45 141.85,65.86 146.39,65.86 146.96,66.43 149.69,66.43 152.23,63.88 152.23,62.05 151.53,61.35 151.53,52.1 150.36,50.94 150.36,42.47 153.2,39.63 153.96,39.63 155.37,38.22 v1(155.55,38.22)
  vias: v4(150.21,36.13)
+0.9VALW_APU: length 2.9
  BOTTOM w0.305: v1(126.83,63.11) UC1.AL14 127.64,63.1 v1(127.68,63.1) 127.29,62.71 UC1.AM14 v1(126.83,63.11) ; v1(126.83,63.11) UC1.AL15
+0.9VS: length 22.6
  TOP w0.508: RC13.2 145.27,73.13 144.44,72.3 v1(144.15,72.3)
  BOTTOM w0.254: UC1.AN13 128.23,61.35 v1(128.61,61.73) 129.19,62.31 UC1.AM12
  BOTTOM w0.3: UC1.AN12 128.81,60.89 v1(128.61,60.89) 128.23,61.27 UC1.AN13 ; UC1.AN12 129.71,60.83 v1(129.76,60.83) ; UC1.AN12 UC1.AM12
  BOTTOM w0.305: UC1.AL13 128.35,63.19 v1(128.35,63.11) 128.35,63.02 UC1.AM13 128.03,62.54 128.61,61.96 v1(128.61,61.73)
  BOTTOM w0.508: v1(139.31,61.31) 139.38,61.38 139.38,62.71 140.15,63.48 141.12,63.48 142.4,64.77 142.4,67.88 143.65,69.12 143.65,71.8 v1(144.15,72.3)
  vias: v1(152.75,46.41) v1(152.75,45.78) v1(152.75,45.14) v1(152.75,44.51) v1(152.75,43.87) v4(151.74,45.14)
+0.95VSDGPU: length 21.9
  TOP w0.508: v1(111.55,126.73) 112.54,127.72 RV30.1 ; v1(118.81,119.04) 119.3,118.55 122.02,118.55 122.45,118.11 123.35,118.11 123.9,118.66 125.49,118.66 126.16,117.99 126.16,116.26 126.67,115.76 131.23,115.76 133.82,118.35 LV8.1
  vias: v1(114.59,113.06) v1(115.22,113.06) v1(115.86,113.06) v1(117.52,119.05) v1(118.15,119.05) v1(119.77,145.21) v1(120.87,145.54) v1(120.87,144.92) v4(95.67,114.68)
+0.95VSDGPUP:
  vias: v4(89.7,110.36)
+1.2V_DDR: length 104.3
  BOTTOM w0.099: UC1.AF26 117.23,67.33 v1(117.65,67.75)
  BOTTOM w0.102: v1(119.23,64.81) 119.63,65.21 UC1.AJ23 ; UC1.AC25 117.92,70.31 117.6,70.63 v1(117.6,70.86) 117.6,70.94 UC1.AA26 ; UC1.AL32 112.76,63.31 v1(112.59,63.14) ; v1(118.32,72.78) 118.32,72.6 UC1.Y25 ; v1(117.65,67.75) 117.65,67.92 UC1.AE25 ; UC1.AJ26 117.23,65.1 117.64,64.69 v1(117.66,64.69) ; UC1.AF32 113.81,67.43 113.27,67.43 v1(113.13,67.56) ; UC1.AA23 119.63,71.41 v1(119.23,71.81) ; v1(119.22,66.93) 119.25,66.93 UC1.AF23 ; UC1.AD23 119.63,69.56 119.42,69.77 v1(119.3,69.77)
  BOTTOM w0.203: JDIMM2.142 57.05,74.74 56.85,74.94 ; JDIMM1.142 69.8,74.74 69.55,74.99
  BOTTOM w0.254: v1(69.72,71.24) 70.95,71.24 JDIMM1.148 ; UC1.AF26 118.03,66.51 UC1.AG25 ; UC1.AC25 117.23,69.51 UC1.AD26 ; UC1.T32 113.32,75.31 113.32,75.29 v1(113.05,75.02) ; 56.96,79.24 JDIMM2.124 ; JDIMM2.163 67.35,67.49 67.53,67.31 68.36,67.31 68.68,67.63 68.68,67.65 v1(68.8,67.76) ; v1(68.37,70.57) 68.37,70.24 68.11,69.99 JDIMM2.153 ; JDIMM2.160 59.24,68.24 59.47,68 v1(59.66,68) ; UC1.AG28 115.33,66.31 115.28,66.26 v1(115.28,66.26) ; 57.02,69.74 JDIMM2.154 ; v1(68.68,80.77) 68.68,80.26 69.7,79.24 JDIMM1.124 ; JDIMM2.148 58.25,71.24 57.02,71.24 ; 69.55,74.99 v1(69.55,75.62) 69.55,75.73 ; JDIMM1.160 71.93,68.24 v1(72.3,67.88) ; v1(69.72,69.74) JDIMM1.154 ; v1(69.56,77.47) 69.56,77.48 69.82,77.74 JDIMM1.130 ; 56.85,74.94 56.85,75.98 57.1,76.24 JDIMM2.136 ; v1(80.97,71.18) 80.97,70.24 80.72,69.99 JDIMM1.153 ; 56.84,77.74 JDIMM2.130
  BOTTOM w0.3: v1(115.28,64.31) 115.28,64.37 115.63,64.72 115.63,65.11 UC1.AJ28 115.6,65.53 115.6,65.9 115.28,66.22 115.28,66.26 v1(115.28,66.26) 115.28,66.26 115.28,66.38 115.83,66.93 UC1.AF28 115.83,67.54 115.61,67.76 115.61,67.91 115.23,68.29 v1(115.23,68.33) ; v1(115.28,64.31) 115.28,64.22 115.63,63.87 115.63,63.51 UC1.AL28 ; v1(115.28,64.31) UC1.AK28 ; UC1.W32 113.37,73.31 v1(113.29,73.39) ; UC1.Y28 v1(115.28,72.31) 115.28,72.39 115.63,72.74 115.63,73.11 UC1.W28 115.63,73.51 115.63,73.88 115.28,74.23 v1(115.28,74.31) UC1.V28 ; v1(115.23,68.33) 115.81,68.33 UC1.AE28 ; v1(115.23,68.33) 115.63,68.74 115.63,69.11 UC1.AD28 ; v1(113.17,71.28) 113.2,71.31 UC1.AA32 ; UC1.AE22 120.43,68.21 v1(120.03,67.81) ; UC1.AC22 120.43,70.41 v1(120.03,70.81) ; v1(120.03,72.81) 120.43,72.41 UC1.Y22 ; v1(120.03,65.81) 120.43,66.21 UC1.AG22 ; UC1.AA28 115.63,71.11 115.63,70.74 115.28,70.39 v1(115.28,70.31) UC1.AC28 ; UC1.AD32 v1(113.12,69.31) ; UC1.AJ32 v1(112.71,65.31)
  BOTTOM w0.305: v1(80.65,67.82) 80.62,67.85 80.62,68.18 80.32,68.49 JDIMM1.159 ; v1(80.51,74.85) 80.37,74.99 JDIMM1.141 ; v1(72.2,82.22) 72.17,82.24 JDIMM1.112 ; v1(67.74,70.53) 67.74,71.18 67.43,71.49 JDIMM2.147 ; JDIMM2.111 67.36,82.49 67.67,82.18 v1(67.67,82.1) ; JDIMM1.117 80.05,80.99 80.36,80.68 v1(80.36,80.02) 80.36,79.79 80.05,79.49 JDIMM1.123 ; JDIMM2.141 67.29,74.99 v1(67.76,74.52) ; JDIMM1.135 80.09,76.49 80.48,76.88 80.48,77.76 v1(80.4,77.84) 80.25,77.99 JDIMM1.129 ; JDIMM2.117 67.54,80.99 v1(67.8,80.73) 67.8,79.79 67.49,79.49 JDIMM2.123 ; UC1.AC28 115.83,70.09 115.75,70.01 115.75,69.61 115.83,69.52 UC1.AD28 ; v1(69.49,80.73) 69.5,80.74 JDIMM1.118 ; v1(80.31,82.2) 80.03,82.49 JDIMM1.111 ; UC1.AA20 v1(122.04,71.12) ; JDIMM1.147 80.06,71.49 v1(80.38,71.17) ; v1(73.25,76.2) 73.21,76.24 JDIMM1.136 ; UC1.AG20 121.92,67.22 121.92,67.8 v1(122.03,67.91) UC1.AE20 ; UC1.AC20 v1(122.03,69.51) ; JDIMM2.135 67.39,76.49 67.77,76.87 v1(67.77,77.47) 67.77,77.61 67.39,77.99 JDIMM2.129 ; JDIMM2.112 v1(59.5,82.24) ; v1(68.01,67.79) 68.01,68.18 67.71,68.49 JDIMM2.159 ; JDIMM2.118 56.8,80.74 ; UC1.AJ20 v1(122.03,64.71) ; UC1.Y28 UC1.AA28
  vias: v1(42.52,33.7) v1(42.82,33.17) v1(43.1,33.7) v1(43.4,33.17) v1(43.73,33.7) v1(44.04,33.17) v1(44.37,33.7) v1(44.67,33.17) v1(44.98,33.7) v1(45.28,33.17) v1(45.61,33.7) v1(45.92,33.17) v1(46.21,33.71) v1(48.8,52.13) v1(48.8,51.49) v1(48.8,50.86) v1(48.8,50.22) v1(48.8,49.59) v1(48.8,48.95) v1(48.8,48.32) v1(49.44,52.13) v1(49.44,51.49) v1(49.44,50.86) v1(49.44,50.22) v1(49.44,49.59) v1(49.44,48.95) v1(49.44,48.32) v1(59.98,70.1) v1(60.3,68.89) v1(60.49,76.07) v1(60.49,72.96) v1(60.74,79.18) v1(61.06,81.47) v1(61.06,77.97) v1(61.06,70.42) v1(61.5,74.42) v1(61.69,71.37) v1(61.76,73.02) v1(62.01,79.18) v1(62.2,69.78) v1(62.33,81.47) v1(62.33,76.13) v1(62.33,70.42) v1(62.39,77.97) v1(62.65,79.18) v1(63.09,76.26) v1(63.09,72.96) v1(63.15,80.56) v1(63.15,68.45) v1(63.41,73.72) v1(63.6,81.47) v1(63.66,77.97) v1(63.85,79.24) v1(64.3,70.48) v1(64.42,80.56) v1(64.49,68.45) v1(64.93,77.97) v1(64.87,76.26) v1(65.06,79.24) v1(69.57,67.81) v1(72.49,77.91) v1(72.91,68.72) v1(73.19,83.82) v1(73.2,72.94) v1(73.44,79.24) v1(73.69,81.72) v1(73.69,77.91) v1(73.76,70.48) v1(74.32,74.42) v1(74.38,83.82) v1(74.47,72.87) v1(74.71,79.18) v1(75.03,81.72) v1(74.96,76.2) v1(75.09,77.97) v1(75.09,70.48) v1(75.29,68.37) v1(75.54,83.82) v1(75.78,72.96) v1(75.92,80.77) v1(75.99,76.39) v1(76.23,81.72) v1(76.36,77.97) v1(76.49,79.18) v1(76.74,83.82) v1(76.93,70.48) v1(76.87,68.45) v1(77.12,80.77) v1(77.82,76.39) v1(77.89,83.75) v1(81.28,67.82) v1(103.92,65.85) v1(104.49,75.33) v1(104.56,80.22) v1(104.64,72.53) v1(105.14,77.12) v1(105.2,65.59) v1(105.74,75.33) v1(105.98,72.53) v1(106.32,80.22) v1(106.33,77.12) v1(106.38,65.59) v1(106.68,63.56) v1(106.9,75.33) v1(107.18,72.53) v1(107.5,77.14) v1(107.55,65.59) v1(107.77,69.19) v1(107.97,63.56) v1(108.07,75.33) v1(108.44,72.53) v1(108.67,77.12) v1(108.72,65.59) v1(109.18,83.85) v1(109.24,75.33) v1(109.22,63.56) v1(109.61,72.53) v1(109.6,69.21) v1(109.84,77.12) v1(109.89,65.59) v1(110.44,83.89) v1(110.49,63.56) v1(111.11,65.59) v1(111.22,82.48) v1(111.49,69.27) v1(111.66,83.89) v1(112.01,81.3) v1(112.42,82.49) v1(121.71,70) v4(68.4,106.92)
