# Allegro board LAF121PR10-1117.brd (continued)
## Copper pours and planes (outline as drawn)
0.9VS_GATE on TOP (solid shape): outline of 89 points within 144.88,37.4 150.85,42.16
0.95V_VIN on TOP (solid shape): 81.33,114.19 81.33,113.62 81.17,113.47 79.45,113.47 79.16,113.18 79.16,112.37 79.43,112.09 80.08,112.09 80.18,111.98 80.18,111.1 79.64,111.1 79.64,110.54 79.45,110.54 79.45,111.11 77.76,111.11 77.62,111.25 77.62,113.67 77.86,113.91 78.75,113.91 79.14,114.31 79.33,114.31 79.45,114.3 79.56,114.34 79.58,114.35 81.17,114.35
1.8VALW_VIN on TOP (solid shape): 179.97,59.71 180.53,59.71 180.53,59.51 179.97,59.51 179.97,58.77 178.35,58.77 178.29,58.83 178.29,60.16 178.39,60.26 179.97,60.26
1.8VALW_VIN on BOTTOM (solid shape): 178.16,62.14 178.16,61.02 179.32,59.85 180.57,59.85 180.93,59.49 180.93,58.56 181.57,57.92 181.57,57.25 181.44,57.13 179.14,57.13 178.89,57.38 178.89,58.32 178.11,59.09 176.79,59.09 176.69,59.19 176.69,62.15 176.79,62.25 178.04,62.25
2.5V_VIN on TOP (solid shape): 76.74,113.57 76.74,112.7 76.7,112.66 76.68,112.66 76.52,112.65 76.39,112.56 70.76,112.56 70.63,112.68 70.63,113.19 70.77,113.33 72.55,113.33 72.97,113.75 73.02,113.79 73.11,113.89 76.42,113.89
3V_SN on TOP (solid shape): 24.52,44.61 24.52,43.04 24.43,42.95 23.53,42.95 23.48,43 23.48,43.92 23.32,44.08 22.24,44.08 22.2,44.13 22.2,44.71 22.23,44.75 24.38,44.75
3V_VIN on TOP (solid shape): 18.45,42.12 18.45,40.83 18.32,40.7 17.92,40.7 17.64,40.42 17.64,40.31 17.62,40.22 17.64,40.12 17.64,39.21 17.5,39.07 16.1,39.07 15.93,39.24 15.93,40.62 16.77,41.46 16.77,42.22 16.81,42.26 18.31,42.26
3V_VIN on BOTTOM (solid shape): outline of 150 points within 13.7,38.48 20.53,42.71
3VS on TOP (solid shape): 36.99,54.6 37.69,54.6 37.69,55.12 38.19,55.12 38.19,54.6 38.89,54.6 38.89,55.12 39.53,55.12 39.62,55.04 39.62,51.32 39.43,51.14 38.31,51.14 38.24,51.2 38.24,52.47 38.08,52.63 36.92,52.63 36.32,53.22 36.32,55.06 36.39,55.12 36.99,55.12
5V_SN on TOP (solid shape): 21.45,102.53 21.45,100.78 21.23,100.56 18.38,100.56 18.23,100.71 18.23,101.42 18.33,101.51 19.25,101.51 19.49,101.76 19.49,102.5 19.66,102.67 21.31,102.67
5V_VIN on TOP (solid shape): 30.41,99.4 30.41,98.54 30.2,98.33 28.13,98.33 28.01,98.45 28.01,99.44 28.11,99.55 30.26,99.55
5V_VIN on BOTTOM (solid shape): outline of 126 points within 24.94,98.27 30.39,103.94
5VS on TOP (solid shape): 40.47,101.78 40.97,101.78 40.97,102.28 41.27,102.28 41.27,101.78 41.77,101.78 41.77,102.28 45.37,102.28 45.37,101.78 46.08,101.78 46.08,102.28 46.57,102.28 46.57,101.78 47.28,101.78 47.28,102.28 48.03,102.28 48.29,102.01 48.29,99.04 48.18,98.93 46.58,98.93 46.57,98.93 46.45,98.97 46.33,98.95 46.32,98.94 44.89,98.94 44.8,98.95 44.72,98.94 43.52,98.94 42.72,98.14 41.69,98.14 41.63,98.2 41.63,98.84 41.61,98.84 41.61,98.92 41.64,98.99 41.72,99.02 42.04,99.51 41.46,99.62 41.43,99.61 41.39,99.62 39.94,101.07 39.94,102.19 40.03,102.28 40.47,102.28
+0.6V_DDR_VTT on TOP (solid shape): 76.39,43.65 76.39,43.11 76.31,43.03 74.72,43.03 74.17,42.48 74.17,41.96 74.05,41.84 73.08,41.84 72.88,42.04 67.97,42.04 67.83,42.18 67.83,42.91 67.87,42.95 68.49,42.95 68.64,42.8 73.04,42.8 73.95,43.71 76.33,43.71
+0.6V_DDR_VTT on TOP (solid shape): 40.84,35.75 40.84,34.9 40.68,34.74 40.2,34.74 40.2,34.74 40.2,34.18 40.02,34.18 40.02,34.73 40.01,34.74 39.38,34.74 39.13,34.99 39.13,35.71 39.28,35.86 39.4,35.86 39.4,35.87 40.72,35.87
+0.6V_DDR_VTT on BOTTOM (solid shape): 74.3,43.75 74.3,42.71 74.13,42.53 74.13,42.12 73.95,41.94 73.41,41.94 73.16,42.2 69.53,42.2 68.84,42.9 68.84,43.26 69.97,43.26 69.97,43.22 69.98,43.17 70,43.13 70.02,43.09 70.05,43.06 70.08,43.03 70.12,43.01 70.16,42.99 70.2,42.99 70.23,42.98 72.07,42.98 72.08,42.96 72.12,42.93 72.16,42.9 72.21,42.87 72.26,42.86 72.31,42.85 72.36,42.85 72.41,42.86 72.46,42.87 72.51,42.89 72.55,42.92 72.58,42.96 72.62,43 72.64,43.05 72.66,43.1 72.67,43.15 72.67,43.2 72.66,43.25 72.64,43.3 72.62,43.35 72.59,43.39 72.56,43.43 72.51,43.46 72.47,43.48 72.42,43.5 72.37,43.51 72.32,43.51 72.27,43.5 72.23,43.49 70.23,43.49 70.2,43.49 70.16,43.49 70.12,43.47 70.08,43.45 70.05,43.42 70.02,43.39 70,43.35 69.98,43.31 69.97,43.26 68.84,43.26 68.84,43.6 69.15,43.91 74.14,43.91
+0.6V_DDR_VTT on BOTTOM (solid shape): 59.18,43.91 59.27,43.85 59.26,43.75 59.21,43.67 59.19,43.58 59.18,43.56 59.11,43.49 57.53,43.49 57.27,43.24 57.53,42.98 59.32,42.98 59.54,43.2 59.56,43.21 59.82,43.41 59.77,43.75 59.75,43.85 59.84,43.91 59.95,43.91 61.1,42.77 61.1,42.11 60.98,41.99 56.53,41.99 56.07,42.46 56.07,43.79 56.19,43.91
+0.6V_DDR_VTT on IN1 (solid shape): outline of 361 points within 41.54,40.98 74.3,47.76
+0.6V_DDR_VTT on IN2 (solid shape): 42.6,47.72 42.6,39.9 41.03,38.32 41.03,36.9 41.03,36.9 41.03,35.3 40.95,35.21 40.05,35.21 40.04,35.2 39.21,35.2 39.12,35.29 39.12,35.64 39.68,36.2 39.68,36.25 39.79,36.35 39.79,38.57 41.33,40.12 41.33,40.18 41.42,40.26 41.42,47.6 41.63,47.81 42.52,47.81
+0.6VSP on TOP (solid shape): 40.8,34.55 40.8,33.43 40.5,33.13 39.33,33.13 39.17,32.97 39.17,29.88 38.79,29.5 37.99,29.5 37.94,29.55 37.94,29.82 38.4,30.27 38.4,30.42 38.49,30.67 38.4,30.91 38.4,31.19 38.32,31.27 37.83,31.27 37.38,30.82 37.38,29.95 37.32,29.89 37.19,29.89 37.13,29.95 37.13,31.09 37.16,31.14 37.18,31.19 37.32,31.32 37.32,32.4 37.93,32.65 37.32,32.89 37.32,34.14 37.37,34.19 38.42,34.19 38.78,34.55 39.68,34.55 39.86,34.37 39.86,33.99 39.91,33.94 40.34,33.94 40.39,33.99 40.39,34.53 40.45,34.58 40.78,34.58
+0.9VALW on TOP (solid shape): 152.92,39.92 152.92,38.69 153,38.6 153.51,38.6 153.51,38.6 154.4,38.6 154.4,38.6 154.91,38.6 154.91,38.6 155.48,38.6 155.77,38.32 155.77,37.87 155.42,37.52 155.42,36.95 154.91,36.95 154.91,36.13 155.42,36.13 155.42,35.75 154.91,35.75 154.91,34.98 155.42,34.98 155.42,34.16 155.1,33.84 148.37,33.84 148.18,34.03 148.18,36.51 149.92,38.25 149.92,39.83 150.22,40.13 152.71,40.13
+0.9VALW on IN2: 126.41,61.65 126.02,62.05 125.99,62.07 125.73,62.34 125.73,63.81 126.11,64.19 127.45,64.19 127.59,64.05 127.59,63.45 127.56,63.44 127.33,63.1 127.56,62.77 127.59,62.76 128.18,62.17 128.18,61.65
+0.9VALW_APU on TOP (solid shape): 127.92,63.24 127.92,62.99 127.8,62.86 127.1,62.86 126.67,62.43 126.67,61.78 126.6,61.72 126.15,61.72 126.08,61.78 126.08,61.8 126.07,61.91 126.02,62 126.02,62.73 126.07,62.78 126.08,62.78 126.24,62.87 126.33,63.03 126.33,63.05 126.65,63.37 127.8,63.37
+0.9VS on TOP (solid shape): outline of 1901 points within 127.73,38.73 154.28,63.36
+0.9VS on VCC: 131.58,46.29 130.84,47.03 130.84,59.6 129.38,61.07 129.38,61.83 128.18,63.03 128.18,64.02 130.92,64.02 134.65,60.28 134.65,51.52 136.45,49.72 146.74,49.72 149.66,46.79 152.84,46.79 153.2,46.44 153.2,41.97 148.58,41.97 144.26,46.29
+0.95VSDGPU on TOP (solid shape): outline of 179 points within 119.09,139.75 121.61,146.07
+0.95VSDGPU on TOP (solid shape): outline of 204 points within 90.01,111.98 116.39,116
+0.95VSDGPU on BOTTOM (solid shape): 118.81,119.29 118.93,119.29 119.03,119.2 119.03,116.78 118.96,116.71 117.38,116.71 117.26,116.82 117.26,119.08 117.48,119.29 118.81,119.29
+0.95VSDGPU on IN3 (solid shape): outline of 2200 points within 107.67,112.82 121.13,146.16
+0.95VSDGPUP on TOP (solid shape): 90.43,114.35 90.43,113.37 90.43,113.37 90.43,113 89.85,113 89.85,112.49 90.43,112.49 90.43,112.11 90.43,112.11 90.43,109.99 90.03,109.58 86.93,109.58 86.83,109.69 86.83,113.33 86.66,113.5 84.65,113.5 84.51,113.64 84.51,114.24 84.67,114.4 86.56,114.4 86.75,114.59 90.19,114.59
+1.2V_DDR on TOP (solid shape): 47.06,34.89 47.06,32.79 47.02,32.76 46.99,32.73 46.82,32.57 46.19,32.57 46.01,32.38 46.01,31.87 45.82,31.68 42.45,31.68 42.11,32.02 42.11,34.94 42.28,35.11 46.84,35.11
+1.2V_DDR on TOP (solid shape): outline of 8863 points within 57.5,60.74 122.29,110.98
+1.2V_DDR on BOTTOM (solid shape): 45.36,33.94 46.26,33.94 46.61,33.59 46.61,33.3 46.73,33.18 46.73,32.56 46.29,32.13 45.77,32.13 45.76,32.14 45.76,32.61 45.69,32.69 45.07,32.69 45.03,32.65 45.03,32.14 45.03,32.14 44.57,32.14 44.56,32.14 44.56,32.66 44.54,32.68 43.89,32.68 43.83,32.62 43.83,32.14 42.43,32.14 42.24,32.33 42.24,34.15 42.51,34.43 44.88,34.43
+1.2V_DDR on BOTTOM (solid shape): outline of 5247 points within 48.29,46.73 81.63,84.7
+1.2V_DDR on IN2 (solid shape): outline of 7212 points within 57.76,60.51 118.99,85.47
+1.2V_DDR on GND1: 86.65,60.52 82.56,64.61 80.43,64.61 78.88,66.16 75.2,66.16 73.67,67.69 68.44,67.69 67.79,68.34 67.79,80.4 68.64,81.25 71.23,81.25 71.95,81.97 71.95,83.9 74.56,86.51 92.46,86.51 95.69,83.28 101.83,83.28 103.48,81.64 103.48,80.32 106.15,77.64 109.37,77.64 109.55,77.47 110.57,77.47 111.73,76.3 111.73,75.92 112.11,75.54 112.11,74.79 112.73,74.16 113.62,74.16 114.38,73.4 118.48,73.4 118.71,73.63 120.61,73.63 120.73,73.5 120.73,73.41 122.21,71.94 122.21,64.68 122.05,64.52 120.83,64.52 120.77,64.46 118.73,64.46 118.48,64.22 115.99,64.22 115.75,63.98 114.06,63.98 113.77,64.27 111.85,64.27 111.19,63.61 105.22,63.61 104.02,62.4 102.75,62.4 101.5,61.16 90.25,61.16 89.62,60.52
+1.2V_DDR on VCC: 86.65,60.52 82.56,64.61 80.43,64.61 78.88,66.16 75.2,66.16 73.67,67.69 70.14,67.69 70.14,81.25 71.23,81.25 71.95,81.97 71.95,83.9 74.56,86.51 92.46,86.51 95.69,83.28 101.83,83.28 103.48,81.64 103.48,80.32 106.15,77.64 110.67,77.64 112.34,75.98 112.34,74.71 112.78,74.27 113.87,74.27 114.51,73.63 121.29,73.63 121.29,72.37 122.21,71.45 122.21,64.52 120.83,64.52 120.77,64.46 118.73,64.46 118.24,63.98 116.13,63.98 115.76,63.61 105.65,63.61 104.45,62.4 102.75,62.4 101.5,61.16 90.25,61.16 89.62,60.52
+1.2V_DDR on VCC: 42.81,32.95 42.33,33.44 42.33,51.13 43.45,52.26 49.59,52.26 49.82,52.02 49.82,48.36 47.85,46.39 47.85,35.22 46.77,34.15 46.77,33.08 46.64,32.95
+1.2V_DDR on GND2: 92.49,60.55 91.3,61.74 79.26,61.74 77.58,63.42 73.77,63.42 73.13,62.78 71.61,62.78 70.24,64.16 66.84,64.16 65.16,65.83 63.41,65.83 61.63,67.61 59.04,67.61 58.26,68.39 58.26,83.75 59.12,84.6 62.77,84.6 63.49,85.31 69.73,85.31 71.3,83.74 72.68,83.74 73.01,84.07 77.93,84.07 78.9,83.1 81.01,83.1 82.35,81.76 98.3,81.76 100.54,79.52 103.94,79.52 104.35,79.12 111.2,79.12 115.79,74.52 115.79,64.02 114.01,62.24 109.92,62.24 109.07,61.39 106.28,61.39 106.2,61.31 105.75,61.31 104.98,60.55
+1.2VP on TOP (solid shape): 35.23,33.37 35.23,32.53 35.3,32.47 36.19,32.47 36.19,30.03 36.07,29.92 35.98,29.92 35.88,30.02 35.88,30.69 35.51,31.06 35.51,31.77 35.32,31.96 34.69,31.96 34.69,33.37 34.73,33.41 35.2,33.41
+1.2VP on TOP (solid shape): 51.45,32.17 54.34,32.17 55.45,31.06 55.45,29.96 55.38,29.89 52.94,29.89 52.1,30.73 48.48,30.73 48.14,31.07 48.14,32.13 48.19,32.17 51.44,32.17
+1.2VP on BOTTOM (solid shape): outline of 103 points within 43.17,25.52 56.43,32.18
+1.8V_ALW on TOP (solid shape): 224.64,66.68 224.64,65.89 224.49,65.74 222.22,65.74 222.08,65.87 222.08,67.04 222.12,67.08 224.24,67.08
+1.8V_ALW on TOP (solid shape): 225.74,59.45 225.74,58.87 225.63,58.75 225.11,58.75 224.44,58.09 223.27,58.09 223.25,58.11 223.25,58.76 223.34,58.85 224.19,58.85 224.83,59.49 225.7,59.49
+1.8V_ALW on TOP (solid shape): 145.45,70.16 145.45,66.57 145.55,66.47 145.54,66.44 145.54,66.23 145.67,66.05 145.67,65.89 145.53,65.76 144.94,65.76 144.94,67.64 144.8,67.77 144.8,68.25 144.94,68.38 144.94,68.38 144.94,69.14 144.69,69.39 144.69,70.18 144.8,70.29 145.32,70.29
+1.8V_ALW on TOP (solid shape): 120.25,47.85 120.25,47.28 119.35,46.38 119.35,46.16 119.27,46.16 119.27,46.02 119.25,45.99 119.21,45.89 119.2,45.78 119.2,44.34 119.05,44.19 119.05,42.86 117.76,42.86 117.62,43 117.62,44.35 118.31,45.04 118.31,46.63 118.02,46.92 116.63,46.92 116.44,47.11 116.44,47.87 116.52,47.95 120.15,47.95
+1.8V_ALW on TOP (solid shape): 35.25,49.81 35.53,49.68 35.81,49.81 36.97,49.81 37.02,49.76 37.02,47.95 36.98,47.91 36.14,47.91 36.14,48.59 35.3,48.59 35.3,48.53 35.24,48.44 35.14,48.45 33.69,48.45 33.56,48.57 33.56,49.62 33.64,49.7 34.61,49.7 34.73,49.81
+1.8V_ALW on BOTTOM (solid shape): 119.21,44.36 119.21,42.63 118.93,42.35 118.12,42.35 117.94,42.53 117.94,44.25 118.25,44.56 119.01,44.56
+1.8V_ALW on BOTTOM (solid shape): 124.25,113.34 124.25,112.8 124.62,112.42 124.62,111.47 124.54,111.39 124.08,111.39 123.95,111.51 123.95,112.14 123.47,112.63 123.47,113.38 123.55,113.46 124.13,113.46
+1.8V_ALW on BOTTOM (solid shape): 34.1,49.39 34.1,48.6 33.83,48.33 33.76,48.33 33.71,48.28 33.7,48.27 33.56,48.19 33.48,48.05 33.47,48.01 32.97,48.01 32.88,48.11 32.88,49 33.39,49.51 33.97,49.51
+1.8V_ALW on BOTTOM (solid shape): 172.31,46.64 171.94,46.27 171.95,46.25 172.31,45.89 172.32,45.88 172.7,46.25 172.87,46.08 172.5,45.71 172.51,45.69 172.87,45.33 172.89,45.32 173.27,45.69 173.58,45.39 173.58,45.11 172.51,44.04 172.11,44.04 170.98,45.17 170.98,45.94 171.94,46.9 172.05,46.9
+1.8V_ALW on IN1 (solid shape): outline of 509 points within 217.37,52.47 225.67,67.17
+1.8V_ALW on IN2 (solid shape): 204.24,55.93 204.72,55.93 204.72,55.92 205.41,55.92 205.42,55.93 205.44,55.93 206.58,57.06 209.71,57.06 213.97,52.8 216.78,52.8 216.79,52.76 217.31,52.51 217.4,53.07 217.37,53.14 217.4,53.22 217.42,53.24 217.73,53.55 218.11,53.55 218.14,53.55 218.68,53.01 218.68,52.25 218.01,51.58 214.17,51.58 214.16,51.58 214.05,51.6 213.95,51.58 213.94,51.58 213.59,51.58 213.52,51.59 213.45,51.6 213.43,51.59 208.85,56.17 207.81,56.17 207.76,56.17 207.56,56.17 207.26,55.88 206.78,55.88 206.58,55.67 206.57,55.67 206.1,55.21 203.12,55.21 201.8,56.53 201.72,56.53 201.71,56.54 201.51,56.6 201.32,56.53 200.01,56.53 199.8,56.6 199.6,56.53 198.62,56.53 197.31,55.22 185.36,55.22 183.5,53.36 183.5,51.27 181.73,49.5 181.52,49.4 181.42,49.19 179.29,47.06 173.91,47.06 171.95,45.1 171.76,45.1 171.12,45.73 171.12,46.08 173.28,48.24 174.28,48.24 174.29,48.24 174.41,48.22 174.52,48.24 174.53,48.24 178.75,48.24 182.34,51.82 182.34,52.08 182.34,52.08 182.34,54.12 184.89,56.67 196.43,56.67 196.6,56.84 196.6,56.88 197.45,57.73 202.43,57.73
+1.8V_ALW on IN3 (solid shape): outline of 2597 points within 115.4,43.3 126.03,65.09
+1.8V_ALW on VCC: 138.32,42.98 127.16,42.98 127.16,59.22 125.51,60.87 125.51,64.02 127.67,64.02 127.67,62.82 128.87,61.62 128.87,60.86 130.34,59.39 130.34,46.82 131.37,45.78 142.71,45.78 142.72,45.78 144.05,45.78 148.37,41.46 163.32,41.46 168.07,46.21 172.52,46.21 172.78,45.95 172.78,44.66 165.77,37.65 140.09,37.65 139.99,37.75 139.99,41.31
+1.8VALWP on TOP (solid shape): 176.01,48.19 176.01,47.67 174.83,46.49 174.73,46.49 174.06,47.15 173.38,47.83 173.38,48.03 174.61,49.26 174.94,49.26
+1.8VALWP on BOTTOM (solid shape): 179,50.5 179,48.55 178.78,48.34 176.75,48.34 173.91,45.5 173.66,45.5 173.3,45.87 173.26,45.87 172.89,45.5 172.68,45.71 173.05,46.08 172.7,46.43 172.32,46.06 172.12,46.27 172.49,46.64 172.08,47.05 171.83,47.29 171.83,47.54 174.27,49.97 175.03,50.73 178.76,50.73
+1.8VGS on TOP (solid shape): outline of 593 points within 107.41,115.12 125.58,143.25
+1.8VGS on BOTTOM (solid shape): 122.21,113.35 122.21,112.72 122.01,112.51 122.01,111.48 121.95,111.43 120.57,111.43 120.52,111.48 120.52,113.28 120.65,113.42 122.15,113.42
+1.8VGS on IN2 (solid shape): outline of 224 points within 112.49,111.58 121.26,118.16
+1.8VS on TOP (solid shape): 124.68,97.58 124.68,94.93 124.58,94.82 124.54,94.86 122.21,94.86 122.18,94.9 122.18,98 122.36,98.18 124.08,98.18
+1.8VS on TOP (solid shape): 35.34,16.95 36.28,16.01 37.38,16.01 37.76,16.39 38.26,16.39 38.44,16.21 38.44,14.77 38.26,14.6 36.28,14.6 34.64,16.24 34.1,16.24 34.03,16.31 34.03,16.83 34.17,16.97 35.32,16.97
+1.8VS on TOP (solid shape): 132.18,88.32 132.18,86.74 132.11,86.67 131.54,86.67 131.42,86.8 131.42,87.18 131.23,87.37 131.15,87.37 131.14,87.38 130.96,87.42 130.79,87.37 130.78,87.37 130.65,87.5 130.65,88.07 130.97,88.39 132.11,88.39
+1.8VS on TOP (solid shape): 121.95,47.18 121.95,46.48 122.14,46.29 122.38,46.29 122.46,46.28 122.55,46.29 123.16,46.29 123.35,46.1 123.35,45.33 123.16,45.14 123.16,44.06 123.06,43.96 122.34,43.96 122.27,44.03 122.27,44.61 121.61,45.27 121.26,45.27 121.07,45.46 121.07,47.05 121.26,47.24 121.89,47.24
+1.8VS on TOP (solid shape): 37.57,45.39 37.65,45.4 38.32,45.4 38.32,45.36 38.87,45.36 38.87,44.81 39.38,44.81 39.38,44.82 39.38,45.37 39.68,45.37 39.68,44.81 40.19,44.81 40.19,45.36 40.53,45.36 40.74,45.14 40.74,41.71 40.55,41.52 36.86,41.52 36.67,41.71 36.67,44.76 37.31,45.4 37.5,45.4
+1.8VS on TOP (solid shape): 123.57,62.33 123.57,62.14 123.59,62.14 123.59,61.93 123.57,61.93 123.57,61.29 123.49,61.21 122.86,61.21 122.85,61.21 122.73,61.23 122.61,61.21 122.6,61.21 121.86,61.21 121.85,61.21 121.73,61.23 121.61,61.21 121.6,61.21 121.51,61.21 121.26,61.46 121.26,62.1 121.51,62.35 122.44,62.35 122.73,62.64 123.25,62.64
+1.8VS on BOTTOM (solid shape): 41.45,44.4 41.45,43.19 41.25,42.99 38.02,42.99 37.92,43.09 37.92,44.37 38.11,44.56 41.29,44.56
+1.8VS on BOTTOM (solid shape): 123.86,96.28 123.86,95.82 122.97,94.93 121.19,94.93 120.75,95.37 120.75,96.71 121.32,97.28 122.87,97.28
+1.8VS on BOTTOM (solid shape): 111.14,33.34 111.14,32.18 109.83,30.86 107.21,30.86 106.9,31.17 106.9,31.62 107.29,32 109.49,32 109.68,32.18 109.68,33.31 109.79,33.42 111.06,33.42
+1.8VS on BOTTOM (solid shape): 88.49,38.03 88.49,33.33 88.17,33.02 84.17,33.02 83.92,33.27 83.92,35.32 83.96,35.33 84.17,35.61 83.96,35.88 83.92,35.89 83.92,38.1 84.17,38.35 88.17,38.35
+1.8VS on BOTTOM (solid shape): 121.75,63.72 122.04,63.54 122.34,63.72 122.35,63.75 122.87,63.75 123,63.62 122.98,63.55 122.94,63.49 122.87,63.47 122.61,63.39 122.49,63.14 122.48,63.12 122.33,62.97 122.32,62.97 122.23,62.51 122.69,62.6 122.69,62.61 122.84,62.76 122.86,62.76 123.09,62.86 123.2,63.08 123.2,63.1 123.25,63.15 123.3,63.1 123.3,63.08 123.4,62.87 123.62,62.78 123.63,62.76 123.63,61.71 123.44,61.52 123.23,61.61 123.02,61.52 122.45,61.52 122.23,61.61 122.02,61.52 121.79,61.52 121.48,61.84 121.48,62.12 121.54,62.31 121.48,62.49 121.48,63.12 121.54,63.3 121.48,63.48 121.48,63.49 121.48,63.56 121.67,63.75 121.73,63.75
+1.8VS on IN2 (solid shape): outline of 380 points within 144.84,56.47 150.58,62.1
+1.8VS on IN2 (solid shape): outline of 2567 points within 120.11,61.48 125.57,96.9
+1.8VS on IN3 (solid shape): outline of 810 points within 120.13,45.35 123.59,62.61
+1.8VS on VCC: 84.21,37.9 83.85,38.26 83.85,41.28 102.63,41.28 104.61,43.26 107.81,43.26 110.63,46.08 114.59,46.08 116.34,47.84 122.69,47.84 124.11,49.26 124.11,58.99 123.73,59.37 123.73,60.49 123.47,60.75 123.47,61.38 121.19,63.66 121.19,64.02 125,64.02 125,60.64 126.65,58.99 126.65,42.98 119.82,42.98 114.74,37.9
+1.8VS_LS on TOP (solid shape): 39.53,49.7 39.53,48.7 40.72,47.51 40.72,47.48 40.72,47.4 40.74,47.31 40.74,45.48 40.06,45.48 40.06,44.93 39.81,44.93 39.81,45.49 39.26,45.49 39.26,44.93 39,44.93 39,45.49 38.45,45.49 38.45,47.62 38.2,47.87 37.37,47.87 37.25,48 37.25,48.57 37.44,48.76 37.88,48.76 38.2,49.08 38.2,49.72 38.32,49.84 39.39,49.84
+1.35V_MEM_GFX on TOP (solid shape): 130.41,140.02 130.41,139.52 130.23,139.34 130.2,139.35 129.82,139.12 129.95,138.7 129.99,138.63 129.96,138.55 129.68,138.27 129.09,138.27 129.32,137.72 129.4,137.65 129.38,137.55 129.24,137.41 129.06,137.41 129.03,137.38 129.02,137.38 128.76,137.01 129.06,136.68 129.08,136.68 129.21,136.55 129.21,135.72 129.11,135.62 128.18,135.62 127.89,135.9 127.89,137.16 127.44,137.61 127.33,137.61 127.28,137.66 127.28,138.32 127.71,138.75 127.71,139.53 128.29,140.11 130.32,140.11
+1.35V_MEM_GFX on TOP (solid shape): outline of 663 points within 139.61,143.75 154.54,149.49
+1.35V_MEM_GFX on TOP (solid shape): outline of 4116 points within 147.68,112.52 164.59,149.53
+1.35V_MEM_GFX on BOTTOM (solid shape): 156.63,115.75 156.63,114.94 157.14,114.44 159.01,114.44 159.52,113.93 159.52,112.31 159.23,112.02 158.52,112.02 158.49,112.05 158.49,112.56 155.7,112.56 155.7,113.14 155.17,113.14 155.17,116 155.23,116.07 156.31,116.07
+1.35V_MEM_GFX on IN1 (solid shape): outline of 1913 points within 127.49,126.79 136.94,140.13
+1.35V_MEM_GFX on IN3 (solid shape): outline of 1344 points within 127.57,126.73 132.74,140.43
+1.35V_MEM_GFX on VCC: 141.34,112.58 136.39,117.53 126.49,117.53 126.49,124.9 128.4,126.81 128.4,128.93 127.13,130.2 127.13,131.25 128.4,132.52 128.4,134.64 126.49,136.55 126.49,145.22 128.25,146.98 132.46,146.98 136.35,150.87 146.51,150.87 146.82,151.19 154.36,151.19 155.12,150.43 161.42,150.43 162.11,149.74 163.42,148.42 163.42,134.02 163.57,133.66 164.51,132.74 164.72,132.52 164.72,118.69 163.12,117.09 160.2,117.09 158.28,115.16 158.28,112.58 ; 1 cut-out
+1.35VGPUP on TOP (solid shape): 155.1,111.97 155.1,109 154.91,108.81 153.53,108.81 153.39,108.95 153.39,112.01 153.5,112.12 154.95,112.12
+1.35VGPUP on BOTTOM (solid shape): 155.92,111.81 159.11,111.81 159.27,111.65 159.27,111.23 156.66,108.63 149.48,108.63 149.3,108.81 149.36,109.01 149.3,109.22 149.3,111.41 149.49,111.6 150.47,111.6 150.9,112.04 155.69,112.04
+2.5V_MEM on TOP (solid shape): 59.79,113.48 59.79,112.31 59.8,112.29 60.34,112.29 60.34,112.29 60.34,112.11 60.34,112.11 59.79,112.11 59.78,112.1 59.78,111.47 59.79,111.46 59.79,110.71 59.66,110.59 57.78,110.59 57.37,110.99 57.37,113.47 57.58,113.67 59.6,113.67
+2.5V_MEM on TOP (solid shape): outline of 249 points within 56.04,40.25 80.3,54.35
+2.5V_MEM on BOTTOM (solid shape): 80.21,44.13 80.21,42.54 80.16,42.49 77.06,42.49 76.81,42.74 76.81,43.76 76.92,43.87 77.89,43.87 78.15,44.14 80.2,44.14
+2.5V_MEM on BOTTOM (solid shape): 67.51,44.13 67.51,42.54 67.46,42.49 63.29,42.49 62.54,43.24 62.54,43.85 62.73,44.04 63.69,44.04 63.86,43.87 65.19,43.87 65.45,44.14 67.5,44.14
+2.5VP on TOP (solid shape): 61.84,113.97 62.03,113.91 62.23,113.97 62.5,113.97 62.71,113.9 62.92,113.96 62.93,113.97 63.07,113.97 63.33,113.85 63.59,113.97 65.02,113.97 65.59,113.39 67.04,113.39 67.27,113.17 67.27,112.68 67.17,112.58 65.45,112.58 64.96,112.09 63.51,112.09 63.5,112.1 62.87,112.1 62.76,111.99 61.81,111.92 61.3,111.1 61.3,111.06 60.25,111.06 59.93,111.38 59.93,111.98 60.39,111.98 60.39,111.98 60.46,111.98 60.46,112.06 60.47,112.06 60.47,112.34 60.46,112.35 60.46,112.42 60.39,112.42 60.39,112.42 59.93,112.42 59.93,113.61 60.28,113.97
+3.3V_VBUS_IN on TOP (solid shape): 55.59,126.62 55.89,126.62 56.48,126.03 57.18,126.03 57.19,126.02 58.37,126.02 58.74,125.65 58.74,124.43 58.7,124.39 56.17,124.39 55.86,124.7 55.76,124.89 55.58,124.98 55.42,125.14 55.3,125.14 55.2,125.15 55.1,125.14 53.99,125.14 53.4,125.73 53.4,126.49 53.54,126.62 55.58,126.62
+3.3V_VDD_PIC on TOP (solid shape): outline of 199 points within 29.57,119.04 35.7,127.91
+3.3V_VDD_PIC on TOP (solid shape): outline of 223 points within 33.28,86.28 43.67,115.48
+3.3V_VDD_PIC on BOTTOM (solid shape): 44.12,116.07 44.12,112.13 44.04,111.91 44.11,111.69 44.12,111.68 44.12,111.56 43.71,111.15 39.97,111.15 39.82,111.31 39.82,112.82 40.04,113.04 41.59,113.04 42.09,113.54 42.09,115.87 42.43,116.21 43.98,116.21
+3.3V_VDD_PIC on BOTTOM (solid shape): 30.75,129.22 30.82,129.18 30.85,129.1 31.03,128.74 31.43,128.78 31.49,128.8 31.78,128.7 32.08,128.8 32.14,128.78 32.44,128.7 32.69,128.89 32.76,128.94 32.85,128.92 33.31,128.46 34.69,128.46 34.81,128.34 34.81,125.98 34.68,125.85 33.24,125.85 33.03,126.06 33.03,126.73 32.64,127.12 29.4,127.12 28.76,127.76 28.76,128.39 28.82,128.46 29.37,128.46 30.13,129.22
+3V_DVDD on TOP (solid shape): 32.58,10.66 32.58,8.77 32.56,8.75 31.97,8.75 31.87,8.64 31.87,8.43 31.78,8.34 30.83,8.34 30.72,8.45 30.72,10.59 31.09,10.96 32.29,10.96
+3V_DVDD on TOP (solid shape): 35.48,9.91 35.77,9.76 36.06,9.91 36.69,9.91 36.74,9.86 36.74,8.66 36.6,8.52 35.37,8.52 35.24,8.64 35.24,9.84 35.31,9.91
+3V_DVDD on IN2 (solid shape): outline of 409 points within 29.87,8.06 40.19,19
+3V_HUB on TOP (solid shape): 218.6,59.75 219.03,59.75 219.04,59.75 220.39,59.75 220.44,59.75 220.63,59.56 220.63,59.37 220.44,59.18 218.15,59.18 216.91,57.94 216.91,56.4 216.46,55.95 213.23,55.95 212.95,55.68 212.95,55.45 212.95,55.44 212.92,55.3 212.95,55.17 212.95,55.16 212.95,54.82 212.95,54.82 212.92,54.68 212.95,54.55 212.95,54.54 212.95,54.42 212.92,54.39 211.27,54.39 211.17,54.29 211.17,53.4 211.24,53.34 211.87,53.34 212,53.21 212,51.59 211.84,51.43 209.73,51.43 209.65,51.52 209.65,54.44 209.69,54.61 209.65,54.77 209.65,55.94 210.25,56.54 212.16,56.54 212.16,56.55 215.3,56.55 215.81,57.05 215.81,58.2 217.48,59.88 218.47,59.88
+3V_HUB on BOTTOM (solid shape): 219.49,63.37 219.49,60.32 217.27,58.1 217.27,56.13 216.95,55.81 215.62,55.81 215.3,56.13 215.3,58.73 217.52,60.96 217.52,62.67 217.27,62.92 217.27,63.24 217.59,63.56 219.3,63.56
+3V_HUB on IN1 (solid shape): 217.02,57.25 217.02,56.19 216.84,56.01 213.11,56.01 212.88,56.24 212.88,57.25 213.06,57.43 216.84,57.43
+3VALW on TOP (solid shape): 99.09,32.54 99.09,26.6 98.91,26.43 97.62,26.43 97.53,26.52 97.53,32.34 97.88,32.69 98.93,32.69
+3VALW on TOP (solid shape): 69.12,138.04 69.12,137.54 69.06,137.47 69.06,136.71 68.93,136.58 68.11,136.58 67.98,136.71 67.98,136.93 68.09,137.05 68.13,137.22 68.13,138.12 69.05,138.12
+3VALW on TOP (solid shape): 171.98,28.91 172.04,28.9 172.22,28.9 172.27,28.91 172.31,28.86 172.31,28.3 172.31,28.25 172.31,28.19 172.31,27.72 172.18,27.59 170.95,27.59 170.89,27.65 170.89,28.81 171.01,28.93 171.92,28.93
+3VALW on TOP (solid shape): 31.07,56.68 31.84,56.68 31.84,56.76 31.99,56.76 31.99,56.68 32.13,56.68 32.61,56.19 32.61,53.97 33.05,53.53 35.78,53.53 37.05,52.26 37.05,51.85 37.05,51.3 36.93,51.18 36.17,51.18 36.1,51.25 35.01,51.25 35.01,51.24 34.32,51.24 33.94,51.62 33.49,51.62 33.34,51.76 32.99,51.85 32.74,51.58 32.74,51.56 32.23,51.05 30.32,51.05 30.07,51.3 30.07,56.57 30.26,56.76 31.07,56.76
+3VALW on TOP (solid shape): 75.55,115.82 75.68,115.79 75.8,115.82 75.81,115.82 76.13,115.82 76.13,115.82 76.26,115.79 76.38,115.82 76.39,115.82 76.71,115.82 76.72,115.82 76.84,115.79 76.97,115.82 76.98,115.82 77.17,115.82 77.28,115.71 77.28,115.71 77.42,115.71 77.42,115.39 77.84,115.39 77.84,114.2 77.75,114.11 77.1,114.11 77.1,114.1 76.11,114.1 76.11,114.63 75.67,114.63 75.67,114.1 75.37,114.1 75.28,114.19 75.28,115.37 75.29,115.38 75.32,115.53 75.3,115.67 75.29,115.7 75.41,115.82 75.54,115.82
+3VALW on TOP (solid shape): 182.79,60.13 182.79,58.38 180.75,56.34 175.58,56.34 175.46,56.22 175.46,55.08 173.61,53.24 173.61,53.12 173.57,53.08 173.57,52.36 172.26,51.04 172.26,47.21 171.34,46.29 171.34,46.11 171.3,46.1 171.08,45.77 171.3,45.43 171.34,45.42 171.34,44.96 171.27,44.75 171.34,44.54 171.34,43.23 170.94,42.83 170.78,42.81 170.65,42.72 170.04,42.72 169.97,42.78 169.97,43.45 170.03,43.51 170.07,43.59 170.3,43.82 170.3,47.05 171.18,47.94 171.18,50.65 171.31,50.88 171.18,51.12 171.18,51.39 172.57,52.78 172.57,53.77 174.34,55.55 174.34,56.38 175.3,57.34 175.52,57.34 175.53,57.31 175.84,57.13 176.16,57.31 176.17,57.34 177.52,57.34 177.54,57.31 177.85,57.13 178.16,57.31 178.18,57.34 179.8,57.34 180.11,57.65 180.11,59.37 180.67,59.37 180.67,59.85 180.11,59.85 180.11,60.14 180.2,60.23 182.7,60.23
+3VALW on TOP (solid shape): outline of 215 points within 23.05,82.99 34.16,93.67
+3VALW on BOTTOM (solid shape): 182.79,60.08 182.79,58.24 182.66,58.1 181.75,58.1 181.51,58.34 181.51,59.91 181.77,60.17 182.7,60.17
+3VALW on BOTTOM (solid shape): 136.5,26.79 134.78,26.79 134.7,26.88 133.64,26.88 133.56,26.79 133.3,26.79 133.01,27.08 133.01,29.04 133.24,29.27 136.5,29.27
+3VALW on BOTTOM (solid shape): 100.68,34.43 100.68,34.05 100.3,33.68 100.3,31.45 100.18,31.33 98.05,31.33 97.9,31.48 97.9,34.29 98.1,34.49 100.62,34.49
+3VALW on BOTTOM (solid shape): 225.48,64.27 225.48,62.98 225.37,62.87 224.95,62.87 224.71,62.96 224.47,62.87 224.05,62.87 223.96,62.98 223.82,63.04 223.82,64.17 223.97,64.31 225.45,64.31
+3VALW on BOTTOM (solid shape): 32.48,58.62 32.48,52.13 32.17,51.81 30.13,51.81 29.84,52.1 29.84,53.58 29.54,53.89 29.26,53.89 28.91,54.24 28.91,55.15 29.07,55.3 29.12,55.3 29.14,55.28 29.42,55.28 29.47,55.33 29.47,57.29 29.42,57.34 29.07,57.34 28.91,57.49 28.91,57.81 28.82,57.9 28.82,57.97 28.76,57.97 28.76,58.68 29.02,58.94 32.16,58.94
+3VALW on BOTTOM (solid shape): 22.06,128.68 22.28,128.68 22.28,128.68 22.44,128.65 22.59,128.68 22.6,128.68 22.82,128.68 22.82,128.73 22.97,128.73 22.97,128.68 23.19,128.68 23.2,128.68 23.35,128.65 23.5,128.68 23.51,128.68 23.73,128.68 23.73,128.73 26.28,128.73 26.38,128.62 26.38,128 26.28,127.9 22.44,127.9 22.17,128.02 21.9,127.9 17.33,127.9 17.19,128.04 17.19,128.59 17.33,128.73 22.06,128.73
+3VALW on BOTTOM (solid shape): 172.06,43.92 172.06,43.92 172.25,43.73 172.25,39.38 173.3,38.33 173.3,35.11 173.25,35.06 173.22,35.06 172.88,34.94 172.82,34.58 172.82,34.57 172.82,28.7 172.78,28.63 172.71,28.6 172.38,28.47 172.33,28.12 172.34,28.09 172,27.75 171.79,27.75 171.23,28.31 171.23,28.32 171.19,28.36 171.19,28.53 172.02,29.36 172.02,29.99 172.04,30.01 172.04,32.72 171.76,33 171.76,36.33 172.04,36.61 172.04,38.4 172.02,38.42 172.02,38.45 171.46,39.01 171.46,42.82 171.24,43.04 170.34,43.04 170.19,43.19 170.19,43.81 170.33,43.95 172.02,43.95
+3VALW on IN1 (solid shape): 133.03,47.46 133.03,47.14 130.85,44.96 130.76,44.94 130.69,45 130.23,45.23 130.02,44.76 130,44.67 129.92,44.62 128.07,44.62 127.96,44.52 127.88,44.59 127.88,47.32 128.11,47.54 132.95,47.54
+3VALW on VCC: outline of 116 points within 13.69,21.27 227.48,137.6 ; 1 cut-out
+3VALW_EC on TOP (solid shape): 36.56,88.07 36.71,88.07 36.71,88.07 36.84,88.04 36.96,88.07 36.97,88.07 37.56,88.07 37.69,87.94 37.69,84.83 37.5,84.64 37.5,82.61 37.37,82.48 37.08,82.48 36.67,82.89 36.68,82.92 36.42,83.41 36,83.06 35.97,82.99 35.9,82.96 35.71,82.9 35.58,82.76 35.5,82.7 35.41,82.73 34.1,84.04 34.1,84.88 34.11,84.89 34.2,84.89 34.2,84.98 34.26,85.05 34.26,85.85 34.71,86.29 34.71,87.82 35.1,88.21 36.42,88.21
+3VALW_EC on IN1 (solid shape): outline of 690 points within 33,66.09 53.07,70.82
+3VALWP on TOP (solid shape): 27.94,53.64 27.94,50.71 27.64,50.41 25.38,50.41 24.86,49.89 24.32,49.89 24.13,50.08 24.13,53.82 24.47,54.16 24.47,54.17 27.4,54.17
+3VALWP on BOTTOM (solid shape): 28.63,58.42 28.63,54.1 28,53.46 28,48.67 27.88,48.55 24.31,48.55 24.09,48.77 24.09,51.9 24.11,51.92 24.11,56.77 24.78,57.44 24.88,57.47 24.95,57.4 24.99,57.32 25.04,57.25 25.07,57.18 25.05,57.11 25.08,56.6 25.59,56.65 25.66,56.68 25.74,56.65 26.36,56.9 25.73,57.11 25.65,57.07 25.57,57.11 25.56,57.12 25.52,57.19 25.55,57.26 25.65,57.5 25.57,57.73 25.54,57.8 25.57,57.86 25.64,58.04 25.62,58.23 25.6,58.26 26.07,58.73 28.32,58.73
+3VGS on BOTTOM (solid shape): 110.42,125.62 110.42,124.06 110.15,123.79 108.69,123.79 108.52,123.96 108.52,125.69 108.58,125.75 110.28,125.75
+3VGS on BOTTOM (solid shape): 131.03,115.59 131.03,114.63 130.73,114.33 128.62,114.33 128.15,114.79 127.86,114.79 127.77,114.88 127.77,115.59 127.87,115.69 130.93,115.69
+3VGS on BOTTOM (solid shape): 122.2,116.23 122.2,114.83 122.12,114.76 121.33,114.76 120.92,115.16 119.57,115.16 119.42,115.32 119.42,116.22 119.55,116.35 122.07,116.35
+3VGS on IN1 (solid shape): outline of 404 points within 108.44,115.71 123.57,125.05
+3VGS on IN2 (solid shape): 127.61,116.77 127.73,116.75 127.86,116.77 127.87,116.77 130.39,116.77 130.5,116.66 130.5,114.64 130.21,114.35 127.76,114.35 127.49,114.49 127.21,114.36 127.19,114.35 127.13,114.35 127.11,114.36 126.83,114.49 126.56,114.35 124.95,114.35 124.87,114.4 124.87,114.5 124.57,115.05 124.26,114.5 124.27,114.4 124.18,114.35 123.1,114.35 122.84,114.46 122.58,114.35 121.24,114.35 120.98,114.46 120.71,114.35 120.21,114.35 119.78,114.78 119.78,116.53 120.02,116.77 127.6,116.77
+3VLP on TOP (solid shape): 60.07,28.11 60.07,26.47 59.98,26.39 59.24,26.39 59.03,26.6 59.03,28.19 59.05,28.21 59.97,28.21
+3VLP on TOP (solid shape): 159.47,32.95 159.47,31.61 159.39,31.53 159.07,31.53 159.07,32.08 158.63,32.08 158.63,31.53 157.77,31.53 157.77,32.95 157.96,33.14 159.28,33.14
+3VLP on TOP (solid shape): 21.94,45.31 21.94,44.92 21.87,44.84 21.87,43.84 21.73,43.7 21.12,43.7 20.79,43.37 20.79,42.03 20.63,41.87 20.63,41.85 20.54,41.77 19.33,41.77 19.2,41.89 19.2,43.04 19.53,43.04 19.53,42.98 19.55,42.93 19.57,42.88 19.59,42.84 19.63,42.79 19.66,42.76 19.71,42.73 19.76,42.7 19.81,42.69 19.86,42.68 19.91,42.68 19.97,42.69 20.02,42.7 20.07,42.73 20.11,42.76 20.15,42.79 20.18,42.84 20.21,42.88 20.23,42.93 20.24,42.98 20.24,43.04 20.24,43.09 20.23,43.14 20.21,43.19 20.18,43.24 20.15,43.28 20.11,43.32 20.07,43.35 20.02,43.37 19.97,43.38 19.91,43.39 19.86,43.39 19.81,43.38 19.76,43.37 19.71,43.35 19.66,43.32 19.63,43.28 19.59,43.24 19.57,43.19 19.55,43.14 19.53,43.09 19.53,43.04 19.2,43.04 19.2,43.5 19.81,44.11 19.81,44.24 20.83,45.25 20.89,45.19 20.93,45.16 20.98,45.13 21.03,45.12 21.09,45.11 21.14,45.11 21.19,45.11 21.24,45.13 21.29,45.15 21.34,45.18 21.38,45.22 21.41,45.26 21.44,45.3 21.46,45.36 21.89,45.36
+3VLP on BOTTOM (solid shape): 60.7,26.44 60.7,25.89 60.41,25.6 60.05,25.6 59.08,26.58 59.08,27.2 59.2,27.33 59.81,27.33
+3VLP on BOTTOM (solid shape): 131.32,30.25 131.32,28.91 130.93,28.52 129.49,28.52 129.42,28.59 129.42,28.68 129.4,28.68 129.4,30.21 129.54,30.34 131.22,30.34
+3VLP on BOTTOM (solid shape): 21.93,45.33 21.93,45.04 21.87,44.98 21.87,43.43 21.8,43.37 21.03,43.37 20.96,43.43 20.96,44.08 21.02,44.17 21.04,44.27 21.04,44.9 21.04,44.94 21.03,44.97 21.05,45.05 21.13,45.09 21.34,45.17 21.46,45.36 21.47,45.4 21.87,45.4
+3VLP on IN1 (solid shape): outline of 187 points within 129.36,29.43 159.65,36.09
+3VS on TOP (solid shape): 26.35,117.97 26.35,116.23 26.13,116.01 24.47,116.01 24.33,116.15 24.33,118 24.48,118.16 26.16,118.16
+3VS on TOP (solid shape): 27.83,100.03 27.83,98.89 27.72,98.78 25.1,98.78 24.92,98.95 24.92,99.87 25.17,100.13 27.73,100.13
+3VS on TOP (solid shape): 41.69,56.19 41.69,53.72 41.44,53.46 40.42,53.46 40.04,53.84 40.04,54.92 39.59,55.37 36.23,55.37 34.64,53.78 33.05,53.78 32.86,53.97 32.86,55.94 34.39,57.46 40.42,57.46
+3VS on TOP (solid shape): 23.34,28.95 23.91,28.95 23.91,29.52 24.16,29.52 24.16,28.95 24.74,28.95 24.74,29.52 25.12,29.52 25.18,29.46 25.18,26.37 25.05,26.25 23,26.25 22.77,26.47 22.77,29.4 22.89,29.52 23.34,29.52
+3VS on TOP (solid shape): 131.38,97 131.38,95.9 131.31,95.84 130.2,95.84 129.96,95.6 129.96,94.49 129.88,94.42 129.07,94.42 129,94.48 129,95.49 128.83,95.66 127.1,95.66 127.05,95.62 127.05,94.88 126.97,94.8 125.31,94.8 125.17,94.94 125.17,96.95 125.34,97.12 131.25,97.12
+3VS on TOP (solid shape): 79.82,39.24 79.82,38.49 79.73,38.4 79.59,38.46 79.43,38.48 78.93,38.48 78.67,38.42 78.46,38.27 76.45,38.27 76.32,38.4 76.32,39.34 76.51,39.53 79.52,39.53
+3VS on TOP (solid shape): 176.25,39.12 176.26,39.12 176.82,38.55 180.75,38.55 180.83,38.48 180.83,37.84 180.86,37.81 180.71,37.66 180.21,37.66 180.19,37.64 180.16,37.64 180.16,37.61 180.09,37.54 180.09,36.95 179.87,36.74 176.75,36.74 174.28,39.21 174.3,39.24 174.35,39.5 174.21,39.72 174.16,39.8 174.19,39.88 174.52,40.21 175.16,40.21
+3VS on TOP (solid shape): 214.84,32.53 216.13,32.53 216.32,32.33 216.34,32.3 216.35,32.26 216.73,31.92 217.06,32.31 217.09,32.38 217.17,32.42 218.1,32.42 218.18,32.33 218.18,31.66 218.1,31.58 217.09,31.58 216.86,31.35 216.4,31.35 216.4,31.35 215.06,31.35 214.82,31.11 214.82,30.83 214.68,30.7 213.92,30.7 213.44,31.18 213.44,32.37 213.7,32.63 214.73,32.63
+3VS on TOP (solid shape): 80.04,123.8 80.04,122.09 79.99,121.82 80.15,121.6 80.16,121.59 80.43,121.32 81.49,121.32 81.93,120.88 87.53,120.88 91.52,116.9 91.52,116.6 90.44,115.52 90.1,115.52 86.87,118.75 84.29,118.75 84.28,118.8 84.15,119.03 83.9,119.12 83.42,119.12 83.22,119.07 83.08,118.91 83.07,118.89 83.03,118.89 82.9,118.75 80.95,118.75 80.95,118.77 80.18,118.77 80.18,118.75 80.03,118.75 80.03,118.77 79.36,118.77 78.8,119.32 78.8,122.95 78.81,122.96 78.81,123.78 78.95,123.92 79.92,123.92
+3VS on TOP (solid shape): 15.78,112.96 15.78,108.68 15.57,108.47 12.38,108.47 12.24,108.61 12.24,109.7 12.37,109.83 13.71,109.83 13.89,110 13.92,109.99 14.29,110.03 14.42,110.38 14.43,110.45 14.49,110.5 14.65,111.03 14.09,111.06 13.98,111.04 13.92,111.13 13.92,112.92 14.07,113.08 15.67,113.08
+3VS on TOP (solid shape): outline of 232 points within 200.08,29.75 208.47,34.4
+3VS on BOTTOM (solid shape): 224.41,33.55 224.41,32.47 224.32,32.38 223.07,32.38 222.96,32.49 222.96,33.49 223.07,33.6 224.36,33.6
+3VS on BOTTOM (solid shape): 14.47,112.99 14.47,112.04 14.4,111.97 13.11,111.97 13.02,112.05 13.02,112.89 13.18,113.04 14.42,113.04
+3VS on BOTTOM (solid shape): 110.91,35.5 111.07,35.5 111.34,35.22 111.34,33.92 111.1,33.67 109.7,33.67 109.61,33.77 109.61,34.61 109.22,34.99 109.22,35.43 109.3,35.5 110.9,35.5
+3VS on BOTTOM (solid shape): 181.97,64.44 182.94,64.44 183.09,64.29 183.09,63.52 181.99,62.42 181.66,62.42 181.01,63.07 181.01,63.08 180.6,63.49 180.6,63.71 181.37,64.49 181.97,64.49
+3VS on BOTTOM (solid shape): 127.66,115.92 127.66,115.66 127.64,115.65 127.64,114.83 127.66,114.81 127.66,113.97 127.61,113.92 126.75,113.92 126.66,114.02 126.66,114.86 126.59,114.93 125.79,114.93 125.65,114.78 125.65,114.14 125.6,114.1 125.15,114.1 124.84,114.4 124.84,114.47 124.85,114.48 124.72,115.01 124.22,114.79 124.21,114.75 123.53,114.75 123.46,114.82 123.46,115.82 123.67,116.03 127.55,116.03
+3VS on BOTTOM (solid shape): outline of 651 points within 179.16,29.65 215.61,38.3
+3VS on IN1 (solid shape): 72.68,46.22 72.68,46 72.63,45.99 72.36,45.9 72.15,45.72 66.77,45.72 65.01,43.95 61.79,43.95 61.67,43.82 61.28,43.82 61.14,43.96 61.14,44.19 61.24,44.41 61.15,44.64 61.34,44.83 64.87,44.83 66.39,46.35 72.55,46.35
+3VS on IN1 (solid shape): outline of 167 points within 33.28,53.28 56.79,57.09
+3VS on IN1 (solid shape): outline of 427 points within 213.77,30.34 220.76,49.39
+3VS on IN1 (solid shape): outline of 856 points within 13.88,110.49 56.55,117.23
+3VS on IN2 (solid shape): 26.26,117.1 26.26,115.81 25.6,115.14 25.32,115.14 24.84,115.63 24.84,115.86 25.34,116.36 25.34,117.12 25.48,117.25 26.1,117.25
+3VS on IN2 (solid shape): 27.43,101.16 27.43,99.08 27.23,98.88 26.35,98.88 26.14,99.08 26.14,100.98 26.46,101.3 27.29,101.3
+3VS on IN2 (solid shape): outline of 90 points within 213.77,29.91 224.37,33.56
+3VS on IN2 (solid shape): outline of 653 points within 22.79,26.77 37.64,56.78
+3VS on IN3 (solid shape): 185.86,39.07 186.22,38.7 186.57,39.07 186.57,39.12 187.11,39.12 187.18,39.05 187.18,38.86 186.71,38.39 182.88,38.39 182.18,37.7 179.13,37.7 179.03,37.79 179.03,38.76 179.07,38.8 181.1,38.8 181.42,39.12 185.86,39.12
+3VS on IN3 (solid shape): 125.61,105.11 125.61,104.63 127.16,103.08 127.16,94.85 126.79,94.48 126.79,93.53 126.76,93.46 126.68,93.43 126.63,93.43 126.57,93.42 126.5,93.43 126.45,93.48 125.81,93.48 126.22,92.98 126.28,92.97 126.33,92.92 126.48,92.77 126.68,92.72 126.76,92.69 126.79,92.62 126.79,92.16 126.45,91.82 125.62,91.82 125.64,92.12 125.42,92.33 125.64,92.63 125.47,92.96 125.43,93.02 125.43,93.08 125,93.56 124.91,92.92 124.95,92.86 124.95,92.79 124.96,92.51 125.17,92.32 124.97,92.11 125,91.82 124.52,91.82 124.2,92.13 124.2,101.53 121.83,103.91 121.83,105.08 122.11,105.36 125.36,105.36
+3VS on VCC: outline of 99 points within 54.64,30.79 206.47,118.55
+3VS_APU on IN1 (solid shape): outline of 1362 points within 122.02,50.54 127.92,63.37
+3VS_CAM on TOP (solid shape): 214.65,46.59 214.7,46.54 215.08,46.54 215.19,46.43 215.19,45.34 215.07,45.21 214.08,45.21 213.91,45.38 213.91,46.27 213.77,46.41 213.49,46.41 213.43,46.41 213.33,46.52 213.33,47.45 213.48,47.45 213.55,47.46 213.62,47.48 213.98,47.48 214.06,47.57 214.65,47.57
+3VS_CAM on BOTTOM (solid shape): 214.11,47.32 214.11,46.37 214.01,46.28 213.7,46.28 213.43,46.41 213.15,46.28 211.93,46.28 211.85,46.32 211.83,46.4 211.83,46.48 211.81,46.56 211.8,46.59 211.86,46.66 213.01,46.66 213.24,46.89 213.24,47.34 213.33,47.43 214,47.43
+3VS_SSD on TOP (solid shape): 28.23,34.86 28.23,32.79 28.03,32.37 28.41,32.11 28.43,32.11 28.53,32.01 28.53,29.01 28.28,28.76 25.94,28.76 25.5,29.21 25.5,29.46 25.24,29.71 24.55,29.71 24.55,29.14 24.35,29.14 24.35,29.71 23.72,29.71 23.72,29.14 23.53,29.14 23.53,29.71 21.31,29.71 21.05,29.97 21.05,30.9 21.06,30.91 21.06,31.76 21.31,32 26.96,32 27.21,32.25 27.21,32.39 27.21,32.4 27.23,32.51 27.21,32.62 27.21,32.62 27.21,33.21 26.89,33.52 26.89,34.86 27.09,35.05 28.04,35.05
+3VS_SSD on BOTTOM (solid shape): outline of 423 points within 20.28,25.59 39.38,30.92
+3VS_TOUCH on TOP (solid shape): outline of 132 points within 111.14,28.57 121,33.73
+3VS_TOUCH on BOTTOM (solid shape): 119.8,32.51 119.8,31.49 119.6,31.29 118.79,31.29 118.43,30.93 118.43,29.68 118.27,29.52 115.91,29.52 115.84,29.59 115.84,30.95 116.05,31.16 117.1,31.16 117.38,31.44 117.42,31.44 117.42,31.48 117.43,31.49 117.43,32.01 117.57,32.16 117.6,32.15 117.9,32.27 117.99,32.58 118.01,32.66 118.09,32.7 119.6,32.7
+3VS_WLAN_NGFF on TOP (solid shape): 73.14,138.06 73.14,136.2 73.08,136.14 69.89,136.14 69.89,136.14 69.31,136.14 69.19,136.27 69.19,136.66 69.19,137.22 69.64,137.67 69.67,137.64 69.91,137.58 70.14,137.68 70.57,138.12 73.08,138.12
+3VS_WLAN_NGFF on TOP (solid shape): 78.21,120.62 78.21,118.37 78.04,118.15 78.08,117.87 78.1,117.84 78.03,117.77 74.48,117.77 74.33,117.62 74.33,117.34 74.22,117.23 73.07,117.23 72.83,116.99 72.01,116.99 71.92,117.08 71.92,118.8 71.45,119.27 71.45,119.51 71.48,119.52 71.61,119.63 71.67,119.78 71.68,119.83 72.56,119.83 73.3,119.08 74.06,119.08 74.34,118.81 74.87,118.81 74.96,118.79 75.06,118.81 76.72,118.81 76.82,118.91 76.82,120.61 76.88,120.67 78.16,120.67
+3VS_WLAN_NGFF on BOTTOM (solid shape): 72.3,139.57 72.3,138.3 72.23,138.23 70.8,138.23 70.66,138.23 70.43,138.01 70.43,136.15 70.37,136.08 68.83,136.08 68.72,136.19 68.72,137.96 69.53,137.96 69.53,137.9 69.54,137.85 69.55,137.8 69.58,137.75 69.61,137.71 69.64,137.67 69.68,137.64 69.73,137.61 69.78,137.59 69.83,137.58 69.88,137.57 69.94,137.58 69.99,137.59 70.04,137.61 70.08,137.64 70.13,137.67 70.16,137.71 70.19,137.75 70.22,137.8 70.23,137.85 70.24,137.9 70.24,137.96 70.23,138.01 70.22,138.06 70.19,138.11 70.16,138.15 70.13,138.19 70.08,138.22 70.04,138.25 69.99,138.27 69.94,138.28 69.88,138.29 69.83,138.28 69.78,138.27 69.73,138.25 69.68,138.22 69.64,138.19 69.61,138.15 69.58,138.11 69.55,138.06 69.54,138.01 69.53,137.96 68.72,137.96 68.72,139.57 68.79,139.63 72.23,139.63
+3VS_WLAN_NGFF on BOTTOM (solid shape): 72.35,121.5 72.35,120.79 72.3,120.71 72.21,120.7 72.03,120.72 71.87,120.65 71.8,120.63 71.74,120.65 71.5,120.75 71.19,120.63 71.12,120.66 70.53,120.39 71.13,120.12 71.19,120.15 71.26,120.12 71.48,120.04 71.78,120.13 72.07,120.01 72.3,120.08 72.7,119.69 72.7,119.55 73.34,118.91 73.46,118.91 73.61,118.76 73.61,117.86 71.17,117.86 71.17,118.93 70.77,119.33 69.88,119.33 69.88,119.33 69.88,121.43 70.05,121.6 72.25,121.6
+3VS_WLAN_NGFF on IN2 (solid shape): outline of 882 points within 69.33,118.43 75.29,137.55
+5V_HDD on TOP (solid shape): 195.93,40.32 195.93,37.68 195.74,37.49 192.3,37.49 191.97,37.82 191.16,37.82 190.39,37.05 188.89,37.05 188.81,37.13 188.81,39.77 189.13,40.1 190.01,40.1 190.01,39.55 190.51,39.55 190.51,40.1 190.81,40.1 190.81,39.55 191.31,39.55 191.31,40.1 191.79,40.1 191.79,40.11 192.56,40.11 192.79,40.33 195.92,40.33
+5V_HDD on BOTTOM (solid shape): 186.22,38.43 186.22,37.92 186.14,37.83 185.6,37.83 185.47,37.71 185.47,36.86 185.5,36.84 185.47,36.8 185.46,36.42 185.79,36.24 185.82,36.24 185.9,36.16 185.9,35.24 185.64,34.98 183.82,34.98 183.7,35.11 183.7,38.13 183.86,38.29 184.92,38.29 185.16,38.53 186.12,38.53
+5V_HDD on IN3 (solid shape): outline of 147 points within 183.6,36.17 193.52,38.37
+5V_HDD on VCC: 183.55,36.55 183.74,36.36 184.66,36.36 186.26,37.96 187.85,37.96 188.01,38.11 188.01,38.11 188.06,38.16 189.72,38.16 190.05,38.49 191.67,38.49 192.43,37.73 193.48,37.73 193.58,37.83 193.58,38.43 192.88,39.14 188.21,39.14 187.67,38.59 186.08,38.59 185.67,38.18 184.26,38.18 183.55,37.47
+5V_HDMI on TOP (solid shape): 17.09,102.61 17.09,100.51 17,100.42 16.4,100.42 16.26,100.28 16.26,99.59 16.16,99.5 14.77,99.5 14.45,99.82 14.45,102.55 14.83,102.93 16.78,102.93
+5V_HDMI on BOTTOM (solid shape): 12.9,113.53 12.9,111.98 12.04,111.98 11.97,112.04 11.97,113.74 12.06,113.82 12.61,113.82
+5V_HDMI on IN1 (solid shape): 12.93,113.36 12.93,112.52 12,111.59 12,108.13 12.01,108.12 12.01,107.66 12.41,107.27 12.72,106.88 13.11,107.2 14.56,107.2 15.75,106.01 15.75,100.79 15.41,100.45 12.42,100.45 12.16,100.71 12.16,102.17 12.42,102.42 14,102.42 14.27,102.68 14.27,105.35 13.78,105.84 11.87,105.84 10.44,107.27 10.44,112.39 11.89,113.84 12.45,113.84
+5V_HDMI on IN2 (solid shape): outline of 248 points within 12.07,100.54 16.18,113.83
+5V_PVDD on TOP (solid shape): 26.83,10.6 26.83,8.82 25.88,7.87 25.69,7.87 25.56,8 25.56,8.21 25.87,8.52 26,8.61 26.06,8.76 26.18,8.89 26.39,8.89 26.64,9.14 26.64,9.65 26.51,9.77 26.51,10.6 26.58,10.66 26.77,10.66
+5V_PVDD on TOP (solid shape): 28.8,10.61 28.8,9.83 29.12,9.52 29.13,9.52 29.21,9.44 29.69,9.44 29.8,9.33 29.8,8.22 29.91,8.11 32.05,8.11 32.17,8.22 32.17,8.48 32.29,8.61 33.63,8.61 33.94,8.29 36.57,8.29 36.61,8.25 36.61,6.71 36.53,6.64 34.24,6.64 33.53,7.35 29.43,7.35 29.3,7.48 29.3,8.84 28.55,9.58 28.55,10.6 28.62,10.67 28.75,10.67
+5V_PVDD on BOTTOM (solid shape): 30.41,8.67 33.4,8.67 33.56,8.5 33.56,7.58 33.44,7.45 30.49,7.45 29.22,8.72 29.22,8.74 29.11,8.95 28.91,9.05 28.89,9.05 28.77,9.16 28.77,9.18 28.54,9.48 28.17,9.39 27.91,9.39 26.32,7.81 25.69,7.81 25.56,7.93 25.56,8.25 26.28,8.97 26.3,8.98 26.5,9.07 26.61,9.25 26.61,9.27 27.56,10.22 28.86,10.22
+5V_USB_PWR1 on TOP (solid shape): 19.8,56.07 19.8,53.73 19.71,53.64 17.58,53.64 17.44,53.79 17.44,55.11 18.51,56.18 18.51,56.19 19.68,56.19
+5V_USB_PWR1 on TOP (solid shape): 19.55,51.7 19.55,51.27 19.46,51.19 19.46,48.1 19.46,48.09 19.43,47.94 19.46,47.79 19.46,47.78 19.46,47.06 19.56,46.96 19.42,46.82 17.87,46.82 17.8,46.86 17.77,46.94 17.7,47.27 17.42,47.47 17.41,47.48 17.24,47.64 17.24,49.21 17.41,49.38 17.41,49.54 17.54,49.75 17.5,49.99 17.5,50.08 17.57,50.14 17.85,50.38 17.77,50.74 17.74,50.81 17.77,50.88 17.86,51.05 17.85,51.24 17.82,51.3 17.78,51.35 17.76,51.42 17.78,51.48 17.84,51.58 17.86,51.68 17.9,51.75 17.97,51.78 19.48,51.78
+5V_USB_PWR1 on BOTTOM (solid shape): 22.56,59.76 22.56,58.62 22.44,58.5 19.43,58.5 19.26,58.33 19.26,57.57 18.84,57.15 18.84,56.86 19.05,56.65 19.23,56.65 19.26,56.62 19.26,54.53 19.07,54.34 18.59,54.34 18.5,54.25 17.54,54.25 16.1,55.69 15.5,55.69 15.38,55.81 15.38,58.63 17.83,58.63 17.83,58.58 17.83,58.53 17.85,58.48 17.87,58.43 17.9,58.38 17.94,58.34 17.98,58.31 18.03,58.28 18.08,58.27 18.13,58.25 18.18,58.25 18.24,58.25 18.29,58.27 18.34,58.28 18.38,58.31 18.42,58.34 18.46,58.38 18.49,58.43 18.51,58.48 18.53,58.53 18.54,58.58 18.54,58.63 18.53,58.69 18.51,58.74 18.49,58.78 18.46,58.83 18.42,58.87 18.38,58.9 18.34,58.93 18.29,58.95 18.24,58.96 18.18,58.96 18.13,58.96 18.08,58.95 18.03,58.93 17.98,58.9 17.94,58.87 17.9,58.83 17.87,58.78 17.85,58.74 17.83,58.69 17.83,58.63 15.38,58.63 15.38,59.59 15.67,59.88 22.44,59.88
+5V_USB_PWR1 on IN3 (solid shape): outline of 1088 points within 14.32,31.05 19.41,57.21
+5V_USB_PWR2 on TOP (solid shape): 198.5,36.13 198.5,35.78 196.61,33.88 195.03,33.88 194.94,33.98 194.94,34.54 194.94,34.55 194.94,35.02 195.12,35.2 195.46,35.2 195.72,35.45 195.86,35.45 196.17,35.76 196.29,35.88 197.03,36.62 198.02,36.62
+5V_USB_PWR2 on BOTTOM (solid shape): 200.31,37.85 200.38,37.83 200.42,37.76 200.63,37.46 201,37.52 201.06,37.54 201.13,37.52 201.31,37.44 201.51,37.47 201.61,37.47 201.66,37.38 201.66,35.55 201.43,35.33 196.67,35.33 196.46,35.54 196.46,36.85 197.23,37.62 197.48,37.62 197.59,37.6 197.7,37.62 197.78,37.62 197.86,37.7 197.89,37.71 197.93,37.7 198.25,37.61 198.5,37.82 198.52,37.85
+5VALW on TOP (solid shape): 35.98,24.81 36.11,24.68 36.11,23.66 36.03,23.58 33.77,23.58 33.72,23.63 33.72,24.51 34.01,24.81 34.83,24.81 35.23,24.81
+5VALW on TOP (solid shape): 40.44,97.56 40.44,97.35 40.41,97.33 39.52,97.33 39.46,97.27 39.46,96.71 39.46,96.71 39.46,96.42 39.39,96.35 38.9,96.35 38.8,96.45 38.8,97.36 39.02,97.58 40.42,97.58
+5VALW on TOP (solid shape): 32.66,130.5 32.66,129.73 32.97,129.42 34.03,129.42 34.11,129.34 34.11,128.38 33.83,128.1 31.21,128.1 30.92,128.39 30.92,130.32 31.21,130.61 32.55,130.61
+5VALW on TOP (solid shape): 40.48,100.26 40.48,98.84 40.48,98.84 40.48,98.29 40.29,98.1 38.64,98.1 38.36,97.82 36.5,97.82 36.3,98.02 36.3,100.16 36.6,100.45 38.55,100.45 40.29,100.45
+5VALW on TOP (solid shape): 53.91,99.3 53.91,94.39 53.68,94.17 49.84,94.17 49.59,94.42 49.59,95.46 49.84,95.72 51.88,95.72 52.04,95.88 52.04,96.13 52.02,96.16 52.05,96.2 52.05,97.85 51.65,98.26 49.64,98.26 49.49,98.41 49.49,99.27 49.77,99.55 53.65,99.55
+5VALW on TOP (solid shape): 29.35,112.12 29.35,111.99 29.55,111.78 29.85,111.78 30.02,111.95 30.19,111.94 30.35,112.02 32.58,112.02 32.65,111.95 32.95,111.95 32.97,111.97 33.05,111.89 33.05,110.09 32.89,109.93 25.72,109.93 25.54,110.11 25.54,112.19 25.85,112.49 28.98,112.49
+5VALW on TOP (solid shape): 62.28,120.26 62.28,119.21 62.4,119.1 62.4,118.8 61.02,117.42 59.51,117.42 59.41,117.52 59.41,118.26 59.59,118.44 60.86,118.44 60.99,118.58 61,118.58 61.12,118.66 61.2,118.78 61.21,118.79 61.26,118.84 61.26,119.2 61.18,119.28 61.1,119.28 61.08,119.29 61.02,119.32 60.95,119.35 60.88,119.42 60.88,120.17 61,120.29 61.34,120.29 61.37,120.31 62.23,120.31
+5VALW on TOP (solid shape): 201.93,38.58 201.93,37.65 203.24,36.33 203.24,35.91 203.24,35.9 203.24,35.63 202.69,35.07 202.37,35.07 201.97,35.47 201.75,35.47 201.4,35.11 200.37,35.11 199.93,34.67 199.83,34.48 199.85,34.27 199.87,34.23 197.57,31.93 195.11,31.93 194.86,32.18 194.86,32.8 195,32.94 195.79,32.94 196.61,33.76 196.66,33.76 198.63,35.73 198.63,35.78 200.44,37.58 200.44,38.62 200.64,38.83 201.68,38.83
+5VALW on TOP (solid shape): 45.74,98 45.83,97.96 45.93,97.96 45.96,97.96 46.08,97.83 46.08,94.36 46.05,94.35 45.78,94.11 45.77,93.75 45.76,93.65 45.68,93.61 45.37,93.61 45.35,93.63 45.35,95.23 45.58,95.46 45.58,97.93 45.65,98 45.73,98
+5VALW on TOP (solid shape): outline of 743 points within 91.07,109.2 144.22,114.33
+5VALW on BOTTOM (solid shape): 124.93,113.91 124.93,113.16 124.86,113.1 124.55,113.1 124.54,113.11 124.54,113.47 124.47,113.54 124.47,113.69 124.36,113.8 124.31,113.87 124.24,113.91 124.2,113.95 123.53,113.95 123.47,114.02 123.47,114.18 123.53,114.24 124.59,114.24
+5VALW on BOTTOM (solid shape): 19.57,54.13 19.57,50.96 19.49,50.74 19.56,50.52 19.57,50.51 19.57,50.47 19.46,50.35 16.72,50.35 16.63,50.44 16.63,51.99 16.76,52.12 18.47,52.12 18.54,52.19 18.54,53.03 18.49,53.08 18.49,54.06 18.64,54.21 19.48,54.21
