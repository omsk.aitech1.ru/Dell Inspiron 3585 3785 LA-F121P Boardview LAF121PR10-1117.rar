# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ILMT_+VDDP: length 3.9
  TOP w0.254: v1(166.36,43.87) 166.75,43.48 PRH04.1
  BOTTOM w0.089: v3(167.64,42.45) 167.13,42.96 PRH03.2
  BOTTOM w0.254: PRH03.2 166.75,43.48 v1(166.36,43.87) 165.81,44.42 PUH01.12
IMON_APU: length 3.8
  TOP w0.203: PUZ01.10 152.77,90.3 152.13,90.94 v3(151.84,90.94) v1(151.33,90.94)
  BOTTOM w0.254: v1(151.33,90.94) 152.05,90.94 PRZ20.2 152.12,90.87 PCZ25.2
IMON_NB: length 3.9
  TOP w0.203: PUZ01.2 155.97,90.9 156.37,91.3 v1(156.57,91.3)
  BOTTOM w0.089: v1(156.57,91.3) 156.57,91.74 v3(156.64,91.8)
  BOTTOM w0.254: v1(156.57,91.3) 156.57,91.05 156.6,91.02 PRZ14.2 155.77,90.67 PCZ11.2
IMON_VGA: length 4
  TOP w0.203: PUV01.10 70.94,127.84 70.56,128.21 69.3,128.21 68.98,128.53 PCV20.1
  TOP w0.254: PCV20.1 PRV16.1
INT#_TYPEC: length 48.2
  TOP w0.089: v3(31.76,80.31) 33.3,80.31 33.64,79.97 RE506.1 33.71,79.81 UE1.102 36.72,79.81 v1(36.95,79.57)
  IN2 w0.089: v1(36.95,79.57) 36.18,80.35 36.18,81.78 36.75,82.35 36.75,84.39 35.98,85.17 35.98,101.51 37.6,103.14 37.6,108.99 37.25,109.34 37.25,117.21 36.9,117.56 v1(36.9,119.24)
  BOTTOM w0.089: UT1.15 36.64,119.5 v1(36.9,119.24)
INT-SPK-R+:
  vias: v1(24.55,5.08) v1(25.18,5.08) v1(28.42,9.14) v1(28.86,8.69) v3(24.86,4.67)
INT-SPK-R-:
  vias: v1(24.55,3.93) v1(25.18,3.93) v1(28.67,7.99) v1(28.67,7.36) v3(24.9,3.23)
INVTPWM: length 142.2
  TOP w0.089: RP3.1 210.8,48 RC5.1 210.73,47.93 v1(210.73,47.37) ; v1(130.89,89.91) 130.88,89.9 130.88,89.51 130.97,89.42 UC2.4 ; v1(131.89,105.53) v3(131.29,105.53)
  IN1 w0.089: v1(131.89,105.53) 131.94,105.59 133,105.59 134.93,107.52 139.56,107.52 140.65,106.42 143.8,106.42 145.05,105.17 163.34,105.17 168.18,100.33 168.18,98.13 170.47,95.85 170.47,87.71 171.98,86.2 171.98,76.49 172.86,75.6 175.18,73.29 179.12,73.29 185.92,66.48 193.29,66.48 193.68,66.09 193.68,65.14 194.5,64.32 194.5,58.63 198.8,54.33 198.8,53.81 199.54,53.07 201.49,53.07 204.59,49.97 207.42,49.97 209.16,48.23 210.26,48.23 210.73,47.76 v1(210.73,47.37)
  IN2 w0.089: v1(131.89,105.53) 131.65,105.53 131.09,104.98 131.09,90.12 130.89,89.91 v1(130.89,89.91)
  BOTTOM w0.089: JEDP1.27 211.79,47.45 211.43,47.81 211.17,47.81 v1(210.73,47.37)
INVTPWM_R: length 14.7
  TOP w0.089: UC2.2 130.16,88.77 v1(130.15,88.75)
  TOP w0.099: v1(126.8,79.67) 126.99,79.67 v3(127.3,79.36)
  IN2 w0.089: v1(130.15,88.75) 129.58,88.19 129.58,84.9 129.31,84.63 129.31,83.93 129.19,83.81 129.19,82.84 127.22,80.87 127.22,80.2 126.8,79.77 v1(126.8,79.67)
  BOTTOM w0.1: v1(126.8,79.67) UC1.L14
ISEN1_APU: length 12
  TOP w0.203: PUZ01.13 151.09,88.33 v1(150.94,88.49) 150.74,88.68 PCZ28.1
  IN3 w0.254: v1(150,81.63) 149.94,81.69 149.94,84.58 150.2,84.83 151.04,84.83 151.67,85.47 151.67,87.75 v1(150.94,88.49)
  BOTTOM w0.089: v3(149.87,82.41) 150,82.27 v1(150,81.63)
  BOTTOM w0.254: v1(150,81.63) 150.25,81.38 PRZ42.2
ISEN1_VGA: length 13.8
  TOP w0.089: v1(69.79,118.66) 69.79,118.49 v3(69.52,118.22)
  TOP w0.203: PCV23.1 71.14,125.79 71.46,126.11 72.64,126.11 73.18,126.64 PUV01.13
  TOP w0.254: v1(69.79,118.66) 69.79,118.91 70.21,119.34 PRV22.2 ; PCV23.1 70.66,125.8 70.27,126.18 70.27,126.39 v1(70.26,126.4)
  BOTTOM w0.254: v1(70.26,126.4) 70.26,126.4 69.91,126.04 69.91,123.23 69.46,122.79 69.46,118.98 v1(69.79,118.66)
ISEN2_APU: length 13.9
  TOP w0.203: PCZ27.1 150.33,89.59 150.9,89.59 v1(150.91,89.6) 151.09,89.42 151.09,89.41 151.37,89.13 151.37,88.94 151.57,88.73 PUZ01.12
  TOP w0.254: PRZ22.2 148.17,81.32 148.53,81.67 148.53,81.9 v1(148.49,81.94)
  IN3 w0.254: v1(148.49,81.94) 148.62,82.07 148.62,84.09 149.81,85.28 150.66,85.28 151.23,85.85 151.23,87.37 150.47,88.13 150.47,89.16 v1(150.91,89.6)
  BOTTOM w0.089: v1(148.49,81.94) 148.49,82.16 v3(148.26,82.39)
ISEN2_VGA: length 14.4
  TOP w0.089: v3(66.87,118.68) 66.87,119.68 67.98,120.79 PRV03.2
  TOP w0.203: PCV22.1 69.71,126.63 v1(69.72,126.65) 69.92,126.84 70.79,126.84 71.22,126.41 72.52,126.41 72.78,126.67 PUV01.12
  TOP w0.254: PRV03.2 68.33,120.99 68.95,120.99 v1(69.01,121.05)
  BOTTOM w0.254: v1(69.01,121.05) 69.01,122.83 69.56,123.38 69.56,126.24 69.63,126.31 69.63,126.55 v1(69.72,126.65)
ISOLATEB: length 2.8
  TOP w0.089: UL1.20 23.67,85.44 23.88,85.65 23.88,86.43 RL14.1 RL12.2
JACK_PLUG_DET: length 1.3
  TOP w0.089: RA30.1 9.46,19.24 v3(8.78,18.56)
JACK_SENSE#: length 1.5
  TOP w0.089: v3(11.3,18.36) 12.11,19.17 RA57.1
JACK_SENSE_1#: length 18
  TOP w0.203: v1(28.66,20.19) 29.41,19.44 RA41.2
  TOP w0.254: v1(13.16,19.46) 13.45,19.17 RA57.2
  IN3 w0.254: v1(28.66,20.19) 28.22,19.74 13.44,19.74 v1(13.16,19.46)
JHDD_P10: length 2
  BOTTOM w0.089: RS61.2 186.14,36.74 186.14,36.58 186.7,36.02 JHDD1.8
JTAG_TCK: length 9
  TOP w0.102: RV369.1 126.56,118.63 126.56,117.87 126.9,117.53 127.65,117.53 v1(127.85,117.72)
  BOTTOM w0.102: v1(127.85,117.72) 127.97,117.84 127.97,120.74 127.75,120.95 127.75,122.67 128.14,123.06 UV1.L3
JTAG_TDI_GPU: length 8.4
  BOTTOM w0.102: RPV34.7 128.93,116.98 129.06,117.11 v1(129.06,118.13) 129.06,118.2 128.45,118.81 128.45,121.07 128.21,121.31 128.21,122.23 128.44,122.47 128.44,122.77 128.43,122.79 128.43,123.21 128.44,123.22 128.44,123.89 UV1.L5
JTAG_TDO_GPU: length 8.5
  BOTTOM w0.102: RPV34.8 129.43,116.8 129.8,117.17 v1(129.94,117.17) 129.94,117.71 129.57,118.08 129.57,118.41 128.66,119.33 128.66,121.6 128.44,121.82 128.44,122.18 128.65,122.39 128.65,122.86 128.63,122.87 128.63,123.12 128.71,123.2 128.71,123.57 UV1.K4
JTAG_TMS_GPU: length 7.4
  TOP w0.089: v4(128.72,116.31) 128.44,116.6 v1(128.44,117.17)
  BOTTOM w0.102: RPV34.6 v1(128.44,117.17) 128.44,117.49 128.25,117.68 128.25,120.75 128.14,120.85 127.98,121.01 127.98,122.44 UV1.L1
JTAG_TRSTB: length 10.2
  TOP w0.089: v1(127.73,117.1) v4(127.01,116.38)
  BOTTOM w0.102: RPV34.5 127.94,116.9 v1(127.73,117.1) 127.46,117.37 127.46,118.01 127.7,118.24 127.7,119.61 127.71,119.63 127.71,120.7 127.52,120.89 127.52,122.73 127.71,122.92 127.71,124.25 128.14,124.67 UV1.L6
KB_BL_PWM: length 61.2
  TOP w0.089: v1(50.26,55.3) v4(47.79,57.77) 46.77,58.8 Q3.1
  IN2 w0.089: 56.17,44.62 51.36,49.43 51.36,54.21 v1(50.26,55.3) ; 57.04,42.35 57.04,41.67 61.44,37.27 64.26,37.27 65.66,35.87 78.84,35.87 79.34,35.37 81.36,35.37 81.85,34.88 90.81,34.88 v1(90.81,34.88)
  IN2 w0.102: 57.04,42.35 57.04,43.75 56.17,44.62
  BOTTOM w0.089: JKBBL1.4 92.05,34.98 91.96,35.07 91.01,35.07 90.82,34.88 90.81,34.88 v1(90.81,34.88)
KB_DET: length 8.6
  TOP w0.089: v4(95.47,38.92) 94.59,38.92 93.8,38.13 v1(93.77,38.13) 93.76,38.12 93.75,38.12 93.43,37.81 QE1.2 93.11,38.47 92.87,38.71 92.48,38.71 RE3.1
  BOTTOM w0.089: v1(93.77,38.13) 93.77,37.44 94.05,37.16 JKBBL1.2
KB_DET#: length 52.8
  TOP w0.089: v1(95.9,38.13) 95.9,39.68 95,40.57 v3(94.27,40.57) 93.98,40.57 93.76,40.36 QE1.1 93.15,39.05 RE2.1
  IN2 w0.089: v1(123.76,49.42) 123.64,49.31 123.64,44.93 120.61,41.9 118.5,41.9 117.18,40.57 117.18,38.68 115.23,36.73 113.91,36.1 112.37,36.1 111.37,36.48 110.7,36.96 108.35,39.31 106.26,39.31 105.66,38.72 96.5,38.72 95.92,38.13 v1(95.9,38.13)
  BOTTOM w0.099: 126.04,53.02 126.04,53.82 UC1.BD15
  BOTTOM w0.102: 126.04,53.02 126.11,52.95 126.11,50.84 125.45,50.18 125.45,49.1 125.26,48.9 124.28,48.9 v1(123.76,49.42)
KB_LED_PWM: length 7.6
  TOP w0.102: v3(49.36,62.31) Q3.2
  TOP w0.203: v1(47.51,66.52) 47.41,66.52 46.95,66.97 UE1.25
  TOP w0.254: v1(47.89,63.42) 47.74,63.27 Q3.2
  IN2 w0.254: v1(47.51,66.52) 47.51,66.2 47.71,66 47.71,63.6 v1(47.89,63.42)
KB_RST#: length 158.9
  TOP w0.089: v1(43.97,70.94) 43.91,71 43.03,71 41.76,72.26 38.43,72.26 37.48,71.32 37.48,70.57 37.5,70.56 37.5,68.9 37.75,68.65 UE1.2
  TOP w0.099: v1(130.91,52.13) 130.91,51.75 130.65,51.49 v3(130.65,50.99)
  IN2 w0.089: v1(43.97,70.94) 43.97,70.67 43.48,70.19 43.48,68.03 44.14,67.38 44.14,66.03 42.97,64.85 42.97,63.53 41.56,62.13 41.56,61.12 41.93,60.75 42.68,60.75 43.55,59.88 43.55,58.8 45.27,57.09 46.12,57.09 50.25,52.96 50.25,48.62 55.9,42.96 55.9,40.99 60.73,36.16 63.4,36.16 64.85,34.71 78.31,34.71 78.77,34.26 80.1,34.26 81.02,33.34 96.73,33.34 97.72,34.33 100.65,34.33 101.02,33.96 103.54,33.96 105.1,32.41 108.2,32.41 108.76,32.97 115.02,32.97 115.49,33.44 116.4,33.44 117.07,34.11 120.83,34.11 121.32,34.6 124.99,34.6 128.66,38.27 129.21,38.27 132.86,41.92 133.22,42.78 134.9,44.47 134.9,46.98 133.02,48.86 133.02,50.79 132.19,51.62 132.19,52.04 131.95,52.28 131.06,52.28 v1(130.91,52.13)
  BOTTOM w0.089: v1(130.91,52.13) 130.63,51.86 130.63,48.91 131.48,48.06 131.48,46.87 RC1707.2
  BOTTOM w0.1: UC1.BB11 130.23,54.43 130.52,54.14 130.52,53.89 130.43,53.79 130.43,52.61 v1(130.91,52.13)
KSI0: length 76
  TOP w0.089: v3(54.3,77.66) 53.75,78.21 UE1.55 50.09,78.21 49.42,78.88 47.16,78.88 46.4,78.12 v1(46.4,77.23)
  BOTTOM w0.089: v1(46.4,77.23) 46.38,77.23 45.6,76.45 44.51,76.45 41.86,73.79 41.86,72.79 41.54,72.48 41.54,68.86 40.78,68.1 40.78,61.77 41.21,61.34 41.21,57.09 42,56.3 42,53.19 44.32,50.88 44.32,44.7 44.32,44.7 44.32,44.22 45.28,43.26 45.28,39.65 46.74,38.19 54.53,38.19 56.24,36.48 65.02,36.48 66.15,35.35 JKB1.22
KSI1: length 77.4
  TOP w0.089: v1(46.03,78.2) 46.25,78.42 46.27,78.42 46.91,79.06 49.78,79.06 50.23,78.61 UE1.56 52.66,78.61 52.72,78.55 54.9,78.55 v3(55.56,77.9)
  BOTTOM w0.089: JKB1.24 64.55,35.17 63.61,36.11 56.09,36.11 54.38,37.82 46.59,37.82 44.92,39.49 44.92,43.11 43.95,44.07 43.95,50.73 41.64,53.04 41.64,56.14 40.84,56.94 40.84,61.19 39.07,62.96 39.07,66.9 41.18,69.01 41.18,72.63 41.49,72.94 41.49,73.94 44.36,76.82 45.1,76.82 45.95,77.66 45.95,78.12 v1(46.03,78.2)
KSI2: length 73.9
  TOP w0.089: v1(45.26,77.79) 45.31,77.79 45.65,78.13 45.65,78.35 45.9,78.6 46.19,78.6 46.83,79.24 49.86,79.24 50.09,79.01 UE1.57 52.75,79.01 v3(52.9,78.85)
  BOTTOM w0.089: JKB1.26 62.95,34.62 61.82,35.75 55.94,35.75 54.23,37.45 46.44,37.45 44.55,39.34 44.55,42.96 43.59,43.92 43.59,50.57 41.27,52.89 41.27,55.99 40.48,56.79 40.48,61.04 38.7,62.81 38.7,67.05 40.18,68.53 40.18,69.85 40.36,70.03 40.36,70.24 39.83,70.77 39.83,72.37 41.12,73.67 41.12,74.1 44.21,77.18 44.95,77.18 45.26,77.49 v1(45.26,77.79)
KSI3: length 77.2
  TOP w0.089: v3(54.17,78.94) 53.71,79.41 UE1.58 50.14,79.41 50.12,79.43 46.69,79.43 46.24,78.98 v1(46.03,78.98)
  BOTTOM w0.089: v1(46.03,78.98) 46.03,78.73 46.44,78.33 46.44,77.89 45.18,76.63 44.44,76.63 41.67,73.87 41.67,72.87 41.36,72.56 41.36,68.94 39.25,66.82 39.25,63.04 41.02,61.26 41.02,57.01 41.82,56.22 41.82,53.12 44.14,50.8 44.14,44.15 45.1,43.19 45.1,39.57 46.67,38 54.46,38 56.16,36.3 64.32,36.3 65.35,35.26 JKB1.23
KSI4: length 76.4
  TOP w0.089: v1(45.16,78.41) 45.66,78.91 45.66,79.19 45.82,79.35 46.36,79.35 46.61,79.61 50.13,79.61 50.33,79.81 UE1.59 55.29,79.81 v4(55.55,79.55)
  BOTTOM w0.089: JKB1.27 62.15,34.65 61.24,35.57 55.86,35.57 54.15,37.27 46.36,37.27 44.37,39.27 44.37,42.88 43.41,43.84 43.41,50.5 41.09,52.81 41.09,55.92 40.29,56.71 40.29,60.96 38.52,62.74 38.52,67.13 39.99,68.6 39.99,69.92 40.04,69.97 40.04,70.3 39.64,70.69 39.64,72.45 40.94,73.74 40.94,74.17 44.46,77.69 44.46,78.1 44.78,78.41 v1(45.16,78.41)
KSI5: length 76.1
  TOP w0.089: v1(46.03,79.72) 46.03,79.74 46.4,80.1 50.29,80.1 50.39,80.21 UE1.60 53.54,80.21 v4(53.87,80.54)
  BOTTOM w0.089: v1(46.03,79.72) 45.65,79.34 45.65,77.62 45.03,77 44.29,77 41.31,74.02 41.31,73.02 41,72.71 41,69.09 38.88,66.98 38.88,62.89 40.66,61.11 40.66,56.86 41.45,56.07 41.45,52.97 43.77,50.65 43.77,44 44.73,43.03 44.73,39.42 46.51,37.64 54.31,37.64 56.01,35.93 62.78,35.93 63.75,34.96 JKB1.25
KSI6: length 76.3
  TOP w0.089: v1(45.13,79.68) 45.73,80.29 50.09,80.29 50.41,80.61 UE1.61 52.64,80.61 52.98,80.95 54.03,80.95 54.31,81.22 v4(55.48,81.22)
  BOTTOM w0.089: JKB1.28 61.35,34.56 60.53,35.38 55.78,35.38 54.08,37.09 46.29,37.09 44.18,39.19 44.18,42.81 43.22,43.77 43.22,50.42 40.91,52.74 40.91,55.84 40.11,56.63 40.11,60.88 39.09,61.91 38.33,62.66 38.33,67.2 39.24,68.11 39.24,70.34 39.46,70.56 39.46,72.52 40.76,73.82 40.76,74.25 44.28,77.77 44.28,78.84 v1(45.13,79.68)
KSI7: length 76.5
  TOP w0.089: v4(55.05,82.85) 55.05,82.55 53.81,81.3 52.89,81.3 52.6,81.01 UE1.62 50.46,81.01 49.93,80.47 45.38,80.47 v1(45.19,80.27)
  BOTTOM w0.089: v1(45.19,80.27) 44.1,79.18 44.1,77.84 40.58,74.32 40.58,73.9 39.28,72.6 39.28,70.64 39.06,70.42 39.06,68.19 38.15,67.28 38.15,62.58 39.93,60.8 39.93,56.56 40.72,55.76 40.72,52.66 43.04,50.35 43.04,43.69 44,42.73 44,39.11 46.21,36.91 54,36.91 55.71,35.2 59.83,35.2 60.55,34.48 JKB1.29
KSO0: length 73.8
  TOP w0.089: v1(46.25,71.47) 46.28,71.5 46.35,71.5 46.44,71.59 50.1,71.59 50.32,71.81 UE1.39 52.49,71.81 52.84,72.16 54.88,72.16 55.42,71.62 v4(55.42,70.99)
  BOTTOM w0.089: JKB1.13 73.35,35.91 71.14,38.13 56.92,38.13 54.5,40.55 47.84,40.55 46.93,41.46 46.93,44.74 45.97,45.71 45.97,53.8 45.82,53.95 45.82,61.05 44.75,62.11 44.27,62.11 43.58,62.81 43.58,64.55 44.12,65.09 44.12,68.05 43.98,68.18 43.98,69.29 46.16,71.47 v1(46.25,71.47)
KSO1: length 71.9
  TOP w0.089: v1(45.74,72.9) 45.8,72.96 49.61,72.96 50.37,72.21 UE1.40 52.51,72.21 52.95,72.65 v3(53.65,72.65)
  BOTTOM w0.089: v1(45.74,72.9) 45.94,72.7 45.94,71.95 43.62,69.63 43.62,68.03 43.75,67.9 43.75,65.24 43.09,64.58 43.09,62.77 44.27,61.6 44.27,61 44.55,60.73 44.55,57.86 45.45,56.96 45.45,53.79 45.6,53.65 45.6,44.76 46.56,43.79 46.56,41.31 47.69,40.18 54.35,40.18 56.77,37.76 69.52,37.76 71.75,35.53 JKB1.15
KSO2: length 71.5
  TOP w0.089: UE1.41 50.23,72.61 49.69,73.15 46.63,73.15 46.29,73.49 v1(45.71,73.49) ; v1(45.41,57.53) v3(45.41,58.14)
  BOTTOM w0.089: JKB1.14 72.55,35.56 70.16,37.94 56.85,37.94 54.42,40.37 47.76,40.37 46.74,41.38 46.74,44.67 45.78,45.63 45.78,53.72 45.63,53.87 45.63,57.3 v1(45.41,57.53) 44.92,58.02 44.92,60.61 44.45,61.08 44.45,61.67 43.28,62.85 43.28,64.51 43.93,65.16 43.93,67.97 43.8,68.11 43.8,69.55 46.13,71.88 46.13,73.27 45.91,73.49 v1(45.71,73.49)
KSO3: length 70.6
  TOP w0.089: UE1.42 51.37,73.01 50.08,73.01 49.76,73.33 47.08,73.33 46.42,74 45.8,74 v1(45.73,74.07) ; v1(45.04,55.9) v3(44.45,55.9)
  BOTTOM w0.089: JKB1.16 70.95,35.51 68.88,37.58 56.7,37.58 54.27,40 47.6,40 46.38,41.22 46.38,43.72 45.42,44.68 45.42,45.15 45.42,53.57 45.04,53.95 v1(45.04,55.9) 45.04,56.9 44.36,57.58 44.36,60.65 44.09,60.93 44.09,61.52 42.91,62.7 42.91,67.55 43.44,68.07 43.44,69.88 45.18,71.62 45.18,73.63 45.62,74.07 v1(45.73,74.07)
KSO4: length 70.5
  TOP w0.089: v1(43.79,73.55) 44.55,73.55 45.44,74.45 46.35,74.45 47.29,73.51 50.14,73.51 50.24,73.41 UE1.43 ; v1(41.84,57.72) v3(41.33,57.72)
  BOTTOM w0.089: v1(43.79,73.55) 42.94,73.55 42.22,72.84 42.22,72.64 41.91,72.33 41.91,67.71 42.18,67.44 42.18,65.34 41.57,64.73 41.57,57.99 v1(41.84,57.72) 41.84,56.97 42.37,56.45 42.37,53.35 44.69,51.03 44.69,45.46 44.69,44.38 45.65,43.41 45.65,40.92 47.95,38.62 54.62,38.62 56.39,36.85 66.1,36.85 67.75,35.2 JKB1.20
KSO5: length 75.2
  TOP w0.089: v3(55.48,72.75) 55.24,73 52.97,73 52.16,73.81 UE1.44 50.25,73.81 50.15,73.7 47.35,73.7 46.43,74.63 45.36,74.63 44.84,74.11 43.9,74.11 v1(43.88,74.13)
  BOTTOM w0.089: JKB1.21 66.95,35.51 65.79,36.66 56.32,36.66 54.61,38.37 46.82,38.37 45.46,39.72 45.46,43.34 44.5,44.3 44.5,50.95 42.19,53.27 42.19,56.37 41.39,57.17 41.39,64.5 40.96,64.93 40.96,68.02 41.73,68.78 41.73,72.4 42.04,72.72 42.04,72.92 43.26,74.13 v1(43.88,74.13)
KSO6: length 72.2
  TOP w0.089: v3(52.95,73.77) 52.52,74.21 UE1.45 50.22,74.21 49.9,73.89 47.43,73.89 46.51,74.81 45.02,74.81 v1(44.69,74.48)
  BOTTOM w0.089: v1(44.69,74.48) 44.59,74.38 44.59,72.92 43.6,71.93 43.6,71.46 42.28,70.14 42.28,67.86 42.55,67.59 42.55,62.55 43.72,61.37 43.72,60.77 44,60.5 44,54.47 45.05,53.42 45.05,45.31 45.05,44.53 46.01,43.57 46.01,41.07 47.45,39.64 54.12,39.64 56.54,37.21 67.66,37.21 69.35,35.52 JKB1.18
KSO7: length 74.4
  TOP w0.089: v1(43.85,74.72) 44.12,74.99 46.58,74.99 47.5,74.07 49.33,74.07 49.87,74.61 UE1.46 52.65,74.61 52.7,74.56 53.5,74.56 v3(54.24,73.82)
  BOTTOM w0.089: v1(43.85,74.72) 44.02,74.72 44.25,74.48 44.25,72.85 43.39,71.99 43.39,71.52 42.09,70.22 42.09,67.78 42.36,67.51 42.36,62.47 43.54,61.29 43.54,60.7 43.82,60.42 43.82,54.4 44.87,53.34 44.87,45.38 44.87,44.45 45.83,43.49 45.83,40.99 47.37,39.45 54.04,39.45 56.47,37.03 67.08,37.03 68.55,35.56 JKB1.19
KSO8: length 78.1
  TOP w0.089: v3(55.51,74.05) 54.82,74.74 52.81,74.74 52.54,75.01 UE1.47 50.01,75.01 49.26,74.25 47.61,74.25 46.68,75.18 44.02,75.18 v1(43.9,75.3)
  BOTTOM w0.089: v1(43.9,75.3) 44.08,75.12 44.58,75.12 45.06,74.64 45.06,74.33 44.97,74.24 44.97,73.05 43.8,71.87 43.8,71.41 42.46,70.07 42.46,67.93 42.73,67.66 42.73,62.62 43.91,61.44 43.91,60.85 44.18,60.57 44.18,54.55 45.23,53.49 45.23,45.23 45.23,44.6 46.2,43.64 46.2,41.15 47.52,39.82 54.2,39.82 56.62,37.39 68.43,37.39 70.15,35.67 JKB1.17
KSO9: length 74.8
  TOP w0.089: v3(52.93,75.04) 52.56,75.41 UE1.48 49.58,75.41 48.92,74.76 48.11,74.76 v1(48.01,74.66)
  BOTTOM w0.089: JKB1.7 78.15,37.2 76.27,39.08 71.91,39.08 71.76,39.22 57.38,39.22 54.24,42.36 54.24,45.16 53.37,46.03 48.28,46.03 47.06,47.25 47.06,61.56 46.5,62.13 46.5,64.84 45.22,66.12 45.22,66.95 46.58,68.32 46.58,69.9 48.03,71.36 48.03,74.64 v1(48.01,74.66)
KSO10: length 77.7
  TOP w0.089: v3(54.21,75.1) 53.51,75.81 UE1.49 48.62,75.81 v1(48.24,75.42)
  BOTTOM w0.089: v1(48.24,75.42) 48.31,75.42 48.58,75.16 48.58,71.38 46.95,69.75 46.95,68.2 47.88,67.27 47.88,65.81 46.88,64.81 46.88,62.29 47.43,61.74 47.43,47.4 48.43,46.4 53.52,46.4 54.61,45.31 54.61,42.51 57.53,39.59 71.92,39.59 72.06,39.45 77.56,39.45 79.75,37.26 JKB1.5
KSO11: length 78.8
  TOP w0.089: v1(48.08,75.99) 48.3,76.21 UE1.50 52.56,76.21 52.76,76 54.81,76 v3(55.48,75.33)
  BOTTOM w0.089: v1(48.08,75.99) 47.87,75.77 47.87,75.27 48.09,75.05 48.23,75.05 48.4,74.88 48.4,71.46 46.77,69.83 46.77,68.13 46.58,67.94 46.58,65.78 46.7,65.67 46.7,62.21 47.25,61.66 47.25,47.32 48.36,46.21 53.45,46.21 54.43,45.23 54.43,42.43 57.45,39.41 71.84,39.41 71.98,39.26 77.14,39.26 78.95,37.45 JKB1.6
KSO12: length 76
  TOP w0.089: v3(53.03,76.31) 52.73,76.61 UE1.51 50.47,76.61 50.25,76.39 47.38,76.39 47.19,76.2 47.1,76.2 v1(46.76,75.86)
  BOTTOM w0.089: v1(46.76,75.86) 46.77,75.85 46.77,74.22 47.08,73.9 47.08,71.7 45.75,70.36 45.31,70.36 44.17,69.22 44.17,68.26 44.3,68.12 44.3,65.01 43.76,64.47 43.76,62.88 44.35,62.3 44.83,62.3 46,61.12 46,54.02 46.15,53.87 46.15,45.78 47.11,44.82 47.11,41.53 47.91,40.73 54.58,40.73 57,38.31 71.38,38.31 71.83,37.85 72.47,37.85 74.15,36.18 JKB1.12
KSO13: length 77.6
  TOP w0.089: v1(47.72,76.78) 47.74,76.75 50.17,76.75 50.43,77.01 UE1.52 53.68,77.01 v3(54.31,76.37)
  BOTTOM w0.089: JKB1.9 76.55,37.21 75.04,38.71 71.76,38.71 71.61,38.86 57.23,38.86 53.88,42.21 53.88,45.01 53.22,45.66 48.13,45.66 46.7,47.1 46.7,61.41 46.13,61.98 46.13,62.4 45.18,63.34 45.18,64.24 44.85,64.58 44.85,67.1 46.22,68.47 46.22,70.06 47.67,71.51 47.67,74.09 47.32,74.44 47.32,75.15 47.5,75.33 47.5,76.25 47.72,76.47 v1(47.72,76.78)
KSO14: length 79.9
  TOP w0.089: v1(47.9,77.33) 47.97,77.41 UE1.53 52.61,77.41 52.73,77.28 54.9,77.28 v3(55.57,76.61)
  BOTTOM w0.089: v1(47.9,77.33) 48.09,77.14 48.09,76.58 47.68,76.17 47.68,75.26 47.5,75.07 47.5,74.52 47.85,74.17 47.85,71.43 46.4,69.98 46.4,68.39 45.03,67.03 45.03,66.04 46.31,64.76 46.31,62.05 46.88,61.49 46.88,47.17 48.21,45.85 53.3,45.85 54.06,45.08 54.06,42.28 57.3,39.04 71.69,39.04 71.83,38.9 75.56,38.9 77.35,37.11 JKB1.8
KSO15: length 77.1
  TOP w0.089: v3(53.02,77.58) 52.79,77.81 UE1.54 50.11,77.81 49.93,77.99 47.93,77.99 v1(47.86,77.92)
  BOTTOM w0.089: v1(47.86,77.92) 47.81,77.86 47.35,77.86 46.97,77.48 46.97,77.11 47.32,76.77 47.32,75.41 47.14,75.22 47.14,74.37 47.49,74.02 47.49,71.58 46.03,70.13 46.03,68.55 44.67,67.18 44.67,64.5 45,64.17 45,63.27 45.95,62.32 45.95,61.9 46.51,61.34 46.51,47.02 48.05,45.48 53.14,45.48 53.7,44.93 53.7,42.13 57.15,38.67 71.54,38.67 71.68,38.53 74.08,38.53 75.75,36.87 JKB1.10
KSO16: length 84.7
  TOP w0.089: v1(44.7,81.83) 43.96,81.83 43.35,82.44 UE1.81 43.35,84.65 42.83,85.17 42.83,86.6 42.17,87.26 v4(42.17,87.97)
  BOTTOM w0.089: v1(44.7,81.83) 44.7,81.83 44.79,81.83 47.16,79.46 47.16,77.93 46.79,77.56 46.79,77.04 47.14,76.69 47.14,75.48 46.95,75.3 46.95,74.29 47.3,73.94 47.3,71.66 45.06,69.42 45.06,67.83 44.48,67.25 44.48,64.94 43.94,64.4 43.94,62.96 44.42,62.48 44.9,62.48 46.18,61.2 46.18,54.1 46.33,53.95 46.33,45.86 47.3,44.9 47.3,41.61 47.99,40.92 54.65,40.92 57.07,38.49 71.45,38.49 71.89,38.06 73.36,38.06 74.95,36.46 JKB1.11
LAN_MDIN0: length 16
  TOP w0.089: v1(22.55,78.83) 22.39,78.99 22.39,80.35 22.47,80.43 UL1.2
  IN1 w0.089: v1(28.16,72) 28.06,72.11 28.06,75.35 25.8,77.61 23.2,77.61 22.52,78.28 22.52,78.8 v1(22.55,78.83)
  BOTTOM w0.089: v1(28.16,72) 28.02,72.15 28.02,72.44 27.79,72.68 27.07,72.68 26.97,72.78 26.97,73.04 26.88,73.13 TL1.9
LAN_MDIN1: length 25.9
  TOP w0.089: UL1.5 23.67,80.36 23.58,80.27 23.58,79.46 v1(23.75,79.29)
  IN1 w0.089: v1(23.75,79.29) 23.58,79.11 23.58,78.71 23.67,78.62 27.07,78.62 28.86,76.83 28.86,67.43 28.25,66.82 v1(28.25,63.48)
  BOTTOM w0.089: TL1.15 26.88,65.51 26.97,65.42 26.97,65.2 27.06,65.11 27.34,65.11 27.65,64.8 27.65,64.26 28.1,63.81 28.1,63.63 v1(28.25,63.48)
LAN_MDIN2: length 13.1
  TOP w0.089: UL1.7 24.47,79.98 24.66,79.79 25.68,79.79 28.15,77.32 v2(28.15,76.27) 28.15,72.68 27.87,72.4 27.41,72.4 27.23,72.22 26.98,72.22 26.89,72.13 26.89,71.95 26.81,71.86 TL2.15
LAN_MDIN3: length 22.2
  TOP w0.089: UL1.10 25.9,81.93 25.98,81.85 26.42,81.85 26.66,81.62 26.66,80.19 29.24,77.61 v2(29.24,69.64) 29.24,65.9 27.63,64.3 26.87,64.3 26.81,64.24 TL2.9
LAN_MDIP0: length 15.9
  TOP w0.089: v1(21.96,78.81) 22.14,78.99 22.14,80.37 22.07,80.44 UL1.1
  IN1 w0.089: v1(21.96,78.81) 22.31,78.46 22.31,78.2 23.11,77.4 25.71,77.4 27.85,75.26 27.85,72.28 v1(27.58,72)
  BOTTOM w0.089: TL1.10 26.88,71.86 26.97,71.95 26.97,72.31 27.09,72.43 27.68,72.43 27.77,72.34 27.77,72.19 v1(27.58,72)
LAN_MDIP1: length 25.8
  TOP w0.089: v1(23.15,79.31) 23.33,79.48 23.33,80.29 23.27,80.36 UL1.4
  IN1 w0.089: v1(23.15,79.31) 23.37,79.09 23.37,78.63 23.58,78.42 26.98,78.42 28.66,76.75 28.66,67.52 28.04,66.91 28.04,63.86 v1(27.67,63.48)
  BOTTOM w0.089: TL1.16 26.88,64.24 26.97,64.33 26.97,64.77 27.06,64.86 27.24,64.86 27.4,64.69 27.4,64.16 27.85,63.71 27.85,63.66 v1(27.67,63.48)
LAN_MDIP2: length 13
  TOP w0.089: TL2.16 26.79,73.13 26.88,73.04 26.88,72.56 26.97,72.47 27.13,72.47 27.31,72.66 27.76,72.66 27.9,72.79 v2(27.9,74.13) 27.9,77.21 25.57,79.54 24.55,79.54 24.21,79.88 24.21,80.25 24.07,80.4 UL1.6
LAN_MDIP3: length 22.2
  TOP w0.089: UL1.9 25.91,81.53 25.99,81.6 26.32,81.6 26.41,81.51 26.41,80.08 28.98,77.51 v2(28.98,68.3) 28.98,66 27.53,64.55 27.14,64.55 27.05,64.64 27.05,65.42 26.96,65.51 TL2.10
LCD_TEST: length 290.5
  TOP w0.089: v1(57.17,26.78) 57.52,26.78 v3(57.74,26.56) ; UE1.72 46.95,82.64 47.5,82.09 47.5,81.62 47.09,81.2 42.76,81.2 41.5,79.95 39.22,79.95 v1(39.17,79.9)
  IN1 w0.089: v1(57.17,26.78) 60.21,23.74 100.78,23.74 101.73,24.69 133.82,24.69 139.22,30.1 142.79,30.1 146.55,26.33 174.47,26.33 177.99,29.85 181.67,29.85 182,30.19 198.63,30.19 199.54,31.09 202.11,31.09 202.64,30.56 202.64,30.26 202.79,30.1 213.32,30.1 214.91,28.51 217.04,28.51 220.32,31.79 220.32,34.66 219.12,35.86 219.12,39.32 221.15,41.36 221.15,48.77 219.69,50.23 216,50.23 212.57,53.67 212.57,56.64 211.24,57.97 210.35,57.97 209.81,58.5 v1(209.81,58.67)
  IN2 w0.089: v1(39.17,79.9) 39.17,79.87 37.35,78.05 37.35,77.54 37.85,77.04 37.85,73.73 37.32,73.2 36.92,73.2 35.72,71.99 35.72,69.94 34.53,68.75 34.53,62.14 35.89,60.78 35.89,57.67 39.63,53.92 39.63,52.57 41.14,51.06 41.14,50.21 41.69,49.66 42.21,49.66 42.97,48.91 42.97,38.12 47.81,33.27 51.72,33.27 52.21,32.78 54.34,32.78 56.85,30.27 56.85,27.11 v1(57.17,26.78)
  BOTTOM w0.089: v1(209.81,58.67) 209.81,58.18 209.76,58.13 RX15.1
LCD_TST_C: length 3.1
  BOTTOM w0.089: JEDP1.10 212.06,55.95 211.68,56.33 211.68,57.46 211.49,57.65 RX15.2
LG1_APU: length 10.1
  IN3 w1.016: 153.96,82.1 153.96,81.08 153.95,81.07 153.95,77.26 156.03,75.18 156.03,73.48
  BOTTOM w0.089: v3(153.95,84.22) 154.05,84.12 v1(154.05,83.65)
  vias: v1(154.05,83.04) v1(157.56,72.66) v1(157.56,72.06) v1(157.56,69.15) v1(157.59,68.44)
LG1_CHG: length 12
  IN3 w0.508: v1(202.03,43.98) 199.93,43.98 199.44,43.49 195.5,43.49 193.4,45.59 v1(193.4,47.88)
LG1_VGA: length 5.6
  IN3 w0.635: 78.6,128.94 80.81,128.94 81.58,128.17 83.52,128.17
  BOTTOM w0.089: 90.03,128.32 v3(90.39,128.32)
  vias: v1(77.89,128.88) v1(84.48,128.52) v1(84.48,127.94) v1(89.66,128.37) v1(89.66,127.78)
LG2_APU: length 14.3
  IN3 w1.016: 155.33,81.87 155.33,80.81 160.71,75.42 160.71,70.49
  BOTTOM w0.089: v1(155.23,83.5) 155.23,84.15 v3(155.28,84.2)
  vias: v1(155.24,82.9) v1(160.1,69.63) v1(160.1,69.02) v1(160.1,65.16) v1(160.1,64.55)
LG2_CHG: length 6.9
  TOP w0.089: v3(197.72,43.16) 198.3,42.59 v1(198.79,42.59)
  IN3 w0.508: v1(198.79,42.59) 198.91,42.71 v1(202.55,42.71)
  BOTTOM w0.203: PUB01.7 203.57,43.47 203.25,43.14 203.25,42.96 203.04,42.76 202.73,42.76 202.68,42.71 v1(202.55,42.71)
LG2_VGA: length 5.9
  IN3 w0.635: 83.4,131.84 81.59,130.03 78.9,130.03 78.9,130.04
  BOTTOM w0.089: v1(89.72,131.44) v3(90.41,131.44)
  vias: v1(77.91,129.99) v1(84.57,132.09) v1(84.57,131.5) v1(89.72,132.02)
LG_1.2V: length 6.5
  TOP w0.635: 38.29,26.7 v3(39.56,25.43) 39.96,25.03 43.65,25.03 v1(43.98,24.7)
LG_NB: length 22.6
  TOP w0.089: v1(162.29,102.5) v3(162.29,101.93)
  IN2 w0.762: 159.34,87.26 159.71,87.63 161.63,87.63 162,87.26 165.09,87.26 166.19,88.35 166.19,96.82 163.71,99.3 163.71,101.74
  vias: v1(158.02,86.95) v1(158.63,86.95) v1(162.9,102.5)
LID_SW#: length 277.6
  TOP w0.089: v1(36.47,68.62) 36.16,68.31 D1.1 v4(31.73,68.31) ; EC1.1 32.7,74.61 RE17.2 33.15,74.21 33.95,74.21 34.17,73.99 34.38,73.99 35,74.61 UE1.115 36.47,74.61 36.79,74.93 38.13,74.93 39.09,73.97 v1(39.35,73.97)
  IN2 w0.089: v1(39.35,73.97) 39.35,73.59 36.95,71.19 36.95,69.1 v1(36.47,68.62) 36.47,66.71 36.24,66.48 36.24,61.98 37.05,61.17 37.05,58.3 41.11,54.24 41.11,52.98 44.07,50.02 44.07,38.92 48.48,34.5 54.49,34.5 57.95,31.04 57.95,29.58 60.35,27.18 61.58,27.18 62.27,27.86 62.35,27.86 63.09,28.6 64.63,28.6 66.86,26.36 82.84,26.36 83.09,26.11 97.3,26.11 97.34,26.14 99.82,26.14 100.67,27 110.49,27 110.91,27.42 111.27,27.42 111.69,27 129.59,27 133.21,30.62 136.23,30.62 138.06,32.45 144.03,32.45 148.23,28.25 148.89,28.25 150,27.13 165.81,27.13 166.44,27.77 170.46,27.77 170.97,27.26 172.76,27.26 173.37,27.87 175.74,27.87 176.26,28.39 180.24,28.39 182.06,30.2 188.9,30.2 189.06,30.04 210.91,30.04 212.36,31.49 214.02,31.49 214.52,31.99 215.37,31.99 218.03,34.65 218.03,35.25 218.56,35.78 218.56,41.19 218.51,41.24 218.51,42.62 218.9,43 221.48,43 223.12,44.64 223.12,47.87 221.79,49.2 221.79,50.26 221.54,50.52 221.54,54.54 222,55 222,56.08 222.86,56.95 222.86,59.08 223.41,59.63 223.41,60.24 222.8,60.85 v1(222.8,62.07)
  BOTTOM w0.089: v1(222.8,62.07) 222.84,62.07 223.2,62.43 JPWR1.3
LIMT_+1.35VGPU: length 4.3
  TOP w0.089: v3(146.15,110.55) 145.89,110.55 145.72,110.73 v1(145.72,110.94)
  TOP w0.254: v1(145.72,110.94) 146.22,111.45 146.5,111.45 PRW03.2
  BOTTOM w0.254: PUW01.12 144.25,110.36 144.84,110.95 144.84,111.19 145.09,111.45 PRW04.1 145.21,111.45 v1(145.72,110.94)
LINE1-L: length 5.2
  TOP w0.203: UA1.22 25.88,16.84 25.45,17.27 24.2,17.27 24.09,17.15 v3(22.77,17.15) 22.55,17.15 22.32,17.38 CA37.1
LINE1-L_C: length 1
  TOP w0.203: CA37.2 22.51,19.81 22.51,20.19 22.7,20.38 RA25.1
LINE1-L_R: length 0.9
  TOP w0.203: CA38.2 RA28.1
LINE1-R: length 3.9
  TOP w0.203: CA38.1 24.04,17.71 25.56,17.71 v3(25.74,17.53) 26.28,17 UA1.21
LM393_P: length 314.7
  TOP w0.254: PC21.1 93.1,147.52 93.31,147.73 PU2.5 ; PC21.1 92.68,147.52 91.98,148.22 PR21.1 ; PC21.1 92.72,147.25 v1(92.34,146.87) ; v1(167.86,31.22) 167.86,31.28 168.17,31.58 v3(168.17,31.76) 168.14,31.76 167.69,32.21 167.69,33.13 166.74,34.08 PUB02.5 166.74,34.7 167.19,35.16 PRB37.2 167.9,35.39 PCB44.2 ; PUS01.8 52.79,115.91 52.53,116.16 52.53,116.77 PCS01.2 52.85,117.9 v1(53.05,118.09) 53.16,118.09 54.71,119.64 PDS01.1 54.71,120.35 55.95,121.59 55.95,123.87 55.66,124.16 53.18,124.16 PRS43.1
  IN2 w0.089: v1(167.86,31.22) 167.53,31.56 163.36,31.56 162.37,30.57 162.23,30.57 161.97,30.31 154.67,30.31 149.76,35.21 147.11,35.21 146.94,35.21 146.22,34.5 135.68,34.5 135.38,34.19 134.41,34.19 134.21,34.4 131,34.4 130.45,33.84 129.81,33.84 125.55,29.58 121,29.58 120.7,29.87 116.97,29.87 116.49,29.4 110.23,29.4 109.67,28.83 100.13,28.83 99.91,29.05 97.26,29.05 96.75,28.54 85.73,28.54 84.57,29.7 67.41,29.7 66.68,30.42 62.33,30.42 61.59,29.69 61.08,29.69 60.67,30.1 60.67,31.24 54.31,37.59 50.68,37.59 47.81,40.46 47.81,44.29 46.08,46.01 46.08,51.07 44,53.15 44,54.19 39.86,58.33 39.86,59.13 39.55,59.44 39.55,65.85 39.52,65.88 39.52,67.39 40.13,68 40.13,69.39 41.13,70.39 41.13,71.27 40.95,71.44 40.95,72.8 41.19,73.04 41.19,75.07 40.79,75.47 40.79,76.78 40.92,76.91 40.92,78.13 41.57,78.79 41.57,80.55 40.92,81.2 40.92,81.77 39.67,83.02 38.84,83.02 38.26,83.6 38.26,86.53 38.85,87.12 39.16,87.12 39.71,86.57 40.9,86.57 40.99,86.65 40.99,87.48 41.12,87.6 41.12,88.57 42.27,89.73 42.27,94.52 41.89,94.9 41.89,96.56 42.27,96.95 42.27,111.1 42.76,111.59 42.76,114.85 45.93,118.03 52.99,118.03 v1(53.05,118.09)
  IN3 w0.254: v1(92.34,146.87) 89.79,146.87 89.22,146.29 86.61,146.29 85.94,146.97 78.18,146.97 75.9,144.69 75.9,141.91 75.07,141.08 73.19,141.08 70.78,138.67 66.49,138.67 63.65,135.84 63.65,130.51 65.36,128.8 65.36,127.57 64.37,126.58 63.91,126.58 62.6,125.26 62.6,123.45 62.14,122.99 58.5,122.99 53.6,118.09 v1(53.05,118.09)
  BOTTOM w0.254: PR50.1 91.8,146.34 v1(92.34,146.87)
LPC_AD0: length 149.1
  TOP w0.099: T104.1 129.85,53.2 v1(129.44,52.79)
  TOP w0.112: v1(37.9,70.81) 38.3,70.41 38.3,70.16 38.48,69.98 38.95,69.98 39.89,69.03 39.93,69.03 40.15,68.81 40.86,68.81 40.95,68.73 UE1.10
  IN3 w0.135: v1(128.46,40.47) 128.46,40.47 128.46,40.47 128.69,40.24 128.69,38.15 126.23,35.69 121.67,35.69 119.74,33.76 116.66,33.76 116.17,33.27 108.34,33.27 107.85,32.78 v1(107.78,32.78) 107.73,32.73 104.7,32.73 104.16,33.27 103.83,33.27 103.2,33.9 97.07,33.9 96.71,34.26 67.12,34.26 64.19,37.19 62.52,37.19 62.08,37.63 61.25,37.63 55.86,43.01 42.66,43.01 37.9,47.76 37.9,49.63 37.12,50.41 37.12,58.21 36.12,59.21 36.12,67.49 36.97,68.34 36.97,68.42 37.31,68.77 37.31,69.55 37.47,69.71 37.47,70.39 37.9,70.81 v1(37.9,70.81)
  BOTTOM w0.089: v1(129.44,52.79) 129.67,52.55 129.67,50.07 128.14,48.54 128.14,48.51
  BOTTOM w0.1: UC1.BB12 129.23,54.48 129.58,54.14 129.58,53.68 129.7,53.56 129.7,53.05 v1(129.44,52.79)
  BOTTOM w0.112: 128.14,48.51 128.04,48.41 128.04,46.57 127.63,46.15 127.63,43.87 127.05,43.29 127.05,41.84 128.42,40.47 v1(128.46,40.47) ; RX29.1 108,32.95 107.83,32.78 v1(107.78,32.78)
LPC_AD1: length 142.8
  TOP w0.112: v1(38.69,69.59) 38.69,69.59 38.81,69.59 39.57,68.83 39.85,68.83 40.15,68.52 UE1.8 ; v1(127.63,41.8) 127.26,41.43 124.96,41.43 122.93,39.4 122.93,34.78 123.37,34.34 123.37,34 123.3,33.92 123.07,33.7 122.02,33.7 121.47,34.25 112.99,34.25 109.67,35.76 108.81,35.76 v1(108.33,36.24)
  IN3 w0.135: v1(108.33,36.24) 108.18,36.24 108.06,36.36 107.01,36.36 106.78,36.59 105.45,36.59 104.43,35.56 97.64,35.56 97.2,36 66.67,36 64.57,38.1 62.9,38.1 62.46,38.54 61.75,38.54 56.37,43.92 43.04,43.92 38.82,48.14 38.82,61.34 37.87,62.28 37.87,64.44 37.03,65.28 37.03,67.11 37.88,67.96 37.88,68.05 38.23,68.39 38.23,69.17 38.65,69.59 38.68,69.59 v1(38.69,69.59)
  BOTTOM w0.1: v1(127.63,41.8) 128.04,42.21 128.04,42.84 129.27,44.07 129.27,46.27 128.93,46.61 128.93,49.08 129.96,50.1 T105.1 129.88,51.57 129.88,53.64 129.76,53.76 129.76,54.37 UC1.BC11
  BOTTOM w0.112: v1(108.33,36.24) 107.77,35.68 RX30.1
LPC_AD2: length 123.3
  TOP w0.099: T106.1 125.65,50.53 125.65,50.2 v1(125.82,50.03)
  TOP w0.112: v1(39.99,66.15) 39.75,66.38 UE1.7
  IN1 w0.099: 121.98,43.54 121.98,44.69 123.73,46.44 123.73,47.27 124.42,47.96
  IN1 w0.119: v1(108.31,40.06) 108.31,40.58 110.94,43.21 114.47,43.21 116.4,41.27 118.02,41.27 118.31,41.57 120.58,41.57 120.73,41.72 121.98,42.97 121.98,43.54 ; v1(125.82,50.03) 125.68,49.89 125.68,49.22 124.42,47.96
  IN3 w0.135: v1(39.99,66.15) 39.99,66.06 40.83,65.22 40.83,63.53 41.68,62.68 41.68,61.3 41.22,60.84 41.22,53.81 47.85,47.18 56.45,47.18 59.1,44.52 59.84,44.52 61.48,42.89 61.48,41.86 61.99,41.35 64.09,41.35 64.94,40.49 65.35,40.49 66.58,39.27 102.03,39.27 103.3,40.53 105.25,40.53 105.78,40 107.02,40 107.47,40.45 108.17,40.45 108.31,40.31 v1(108.31,40.06)
  BOTTOM w0.099: 126.3,52.63 126.31,52.65 126.31,53.67 126.54,53.9 126.54,54.11 126.23,54.42 UC1.BB15
  BOTTOM w0.102: 126.3,52.63 126.3,50.5 v1(125.82,50.03)
  BOTTOM w0.112: RX31.1 107.72,38.54 108.31,39.13 v1(108.31,40.06)
LPC_AD3: length 122.6
  TOP w0.099: v1(126.66,52.25) 126.63,52.21 126.63,51.47 T107.1
  TOP w0.112: UE1.5 38.95,68.72 38.66,69.01 v1(38.62,69.01)
  IN1 w0.099: 124.42,51.48 124.09,51.16 123.78,51.16 119.88,47.26 116.49,47.26 114.81,45.59 109.67,45.59 107.63,43.54
  IN1 w0.119: v1(126.66,52.25) 126.66,52.25 126.4,51.99 124.92,51.99 124.42,51.48 ; 107.63,43.54 107.27,43.18 104.66,43.18 102.63,41.15 101.76,41.15 v1(101.51,40.89) 101.25,41.15 74.52,41.15 74.14,41.52 65.91,41.52 65.17,40.78 60.97,40.78 59.62,42.13 58.5,42.13 58.29,42.35 57.12,42.35 55.49,43.98 46.91,43.98 v1(46.31,44.57)
  IN3 w0.135: v1(38.62,69.01) 38.62,68.46 38.11,67.95 38.11,65.27 38.33,65.06 38.33,62.47 39.27,61.53 39.27,48.33 43.23,44.38 46.12,44.38 v1(46.31,44.57)
  BOTTOM w0.099: UC1.BC15 126.72,54.41 126.72,53.82 126.52,53.62 126.52,52.35 126.62,52.25 v1(126.66,52.25)
  BOTTOM w0.112: v1(101.51,40.89) 101.45,40.84 101.45,40.37 RX32.1
LPC_CLK0_EC: length 137
  TOP w0.112: v1(38.69,70.36) 38.9,70.36 39.48,69.78 41.44,69.78 41.75,69.47 UE1.12 41.75,67.04 41.46,66.75 41,66.75 40.89,66.63 40.89,65.83 RE14.1
  IN3 w0.135: v1(126.79,38.56) 126.87,38.49 126.87,37.66 126.09,36.89 121.58,36.89 120.03,35.34 118.1,35.34 117.43,34.67 116.29,34.67 115.79,34.18 109.34,34.18 108.19,35.33 105.69,35.33 105.51,35.15 97.73,35.15 97.11,35.77 66.58,35.77 64.47,37.87 62.8,37.87 62.36,38.31 61.64,38.31 56.26,43.7 42.94,43.7 38.59,48.05 38.59,61.24 37.64,62.19 37.64,64.35 36.81,65.19 36.81,67.21 37.65,68.06 37.65,68.14 38,68.48 38,69.27 38.29,69.56 38.29,69.76 38.69,70.15 v1(38.69,70.36)
  BOTTOM w0.112: RC449.1 125.15,45.58 124.58,45 T113.1 124.62,44.73 124.62,43.5 126.22,41.89 126.22,41.5 126.73,40.99 126.73,38.62 v1(126.79,38.56)
LPC_FRAME#: length 136.1
  TOP w0.099: v1(129.31,52.22) 129.17,52.08 129.17,51.52 T109.1
  TOP w0.112: UE1.4 38.55,66.93 37.77,66.15 v1(37.64,66.15)
  IN3 w0.135: v1(37.64,66.15) 37.4,66.15 37.26,66.01 37.26,65.38 38.1,64.54 38.1,62.38 39.05,61.43 39.05,48.24 43.13,44.15 56.47,44.15 61.85,38.77 62.55,38.77 62.99,38.33 64.66,38.33 66.77,36.23 97.58,36.23 98.01,35.79 99.48,35.79 100.14,36.44 104.99,36.44 105.36,36.81 107.74,36.81 108.57,37.65 108.77,37.65 108.8,37.61 108.84,37.56 v1(108.83,37.52) 109.52,36.49 111.07,34.94 115.6,34.94 116.01,35.35 117.15,35.35 119.09,37.28 119.8,37.28 122.16,39.65 124.12,39.65 124.6,40.13 125.25,40.13 126.08,40.96 126.08,43.25 127.25,44.41 127.25,45.16 127.67,45.58 127.67,48.26 128.29,48.88 128.29,50.76 129.31,51.77 v1(129.31,52.22)
  BOTTOM w0.1: UC1.BA12 128.73,54.83 129.03,54.53 129.03,54.23 128.94,54.14 128.94,52.55 129.27,52.22 129.3,52.22 v1(129.31,52.22)
  BOTTOM w0.112: RX34.1 107.79,36.91 107.91,36.91 108,37.01 108.56,37.01 108.83,37.28 v1(108.83,37.52)
LPC_RST_A#: length 16.7
  TOP w0.112: RC602.1 126.65,42.83 v3(127.27,42.21) 127.29,42.19 128.04,42.19 v1(128.73,41.5)
  BOTTOM w0.1: v1(128.73,41.5) 128.47,41.76 128.47,42.73 129.66,43.93 129.66,45.88 130.62,46.83 130.62,47.66 130.45,47.82 130.45,51.66 130.25,51.86 130.25,53.99 UC1.BD11
LPCI_CLK_TPM: length 37.1
  IN3 w0.089: v1(116.48,36.38) 118.26,38.16 120.23,38.16 122.31,40.24 124.23,40.24 124.73,40.73 124.73,40.98 125.51,41.76 125.51,42.93 124.89,43.55 124.89,44.51 124.88,44.52 124.88,45.16 126.35,46.62 126.35,48.51 127.59,49.75 127.59,50.4 v1(127.66,50.47)
  BOTTOM w0.089: v1(116.48,36.38) 115.74,36.38 114.66,35.3 111.86,35.3 111.41,35.75 111.01,35.75 109.41,37.35 109.41,37.51 108.95,37.97 RX33.1
  BOTTOM w0.1: UC1.BB13 128.23,54.43 128.57,54.1 128.57,50.93 128.11,50.47 v1(127.66,50.47)
LPCPD#: length 45.6
  TOP w0.099: T103.1 127.37,51.6 v1(127.26,51.6)
  IN3 w0.135: v1(127.34,39.14) 127.61,38.87 127.61,37.75 126,36.15 121.48,36.15 119.55,34.22 116.47,34.22 115.98,33.73 107.83,33.73 107.68,33.87 106.49,33.87 106.14,33.52 106.14,33.51 v1(106.1,33.48)
  BOTTOM w0.089: 126.95,48.51 126.95,51.3 v1(127.26,51.6)
  BOTTOM w0.1: v1(127.26,51.6) 127.44,51.79 127.44,52.87 127.52,52.95 127.52,54.19 127.23,54.48 UC1.BB14
  BOTTOM w0.112: v1(127.34,39.14) 127.29,39.19 127.29,40.72 126.43,41.58 126.43,43.55 127.01,44.13 127.01,48.35 126.95,48.41 126.95,48.51 ; v1(106.1,33.48) 106.52,33.06 106.52,31 RX37.1
LPCPD#_R: length 8.8
  BOTTOM w0.089: v3(105.47,29.64) RX37.2 101.95,30.53 RX39.2 101.86,30.95 102.93,30.95 103.24,31.25 103.24,32.97 103.03,33.18 UX1.28
LX1_APU: length 14.1
  IN3 w1.016: 152.54,82.38 152.54,76.13 153.96,74.71 153.96,72.64 154.47,72.13 154.47,69.08
  vias: v1(153.06,83.32) v1(153.45,83.8) v1(154.33,67.78) v1(154.35,67.17) v1(154.35,66.56) v1(154.94,67.78) v1(154.94,67.17) v1(154.94,66.56) v1(154.94,65.95) v1(155.55,67.78) v1(155.55,67.17) v1(155.55,66.56) v1(155.55,65.95) v1(156.16,67.78) v1(156.16,67.17) v1(156.16,66.56) v1(156.16,65.95) v1(156.76,66.56) v1(156.76,65.95) v1(157.37,66.56) v1(157.37,65.95) v1(157.98,66.56) v1(157.98,65.95) v4(155.23,64.77)
LX1_CHG: length 16.7
  TOP w0.089: PRB17.1 v3(187.28,54.17)
  IN3 w0.508: v1(201.07,44.62) 200.89,44.62 200.39,45.13 200.39,50.7 198.44,52.65 197.04,52.65 195.3,50.91 v1(193.33,50.91)
  vias: v1(190.31,54.14)
LX1_VGA: length 11.3
  IN3 w0.635: 88.77,125.37 85,125.37 83.97,126.4 80.36,126.4 78.64,128.12
  vias: v1(77.9,128.3) v1(89.45,126.42) v1(89.45,125.81) v1(89.45,125.2) v1(90.06,127.16) v1(90.06,126.42) v1(90.27,124.34) v1(90.65,127.19) v1(90.65,126.45) v1(90.85,124.34) v1(91.44,124.34) v1(92.02,124.34) v1(92.19,124.95) v1(92.6,124.34) v1(92.95,124.95) v1(93.34,125.41) v1(93.38,124.51) v1(94.74,126.45) v1(94.94,127.02) v1(95.4,126.5) v1(95.53,127.07) v1(95.79,127.8) v1(95.77,125.97) v1(96.12,127.16) v1(96.12,126.55) v1(96.38,127.8) v1(96.35,125.97) v1(96.71,127.16) v1(96.71,126.55) v1(96.94,125.97) v1(96.96,127.8) v1(97.29,127.16) v1(97.29,126.55) v4(93.38,126.49)
LX2_APU: length 16.8
  IN3 w1.016: 156.65,82.48 163.05,76.08 163.05,68.3
  vias: v1(155.74,83.85) v1(155.89,83.28) v1(161.68,63.33) v1(161.68,62.67) v1(162.19,64.3) v1(162.29,63.33) v1(162.29,62.67) v1(162.8,64.3) v1(162.8,63.69) v1(163.41,64.3) v1(163.41,63.69) v1(164.02,64.3) v1(164.02,63.69) v1(164.63,64.3) v1(164.63,63.69) v1(165.24,64.3) v1(165.24,63.69) v1(165.85,63.69) v1(166.56,63.69) v1(166.56,63.08) v1(166.56,62.47) v1(166.56,61.86) v4(163.99,62.8)
LX2_CHG: length 5.2
  TOP w0.089: 192.88,43.49 193.14,43.49 v3(193.33,43.3)
  IN3 w0.508: v1(203.77,43.05) 202.71,42 v1(200.38,42)
  BOTTOM w0.203: PUB01.6 203.97,43.38 203.87,43.29 203.87,43.16 v1(203.77,43.05)
  vias: v1(192.29,43.68)
LX2_VGA: length 13.2
  IN3 w0.635: 78.71,130.93 81.2,130.93 82.59,132.31 82.59,133.75 83.43,134.6 89.33,134.6 89.46,134.73
  vias: v1(77.84,130.58) v1(89.43,135.43) v1(89.53,133.45) v1(90.04,135.43) v1(90.03,132.82) v1(90.14,133.45) v1(90.5,136.01) v1(90.65,135.43) v1(90.61,132.82) v1(90.75,133.45) v1(91.11,136.01) v1(91.19,132.82) v1(91.26,135.43) v1(91.72,136.01) v1(91.78,132.82) v1(91.87,135.43) v1(92.32,136.01) v1(92.9,136.75) v1(93.01,136.08) v1(93.44,136.51) v1(93.44,135.65) v1(93.87,136.08) v1(93.87,135.22) v1(94.31,135.65) v4(93,134.17)
LX_1.2V: length 6.2
  IN3 w0.635: v1(46.72,25.79) 40.78,25.79 v1(40.57,25.99)
  vias: v1(47.07,28.89) v3(47.15,29.59)
LX_1.8VALW: length 1.7
  TOP w0.089: PR1804.1 v3(175.73,52.07)
  vias: v1(177.06,55.34)
LX_3V: length 6.5
  TOP w0.089: v4(28.12,43.85) PR305.1
  TOP w0.508: v1(26.13,45.5) 26.62,45.01 PR305.1
  BOTTOM w0.254: PU301.6 18.79,42.14 18.84,42.18 20.91,42.18 20.96,42.14 PU301.20
LX_5V: length 5.4
  TOP w0.089: v3(22.75,98.23) 22.54,98.45 v1(22.54,99)
  TOP w0.508: PR505.1 21.71,98.95 PC507.2 22.43,99.11 v1(22.54,99)
  BOTTOM w0.203: 24.79,98 26.62,98 26.69,98.07 PU501.6
LX_+1.35VGPU: length 2.4
  TOP w0.089: v1(148.73,108.23) 148.73,108.17 v3(149.17,107.72)
  TOP w0.508: PRW07.1 v1(148.85,109.77) ; PCW12.2 v1(148.73,108.23)
LX_+VDDP:
  vias: v1(161.97,47.2) v1(161.97,46.57) v3(162.02,45.97)
LX_NB: length 21.9
  TOP w0.762: 157.83,97.59 v4(159.61,97.59) 160.34,97.59 163.01,94.93 163.8,94.93 165.3,93.43 165.3,88.9 164.27,87.87 164.27,86.9 162.84,85.47 160.18,85.47 159.42,86.23
  vias: v1(157.56,99.4) v1(157.56,98.79) v1(157.97,86.34) v1(158.58,86.34)
M0_MA0: length 31.4
  TOP w0.102: v1(153.99,139.13) 153.83,139.28 153.83,139.99 153.32,140.51 148.87,140.51 148.17,139.81 148.17,138.97 147.55,138.35
  TOP w0.127: v1(130.91,135.69) 130.91,135.44 131.04,135.32 131.97,135.32 132.13,135.48 133.16,135.48 133.42,135.23 135.44,135.23 135.96,135.75 136.52,135.75 ; v1(153.99,139.13) 154.31,138.8 UV12.H4
  TOP w0.14: 136.52,135.75 143.79,135.75 v3(145.16,137.12) 146.39,138.35 147.55,138.35
  BOTTOM w0.127: v1(130.91,135.69) 130.51,135.69 130.17,135.35 130.17,134.6 129.93,134.37 129.59,134.37 129.22,134 UV1.K17 ; UV12.H4 154.31,138.8 v1(153.99,139.13)
M0_MA1: length 30.7
  TOP w0.102: 147.36,138.83 147.97,139.44 147.97,139.9 148.78,140.71 153.63,140.71 v1(154.17,140.18)
  TOP w0.127: v1(130.91,136.83) 131.19,136.83 131.32,136.71 131.32,135.78 131.55,135.55 131.87,135.55 132.04,135.71 133.25,135.71 133.51,135.45 135.29,135.45 136.06,136.23 136.51,136.23 ; UV12.H5 154.31,140.04 v1(154.17,140.18)
  TOP w0.14: 136.51,136.23 143.51,136.23 v3(145.73,138.46) 146.11,138.83 147.36,138.83
  BOTTOM w0.127: UV12.H5 154.31,140.04 v1(154.17,140.18) ; UV1.J20 130.02,136.4 130.39,136.03 130.72,136.03 130.97,136.29 130.97,136.77 v1(130.91,136.83)
M0_MA2: length 29.9
  TOP w0.102: v1(154.71,143.93) 154.71,142.98 154.07,142.34 148.45,142.34 148.21,142.57
  TOP w0.127: 148.21,142.57 147.61,143.17 147.36,143.17 ; v1(130.34,138.1) 130.34,138.36 131.81,139.83 133.09,139.83 134.7,141.44 135.31,141.44 ; UV12.H11 154.31,144.33 v1(154.71,143.93)
  TOP w0.14: 135.31,141.44 141.74,141.44 143.47,143.17 v3(144.12,143.17) 147.36,143.17
  BOTTOM w0.127: UV1.H23 130.54,138.54 130.34,138.34 v1(130.34,138.1) ; UV12.H11 154.31,144.33 v1(154.71,143.93)
M0_MA3: length 29.4
  TOP w0.102: v1(154.03,142.93) 153.64,142.54 148.72,142.54 147.76,143.5
  TOP w0.127: UV12.H10 154.31,143.21 v1(154.03,142.93) ; 135.03,142.59 133.95,142.59 133.78,142.42 133.78,142 133.72,141.94 133.72,141.14 133.45,140.87 132.37,140.87 131.27,139.77 v1(131.03,139.77)
  TOP w0.14: 135.03,142.59 135.11,142.51 135.78,142.51 135.86,142.59 138.38,142.59 139.04,141.93 141.54,141.93 143.27,143.65 143.28,143.65 143.3,143.68 v3(145.32,143.68) 147.58,143.68 147.76,143.5
  BOTTOM w0.127: UV1.G23 130.86,139.08 130.86,139.59 v1(131.03,139.77) ; UV12.H10 154.31,143.21 v1(154.03,142.93)
M0_MA4: length 29.8
  TOP w0.102: 147.36,142.21 147.76,142.21 148.04,141.93 156.04,141.93 156.31,142.2 v1(156.31,143.93)
  TOP w0.127: v1(131.8,138.94) 131.8,139.17 132,139.38 133.6,139.38 134.65,140.43 135.1,140.43 ; v1(156.31,143.93) 155.91,144.33 UV12.K11
  TOP w0.14: 147.36,142.21 v3(145.39,142.21) 144.5,142.21 142.72,140.43 142.05,140.43 142.04,140.42 137.77,140.42 137.76,140.43 137.41,140.43 137.39,140.42 135.11,140.42 135.1,140.43
  BOTTOM w0.127: v1(156.31,143.93) 155.91,144.33 UV12.K11 ; UV1.G24 v1(131.8,138.94)
M0_MA5: length 30.8
  TOP w0.102: v1(155.91,142.96) 155.91,142.81 155.24,142.14 148.12,142.14 147.57,142.69 147.36,142.69
  TOP w0.127: v1(131.74,138.23) 131.4,138.56 131.4,139.1 131.91,139.6 133.37,139.6 134.73,140.96 135.17,140.96 ; UV12.K10 155.91,142.96 v1(155.91,142.96)
  TOP w0.14: 135.17,140.96 141.94,140.96 141.99,141.01 142.63,141.01 144.31,142.69 v3(146.66,142.69) 147.36,142.69
  BOTTOM w0.127: v1(155.91,142.96) 155.91,142.96 UV12.K10 ; UV1.H24 130.54,139.16 130.55,139.15 130.55,139.04 130.91,138.67 130.91,138.55 131.23,138.23 v1(131.74,138.23)
M0_MA6: length 31.5
  TOP w0.102: v1(130.02,135.82) 130.53,136.32 130.53,136.99 130.76,137.21 130.88,137.21 131.2,137.54 131.97,137.54 132.28,137.23 132.87,137.23 133.27,136.83 135.2,136.83 136.22,137.85 ; v1(155.91,140.09) 154.68,141.32 148.38,141.32 148.23,141.17
  TOP w0.127: v1(155.91,140.09) 155.91,139.53 UV12.K5 ; 147.6,140.54 148.23,141.17
  TOP w0.14: 147.6,140.54 v3(145.32,140.54) 143.01,138.23 136.6,138.23 136.22,137.85
  BOTTOM w0.127: UV1.J19 129.74,135.53 v1(130.02,135.82) ; v1(155.91,140.09) 155.91,140.09 UV12.K5
M0_MA7: length 34
  TOP w0.102: 147.56,140.06 148.62,141.12 154.05,141.12 154.16,141.01 154.39,141.01 155.51,139.89 v1(155.51,139.13)
  TOP w0.127: v1(131.85,136.59) 132.2,136.93 132.86,136.93 133.88,135.91 134.99,135.91 136.11,137.19 136.38,137.19 ; UV12.K4 155.91,138.73 v1(155.51,139.13)
  TOP w0.14: 136.38,137.19 136.78,137.6 143.05,137.6 v3(144.47,139.02) 145.52,140.06 147.56,140.06
  BOTTOM w0.102: v1(131.85,136.59) 131.66,136.78 131.51,136.78 131.29,136.99 131.29,136.99 131.28,137 131.2,137.09 131.2,137.09 131.07,137.21 130.76,137.21 130.63,137.09 130.44,137.09 130.23,137.29 129.94,137.29 129.89,137.24 129.87,137.24 129.7,137.07 129.7,136.96 129.34,136.6 129.34,136.29 129.52,136.11 129.52,135.75 129.38,135.62 129.38,135.3 129.28,135.2 UV1.K19
  BOTTOM w0.127: UV12.K4 155.91,138.73 v1(155.51,139.13)
M0_MA8: length 29.9
  TOP w0.102: 147.39,139.58 147.77,139.96 147.77,139.98 148.7,140.92 153.97,140.92 154.79,140.09 v1(154.79,140.07)
  TOP w0.127: v1(131.71,135.94) 133.35,135.94 133.6,135.68 135.19,135.68 136.22,136.71 136.38,136.71 ; v1(154.79,140.07) 155.11,139.75 UV12.J5
  TOP w0.14: 136.38,136.71 136.64,136.71 136.78,136.85 136.78,136.88 136.92,137.02 137.2,137.02 137.34,136.88 137.34,136.85 137.48,136.71 137.76,136.71 137.9,136.85 137.9,136.88 138.04,137.02 138.32,137.02 138.46,136.88 138.46,136.85 138.6,136.71 138.88,136.71 139.01,136.85 139.01,136.88 139.15,137.02 139.43,137.02 139.57,136.88 139.57,136.85 139.71,136.71 139.98,136.71 140.12,136.85 140.12,136.88 140.26,137.02 140.54,137.02 140.68,136.88 140.68,136.85 140.82,136.71 141.1,136.71 141.24,136.85 141.24,136.88 141.38,137.02 141.66,137.02 141.8,136.88 141.8,136.85 141.94,136.71 142.84,136.71 143.05,136.91 143.24,136.91 143.25,136.91 143.44,136.91 143.64,137.11 143.64,137.31 143.64,137.31 143.64,137.51 143.84,137.7 144.03,137.7 144.04,137.7 144.23,137.7 144.43,137.9 144.43,138.1 144.43,138.1 144.43,138.3 144.63,138.49 144.82,138.49 144.83,138.49 145.02,138.49 145.22,138.69 145.22,138.89 145.22,138.89 145.22,139.09 145.71,139.58 v3(146.4,139.58) 147.39,139.58
  BOTTOM w0.127: v1(154.79,140.07) 155.11,139.75 UV12.J5 ; v1(131.71,135.94) 131.54,135.94 131.34,136.14 UV1.G20
M1_MA0: length 35.5
  TOP w0.102: 147.53,124.09 147.83,124.09 148.24,124.51 155.48,124.51 156.64,125.66 156.64,126.04 156.32,126.36 156.32,126.82 v1(156.23,126.91)
  TOP w0.127: v1(156.23,126.91) 155.91,127.23 UV14.H4 ; v1(129.11,131.09) 129.11,131.13 129.4,131.42 130.53,131.42 130.79,131.16 130.79,130.74 131.02,130.51 131.35,130.51 131.35,130.52 131.69,130.52 132.15,130.06 132.15,129.16 132.45,128.86 135.51,128.86 135.62,128.75 ; 147.36,124.09 147.53,124.09
  TOP w0.14: 147.36,124.09 v3(146.78,124.09) 146.63,124.09 146.55,124.13 142.57,128.1 142.17,128.1 142.17,128.09 136.28,128.09 135.62,128.75
  BOTTOM w0.127: v1(129.11,131.09) 129.11,131.1 129.62,131.6 UV1.J14 ; UV14.H4 155.91,127.23 v1(156.23,126.91)
M1_MA1: length 33.4
  TOP w0.102: v1(156.06,125.85) 154.91,124.71 148.07,124.71
  TOP w0.127: UV14.H5 155.91,126 v1(156.06,125.85) ; v1(129.27,132.37) 129.27,131.78 129.4,131.65 130.83,131.65 131.17,131.3 131.49,131.3 131.76,131.03 131.76,130.78 132.38,130.16 132.38,129.98 132.66,129.7 132.98,129.7 133.59,129.09 136.09,129.09 136.58,128.6 ; 147.68,124.71 148.07,124.71
  TOP w0.14: 147.68,124.71 146.84,124.71 v3(145.98,125.56) 142.98,128.57 142.79,128.57 142.77,128.58 136.59,128.58 136.58,128.6
  BOTTOM w0.127: v1(156.06,125.85) 155.91,126 UV14.H5 ; v1(129.27,132.37) 129.27,131.93 UV1.K14
M1_MA2: length 33.8
  TOP w0.127: v1(129.5,129.83) 129.86,130.19 130.37,130.19 130.51,130.05 130.51,129.31 130.69,129.12 131.22,129.12 132.17,128.17 134.2,128.17 134.52,127.85 134.52,127.65 135.25,126.92 135.58,126.92 ; 147.38,122.6 148.67,123.89 154.47,123.89 154.73,123.62 154.73,122.29 154.91,122.11 v1(155.51,122.11) UV14.H11
  TOP w0.14: 135.58,126.92 135.93,126.92 136.8,126.05 142.34,126.05 v3(144.15,124.24) 145.8,122.6 147.38,122.6
  BOTTOM w0.127: v1(129.5,129.83) 129.74,129.6 UV1.J11 ; UV14.H11 v1(155.51,122.11)
M1_MA3: length 33.4
  TOP w0.102: v1(156.19,123.1) 156.19,123.36 155.46,124.1 148.56,124.1 147.56,123.1
  TOP w0.127: 135.68,127.16 135.33,127.16 134.75,127.74 134.75,127.94 134.29,128.4 132.26,128.4 131.69,128.98 131.69,129.28 131.68,129.29 131.68,129.72 131.37,130.03 130.86,130.03 130.47,130.42 130.22,130.42 129.71,130.93 v1(129.71,131.02) ; 147.36,123.1 147.56,123.1 ; UV14.H10 155.91,122.82 v1(156.19,123.1)
  TOP w0.14: 147.36,123.1 145.99,123.1 v3(143.55,125.54) 142.56,126.53 137,126.53 136.37,127.16 135.68,127.16
  BOTTOM w0.127: UV14.H10 155.91,122.82 v1(156.19,123.1) ; v1(129.71,131.02) 129.71,130.43 UV1.J13
M1_MA4: length 31.8
  TOP w0.102: 147.41,121.58 148.18,122.35 148.18,122.8 148.85,123.47 153.58,123.47 153.83,123.22 153.83,122.18 v1(153.91,122.11)
  TOP w0.127: v1(130.08,129.79) 130.08,129.29 130.58,128.8 130.58,128.56 130.88,128.26 131.43,128.26 132.54,127.15 132.91,127.15 134.83,125.23 136.04,125.23 136.58,124.69 ; v1(153.91,122.11) UV14.K11
  TOP w0.14: 136.58,124.69 137.98,123.29 143.65,123.29 145.35,121.58 v3(145.89,121.58) 147.41,121.58
  BOTTOM w0.127: UV1.H11 130.08,129.65 v1(130.08,129.79) ; UV14.K11 v1(153.91,122.11)
M1_MA5: length 29.5
  TOP w0.102: v1(154.31,123.07) 153.71,123.67 148.76,123.67 147.82,122.73 147.82,122.46 147.45,122.09 147.36,122.09
  TOP w0.127: v1(154.31,123.07) UV14.K10 ; v1(130.97,128.73) 131.29,128.73 132.64,127.38 133,127.38 133.69,126.68 133.95,126.68 134.08,126.81 134.08,127.01 134.24,127.17 134.42,127.17 134.58,127.01 134.58,126.81 134.71,126.68 135.49,126.68 136.58,125.6
  TOP w0.14: 147.36,122.09 145.54,122.09 v3(144.69,122.94) 143.38,124.26 137.91,124.26 136.58,125.6
  BOTTOM w0.127: v1(130.97,128.73) 130.97,128.83 UV1.G11 ; UV14.K10 v1(154.31,123.07)
