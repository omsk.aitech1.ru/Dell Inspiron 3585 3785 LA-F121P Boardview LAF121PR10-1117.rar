# Allegro board LAF121PR10-1117.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M1_MA6: length 31
  TOP w0.102: 154.09,125.85 154.03,125.85 153.7,125.52 148.87,125.52 148.11,126.28
  TOP w0.127: v1(130,133.38) 130.09,133.38 130.55,132.91 130.86,132.91 130.95,132.82 131.55,132.22 131.87,132.22 132.27,131.82 132.88,131.82 133.34,131.36 134.22,131.36 134.52,131.66 136.37,131.66 136.58,131.46 ; UV14.K5 154.31,126.07 v1(154.09,125.85) 154.09,125.85 ; 148.11,126.58 148.11,126.28
  TOP w0.14: 148.11,126.58 v3(143.91,130.79) 143.24,131.46 142.22,131.46 142.08,131.32 142.08,131.22 141.94,131.08 141.71,131.08 141.53,131.26 141.53,131.32 141.39,131.46 141.11,131.46 140.97,131.32 140.97,131.18 140.83,131.04 140.55,131.04 140.41,131.18 140.41,131.32 140.27,131.46 137.98,131.46 137.97,131.46 137.62,131.46 137.61,131.46 136.58,131.46
  BOTTOM w0.127: v1(154.09,125.85) 154.09,126.29 UV14.K5 ; v1(130,133.38) 130,133.1 129.74,132.83 UV1.J16
M1_MA7: length 34.2
  TOP w0.102: 147.9,126.08 148.02,126.08 148.78,125.32 154.1,125.32 154.54,125.76 154.54,126.28 154.63,126.37 154.63,126.83 v1(154.71,126.91)
  TOP w0.127: v1(154.71,126.91) UV14.K4 ; v1(128.57,133.4) 128.99,133.82 129.48,133.82 129.61,133.7 129.61,133.08 130.01,132.68 130.76,132.68 131.46,131.99 131.78,131.99 132.18,131.59 132.79,131.59 133.24,131.13 133.88,131.13 134.14,130.88 136.36,130.88 ; 147.84,126.18 147.84,126.14 147.9,126.08
  TOP w0.14: 136.36,130.88 136.38,130.9 137.04,130.9 137.38,130.56 139.08,130.56 139.08,130.55 139.43,130.55 139.44,130.56 143.46,130.56 v3(144.49,129.53) 147.84,126.18
  BOTTOM w0.127: UV14.K4 v1(154.71,126.91) ; v1(128.57,133.4) 128.57,132.95 128.56,132.94 128.56,132.7 128.14,132.28 UV1.L15
M1_MA8: length 30.2
  TOP w0.102: 148.01,125.62 148.2,125.62 148.7,125.12 154.59,125.12 154.92,125.45 v1(154.92,125.91)
  TOP w0.127: 147.73,125.9 148.01,125.62 ; 136.37,130.42 135.36,130.42 135.36,130.42 134.27,130.42 133.79,130.9 133.15,130.9 132.7,131.35 132.09,131.35 131.68,131.76 131.36,131.76 130.96,132.16 130.73,132.16 v1(130.62,132.27) ; UV14.J5 155.11,126.1 v1(154.92,125.91)
  TOP w0.14: 136.37,130.42 136.38,130.42 136.83,130.42 137.24,130.01 143.32,130.01 v3(145.16,128.17) 147.32,126.01 147.62,126.01 147.73,125.9
  BOTTOM w0.127: UV1.G14 131.29,131.6 v1(130.62,132.27) ; UV14.J5 155.11,126.1 v1(154.92,125.91)
M_ADBI0: length 32.5
  TOP w0.127: UV12.J4 155.11,138.73 v1(155.51,138.33) 155.51,137.85 155.18,137.52 155.03,137.52 154.73,137.22 154.73,136.12 154.71,136.09 ; v1(128.95,134.61) 129.97,134.61 130.61,133.96 131.94,133.96 132.19,134.22 132.83,134.22 133.16,133.89 135.53,133.89 135.64,134 136.58,134
  TOP w0.14: 136.58,134 v3(145.39,134) 153.77,134 154.67,134.9 154.67,135.55 154.71,135.59 154.71,135.93 154.71,135.93 154.71,136.09
  BOTTOM w0.102: v1(128.95,134.61) 128.76,134.8 UV1.L18
  BOTTOM w0.127: UV12.J4 155.11,138.73 v1(155.51,138.33)
M_ADBI1: length 35.1
  TOP w0.102: 155.57,125.68 154.81,124.91 148.42,124.91 148.39,124.94
  TOP w0.127: 148.39,124.94 147.75,124.94 147.36,125.33 ; 155.57,125.68 155.57,125.95 155.39,126.13 155.39,126.31 155.57,126.49 155.57,126.91 v1(155.55,126.93) 155.17,127.31 UV14.J4 ; 136.58,129.93 136.32,130.19 135.24,130.19 135.11,130.06 135.11,130.01 134.99,129.88 134.73,129.88 134.61,130.01 134.61,130.06 134.48,130.19 134.18,130.19 133.69,130.68 132.92,130.68 132.79,130.54 132.32,130.54 132.03,130.83 132.03,131.09 131.59,131.53 131.27,131.53 130.92,131.87 129.79,131.87 129.66,132 129.66,132.54 129.08,133.12 129.08,133.3 v1(129.22,133.43)
  TOP w0.14: 136.58,129.93 136.58,129.79 136.71,129.66 136.71,129.34 136.85,129.2 143.22,129.2 143.35,129.07 143.37,129.07 v3(145.58,126.87) 147.06,125.39 147.3,125.39 147.36,125.33
  BOTTOM w0.127: UV1.K16 128.94,133.15 v1(129.22,133.43) ; v1(155.55,126.93) 155.17,127.31 UV14.J4
M_CAS#0: length 33.1
  TOP w0.102: 147.98,141.38 148.12,141.53 155.82,141.53 156.31,141.03 v1(156.31,138.33)
  TOP w0.127: v1(133.34,137.3) 133.41,137.3 134,137.89 134.27,137.89 134.53,138.15 134.53,138.6 134.66,138.73 134.82,138.73 134.84,138.75 135.78,138.75 135.8,138.73 136.58,138.73 ; v1(156.31,138.33) 156.71,137.93 UV12.L3
  TOP w0.14: 136.58,138.73 142.6,138.73 144.95,141.08 v3(146.53,141.08) 147.67,141.08 147.98,141.38
  BOTTOM w0.102: UV1.G19 131.34,135.21 131.53,135.4 131.71,135.4 132.01,135.7 132.18,135.7 132.42,135.94 132.89,135.94 133.02,136.07 133.02,136.1 133.02,136.1 133.02,136.41 133.02,136.42 133.02,136.49 132.63,136.87 132.63,137.12 132.81,137.3 v1(133.34,137.3)
  BOTTOM w0.127: v1(156.31,138.33) 156.71,137.93 UV12.L3
M_CAS#1: length 32.4
  TOP w0.102: v1(153.91,127.71) 153.91,126.37 153.27,125.73 148.95,125.73 148.34,126.34 148.34,127.22 148.2,127.36
  TOP w0.127: 136.58,132.36 134.53,132.36 133.98,132.91 133.2,132.91 132.95,132.66 132.95,132.56 132.63,132.25 132.21,132.25 v1(131.85,132.61) ; v1(153.91,127.71) UV14.L3
  TOP w0.14: 136.58,132.36 v3(143.19,132.36) 145.04,130.52 145.24,130.52 145.71,130.98 145.9,130.98 146.1,130.79 146.1,130.59 145.63,130.12 145.63,129.92 145.83,129.72 146.03,129.72 146.47,130.16 146.66,130.16 146.86,129.96 146.86,129.77 146.42,129.33 146.42,129.13 148.2,127.36
  BOTTOM w0.127: UV1.G16 131.66,132.8 v1(131.85,132.61) ; UV14.L3 v1(153.91,127.71)
M_CKE0: length 34
  TOP w0.127: 136.58,134.63 135.63,134.63 135.11,134.11 134.27,134.11 134.14,134.24 134.14,134.64 134.01,134.76 133.76,134.76 133.63,134.64 133.63,134.24 133.5,134.11 133.25,134.11 132.69,134.68 132.33,134.68 131.84,134.19 130.71,134.19 129.4,135.5 129.4,136.75 v1(129.12,137.04) ; UV12.J3 155.11,137.93 v1(154.71,138.33) 154.71,137.85 154.45,137.59 154.3,137.59 153.91,137.2 153.91,135.75
  TOP w0.14: 136.58,134.63 v3(143.61,134.63) 144.13,134.63 144.5,135 144.8,135 145.16,134.63 152.88,134.63 153.91,135.66 153.91,135.75
  BOTTOM w0.127: UV12.J3 155.11,137.93 v1(154.71,138.33) ; v1(129.12,137.04) 128.94,136.86 UV1.K20
M_CKE1: length 33.4
  TOP w0.127: 153.91,130.4 153.91,128.75 154.11,128.54 154.38,128.54 154.72,128.2 v1(154.72,127.63) 155.01,127.92 155.11,128.02 UV14.J3 ; 136.39,133.02 135.98,133.43 133.13,133.43 132.8,133.1 131,133.1 130.64,133.46 v1(130.56,133.46)
  TOP w0.14: 136.39,133.02 136.59,132.82 144.6,132.82 144.74,132.68 144.74,131.64 144.88,131.5 145.16,131.5 145.3,131.64 145.3,132.68 145.44,132.82 145.71,132.82 145.85,132.68 145.85,132.6 145.99,132.46 146.27,132.46 146.41,132.6 146.41,132.68 146.55,132.82 151.83,132.82 v3(152.82,131.83) 153.91,130.75 153.91,130.4
  BOTTOM w0.127: UV14.J3 155.11,128.02 v1(154.72,127.63) ; v1(130.56,133.46) 130.55,133.46 130.02,134 UV1.J17
M_CLK0: length 35.2
  TOP w0.102: 155.72,147.42 155.72,147.39 v1(155.57,147.24)
  TOP w0.112: UV12.J12 155.11,145.12 v1(154.71,144.73)
  TOP w0.122: RV79.2 155.2,148.49 155.2,148.25 155.72,147.73 155.72,147.42
  IN3 w0.132: v1(130.94,141.37) 131.26,141.04 132.17,141.04 132.23,141.1 133.11,141.1 133.29,140.93 134.94,140.93 135.32,141.32 136.12,141.32 136.36,141.32 136.63,141.59 137.41,141.59 138.08,142.26 149.04,142.26 149.39,141.91 154.98,141.91 155.29,142.22 155.29,143.96 155.09,144.15 155.09,144.34 v1(154.71,144.73) 154.97,144.99 154.97,145.41 155.58,146.01 155.58,146.65 155.76,146.82 155.76,147.06 v1(155.57,147.24)
  BOTTOM w0.102: UV1.H26 130.57,141 v1(130.94,141.37)
  BOTTOM w0.112: UV12.J12 155.11,145.12 v1(154.71,144.73)
M_CLK1: length 35.2
  TOP w0.112: UV14.J12 v1(155.51,121.31)
  TOP w0.122: v1(155.32,117.52) 155.16,117.36 155.16,116.99 155.49,116.66 RV85.2
  IN3 w0.132: v1(131.74,127) 131.63,126.89 131.63,126.42 131.97,126.09 133.04,126.09 133.92,126.98 136.39,126.98 136.68,126.69 139.72,126.69 139.99,126.42 146.32,126.42 147.11,125.62 148.28,125.62 149.64,124.27 154.17,124.27 155,123.43 155,121.98 155.13,121.86 155.13,121.69 v1(155.51,121.31) 155.26,121.06 155.26,120.35 154.97,120.07 154.97,118.47 155.19,118.26 155.19,117.66 155.19,117.65 v1(155.32,117.52)
  BOTTOM w0.102: v1(131.74,127) UV1.G9
  BOTTOM w0.112: UV14.J12 v1(155.51,121.31)
M_CLK#0: length 35.3
  TOP w0.102: 155.98,147.42 v1(156.15,147.24)
  TOP w0.112: UV12.J11 155.11,144.33 v1(155.51,144.73)
  TOP w0.122: RV80.2 155.42,148.94 155.42,148.34 155.94,147.82 155.94,147.46 155.98,147.42
  IN3 w0.132: v1(156.15,147.24) 155.98,147.07 155.98,146.73 155.8,146.55 155.8,145.92 155.2,145.31 155.2,145.04 v1(155.51,144.73) 155.31,144.53 155.31,144.25 155.51,144.05 155.51,142.13 155.07,141.69 149.3,141.69 148.95,142.04 138.17,142.04 137.5,141.37 136.72,141.37 136.42,141.07 136.02,141.07 136.02,141.07 135.41,141.07 135.41,141.07 135.39,141.07 135.03,140.71 133.19,140.71 133.02,140.88 132.32,140.88 132.26,140.82 131.11,140.82 v1(130.94,140.65)
  BOTTOM w0.102: UV1.H25 130.94,140.6 v1(130.94,140.65)
  BOTTOM w0.112: v1(155.51,144.73) 155.11,144.33 UV12.J11
M_CLK#1: length 35.4
  TOP w0.112: UV14.J11 v1(154.71,121.31)
  TOP w0.122: RV86.2 154.94,117 154.94,117.31 v1(154.74,117.52)
  IN3 w0.132: v1(130.94,127) 131.41,126.53 131.41,126.33 131.88,125.87 133.13,125.87 134.02,126.75 136.3,126.75 136.58,126.47 139.62,126.47 139.89,126.2 146.22,126.2 147.02,125.4 148.19,125.4 149.55,124.05 154.07,124.05 154.78,123.34 154.78,121.89 154.91,121.77 154.91,121.5 v1(154.71,121.31) 154.76,121.31 155.04,121.03 155.04,120.44 154.75,120.16 154.75,118.38 154.97,118.16 154.97,117.75 v1(154.74,117.52)
  BOTTOM w0.102: v1(130.94,127) UV1.H9
  BOTTOM w0.112: UV14.J11 v1(154.71,121.31)
M_CS0B#0: length 32.3
  TOP w0.102: v1(153.91,144.73) 153.91,143.39 153.27,142.74 148.98,142.74 148.38,143.34 148.38,143.55 148.24,143.7
  TOP w0.127: v1(153.91,144.73) 153.51,145.13 UV12.G12 ; 135.31,142.99 133.61,142.99 132.91,142.3 132.91,141.94 131.23,140.25 130.96,140.25 130.6,139.89 130.6,139.44 130.15,139 v1(130.15,138.99)
  TOP w0.14: 135.31,142.99 135.59,142.99 135.9,143.3 138.88,143.3 139.2,143.62 140.28,143.62 140.29,143.63 140.64,143.63 140.65,143.62 140.94,143.62 141.08,143.48 141.08,143.33 141.22,143.19 141.5,143.19 141.64,143.33 141.64,143.48 141.78,143.62 142.56,143.62 143.07,144.14 143.08,144.14 143.13,144.19 v3(146.66,144.19) 147.75,144.19 148.24,143.7
  BOTTOM w0.127: UV12.G12 153.51,145.13 v1(153.91,144.73) ; UV1.H22 130.29,137.6 129.95,137.94 129.95,138.36 130.15,138.56 130.15,138.99 v1(130.15,138.99)
M_CS1B#0: length 35.2
  TOP w0.102: 147.64,123.61 148.33,124.3 155.54,124.3 156.57,123.27 156.57,122.93 156.25,122.6
  TOP w0.127: 147.36,123.61 147.64,123.61 ; 156.25,122.6 156.25,121.37 v1(156.26,121.35) 156.71,120.91 UV14.G12 ; v1(130.31,131.02) 130.31,130.9 130.96,130.25 131.46,130.25 131.92,129.8 131.92,129.07 132.36,128.63 134.39,128.63 135.4,127.62 136.55,127.62
  TOP w0.14: 147.36,123.61 146.38,123.61 v3(142.98,127.01) 142.38,127.61 136.56,127.61 136.55,127.62
  BOTTOM w0.127: UV1.G13 131.06,130.4 130.69,130.77 130.57,130.77 130.31,131.02 v1(130.31,131.02) ; UV14.G12 156.63,120.91 156.26,121.28 v1(156.26,121.35)
M_DA0: length 60.3
  IN3 w0.142: v1(129.26,142.99) 129.26,143.19 127.92,144.52 127.92,146.54 134.98,153.6 159.81,153.6 162.65,150.77 162.65,149.28 163.63,148.3 163.63,148.06 163.92,147.77 163.92,142.88 163.49,142.46 163.49,138.3 v1(161.91,136.72)
  BOTTOM w0.127: UV13.A2 v1(161.91,136.72) ; UV1.K27 129.33,142.18 129.33,142.93 129.26,142.99 v1(129.26,142.99)
M_DA1: length 57.4
  IN3 w0.142: v1(161.11,136.72) 161.11,137.14 161.49,137.52 161.61,137.52 162.47,138.38 162.47,142.41 163.23,143.17 163.23,148.14 161.71,149.66 161.71,150.74 159.24,153.2 135.15,153.2 128.34,146.39 128.34,144.74 v1(129.26,143.82)
  BOTTOM w0.127: v1(129.26,143.82) 129.26,143.82 129.26,143.69 129.74,143.21 UV1.J29 ; UV13.B2 v1(161.11,136.72)
M_DA2: length 51.5
  IN3 w0.142: v1(129.97,144.9) 129.4,145.47 129.4,145.84 130.19,146.63 130.19,147.49 135.51,152.81 158.7,152.81 160.7,150.81 160.7,150.43 160.69,150.42 160.69,149.79 162.33,148.15 162.33,143.23 161.91,142.81 v1(161.91,139.13)
  BOTTOM w0.127: UV1.H30 130.54,143.43 130.22,143.75 130.22,144.65 130.09,144.78 ; v1(161.91,139.13) UV13.A4
  BOTTOM w0.14: 130.09,144.78 v1(129.97,144.9)
M_DA3: length 48.5
  IN3 w0.102: 161.52,147.42 161.52,139.54 v1(161.11,139.13)
  IN3 w0.142: 161.52,147.42 161.52,147.96 159.5,149.98 159.5,150.19 159.74,150.42 159.74,150.75 158.38,152.11 135.37,152.11 130.6,147.34 130.6,145.98 v1(130.09,145.47)
  BOTTOM w0.127: v1(161.11,139.13) UV13.B4 ; 130.4,145.17 130.54,145.03 UV1.H32
  BOTTOM w0.14: 130.4,145.17 v1(130.09,145.47)
M_DA4: length 46
  IN3 w0.102: v1(157.11,136.72) 157.53,137.15 157.53,147.36 157.47,147.42
  IN3 w0.142: v1(131.66,143.37) 132.08,143.37 132.11,143.41 133.81,143.41 135.62,145.22 144.12,145.22 146.99,148.09 147.31,148.09 147.45,148.23 147.45,148.49 147.59,148.63 147.88,148.63 148.02,148.49 148.02,148.23 148.16,148.09 148.45,148.09 148.59,148.23 148.59,148.49 148.73,148.63 149.02,148.63 149.16,148.49 149.16,148.23 149.3,148.09 149.58,148.09 149.73,148.23 149.73,148.49 149.87,148.63 150.15,148.63 150.3,148.49 150.3,148.23 150.44,148.09 150.72,148.09 150.86,148.23 150.86,148.49 151.01,148.63 151.29,148.63 151.43,148.49 151.43,148.23 151.58,148.09 151.86,148.09 152,148.23 152,148.49 152.14,148.63 152.43,148.63 152.57,148.49 152.57,148.23 152.71,148.09 153,148.09 153.14,148.23 153.14,148.49 153.28,148.63 153.57,148.63 153.71,148.49 153.71,148.23 153.85,148.09 154.14,148.09 154.28,148.23 154.28,148.49 154.42,148.63 154.71,148.63 154.85,148.49 154.85,148.23 154.99,148.09 155.27,148.09 155.42,148.23 155.42,148.49 155.56,148.63 155.84,148.63 155.99,148.49 155.99,148.23 156.13,148.09 156.8,148.09 157.47,147.42
  BOTTOM w0.127: v1(131.66,143.37) 131.66,143.32 UV1.G29 ; UV13.F2 v1(157.11,136.72)
M_DA5: length 47.3
  IN3 w0.102: v1(157.11,138.33) 156.84,138.59 156.65,138.59 156.29,138.95 156.29,140.21 156.69,140.61 156.69,147.38 156.65,147.42
  IN3 w0.142: 156.65,147.42 156.37,147.7 147.86,147.7 146.21,146.05 146.21,145.74 144.81,144.34 143.27,144.34 143.25,144.37 143.07,144.2 143.07,143.82 142.9,143.65 142.54,143.65 142.37,143.82 142.37,144.2 142.19,144.37 141.84,144.37 141.67,144.2 141.67,143.17 141.49,143 141.14,143 140.97,143.17 140.97,144.2 140.79,144.37 139.72,144.37 139.54,144.2 139.54,143.17 139.37,143 139.02,143 138.84,143.17 138.84,144.2 138.67,144.37 138.32,144.37 138.14,144.2 138.14,143.31 137.97,143.13 137.4,143.13 137.23,142.96 137.23,142.67 137.03,142.47 136.65,142.47 136.48,142.64 136.48,144.2 136.3,144.37 135.87,144.37 135.67,144.17 135.67,142.79 135.49,142.61 135.17,142.61 135.08,142.7 132.8,142.7 v1(132.5,142.99)
  BOTTOM w0.127: v1(132.5,142.99) 132.14,142.63 UV1.F28 ; UV13.F4 v1(157.11,138.33)
M_DA6: length 46.2
  IN3 w0.102: v1(158.71,138.33) 159.09,138.71 159.09,139.28 159.04,139.33 159.04,143.72 159.12,143.79 159.12,147.23 158.92,147.42
  IN3 w0.142: v1(132.19,144.89) 132.41,144.89 134.59,147.08 135.66,147.08 135.8,146.93 135.8,146.28 135.94,146.13 136.22,146.13 136.37,146.28 136.37,146.93 136.51,147.08 136.79,147.08 136.94,146.93 136.94,146.28 137.08,146.13 137.36,146.13 137.5,146.28 137.5,146.93 137.65,147.08 137.92,147.08 138.06,147.22 138.06,147.47 138.2,147.61 138.48,147.61 138.63,147.47 138.63,147.22 138.77,147.08 139.05,147.08 139.2,147.22 139.2,147.47 139.34,147.61 139.62,147.61 139.76,147.47 139.76,147.22 139.91,147.08 140.19,147.08 140.33,147.22 140.33,147.47 140.48,147.61 140.76,147.61 140.9,147.47 140.9,147.22 141.04,147.08 141.33,147.08 141.47,147.22 141.47,147.47 141.61,147.61 141.9,147.61 142.04,147.47 142.04,147.22 142.18,147.08 142.81,147.08 145.28,149.55 156.79,149.55 158.92,147.42
  BOTTOM w0.127: v1(132.19,144.89) 132.18,144.89 132.18,144.9 132.14,144.85 UV1.F32 ; UV13.E4 v1(158.71,138.33)
M_DA7: length 48.9
  IN3 w0.102: 158.29,147.42 158.29,144.16 157.93,143.8 157.93,139.65 158.29,139.28 158.29,137.11 v1(157.91,136.72)
  IN3 w0.142: 158.29,147.42 158.29,147.49 156.75,149.03 145.32,149.03 143.63,147.34 143.63,145.9 143.47,145.74 143.12,145.74 142.94,145.91 142.94,146.5 142.77,146.68 142.35,146.68 142.17,146.5 142.17,145.91 142,145.74 141.65,145.74 141.47,145.91 141.47,146.5 141.3,146.68 140.95,146.68 140.77,146.5 140.77,145.91 140.6,145.74 140.25,145.74 140.07,145.91 140.07,146.5 139.9,146.68 139.54,146.68 139.37,146.5 139.37,145.91 139.19,145.74 138.84,145.74 138.67,145.91 138.67,146.5 138.49,146.68 138.14,146.68 137.97,146.5 137.97,145.91 137.79,145.74 134.66,145.74 133.19,144.26 v1(131.61,144.26)
  BOTTOM w0.127: v1(131.61,144.26) 131.61,144.2 132.14,143.67 UV1.F30 ; UV13.E2 v1(157.91,136.72)
M_DA8: length 26.8
  TOP w0.127: UV12.M11 157.51,144.33 v1(157.91,144.73)
  IN1 w0.102: v1(157.91,144.73) 157.49,144.31 153.32,144.31 153.29,144.33 152.93,144.33 152.69,144.57 152.69,144.88 152.47,145.11 151.72,145.11 150.91,145.92 150.4,145.92 150.38,145.9 148,145.9
  IN1 w0.147: 148,145.9 145.53,145.9 145.51,145.92 139.47,145.92 v1(137.45,143.91)
  BOTTOM w0.102: UV1.C30 133.85,143.4 134.23,143.78 134.99,143.78 135.12,143.91 135.31,143.91
  BOTTOM w0.14: 135.31,143.91 v1(137.45,143.91)
M_DA9: length 35.8
  TOP w0.127: v1(161.11,146.33) 160.71,145.93 UV12.T13
  IN1 w0.102: 160.69,147.35 160.69,146.75 v1(161.11,146.33)
  IN1 w0.145: 133,144.65 133,144.42 132.06,143.47 132.06,143.2 131.76,142.9 v1(131.76,142.18)
  IN1 w0.147: 133,144.65 137.76,149.41 154.15,149.41 155.22,148.34 159.71,148.34 160.69,147.35
  BOTTOM w0.127: v1(131.76,142.18) UV1.F27
M_DA10: length 28
  TOP w0.127: UV12.N11 158.31,144.33 v1(158.71,144.73)
  IN1 w0.102: v1(158.71,144.73) 158.32,144.33 158.32,143.99 157.83,143.51 157.27,143.51 157.27,143.51 152.95,143.51 152.95,143.51 152.37,143.51 152.05,143.82 152.05,144.27 151.18,145.14 150.55,145.14 150.48,145.22 148,145.22
  IN1 w0.147: 148,145.22 139.69,145.22 137.29,142.81 137.13,142.81 v1(136.37,142.05)
  BOTTOM w0.127: 135.31,142.28 134.86,142.28 UV1.A28
  BOTTOM w0.14: 135.31,142.28 135.56,142.28 135.79,142.05 v1(136.37,142.05)
M_DA11: length 31.8
  TOP w0.127: v1(161.11,143.93) 160.71,144.33 UV12.T11
  IN1 w0.102: v1(161.11,143.93) 160.95,143.76 160.69,143.76 160.47,143.54 160.47,143.48 159.36,142.36 155.58,142.36 155.01,142.93 154.7,142.93 154.16,142.39 151.74,142.39 150.59,143.54 150.59,144.03 150.28,144.34 148.95,144.34 148.78,144.52 148,144.52
  IN1 w0.147: v1(137.21,142.06) 137.64,142.06 140.1,144.52 148,144.52
  BOTTOM w0.127: UV1.C28 133.76,142.6 134.15,142.99 135.31,142.99
  BOTTOM w0.14: 135.31,142.99 136.28,142.99 v1(137.21,142.06)
M_DA12: length 33.1
  TOP w0.127: v1(158.71,146.33) 158.31,145.93 UV12.N13
  IN1 w0.145: v1(158.71,146.33) 159.11,146.72 159.11,147.31 ; 134.98,146.06 133.39,144.47 v1(133.39,142.17)
  IN1 w0.147: 134.98,146.06 135.61,146.69 137.92,149 153.99,149 154.53,148.46 154.53,148.09 154.68,147.94 158.48,147.94 159.11,147.31
  BOTTOM w0.102: v1(133.39,142.17) 133.31,142.17 UV1.E27
M_DA13: length 38.9
  TOP w0.127: v1(161.91,146.33) 161.51,145.93 UV12.U13
  IN1 w0.145: v1(131.74,141.47) 130.88,142.33 130.88,143.17
  IN1 w0.147: v1(161.91,146.33) 161.91,146.9 160.07,148.74 155.39,148.74 154.32,149.81 137.59,149.81 132.6,144.82 132.6,144.68 131.74,143.82 131.54,143.82 130.88,143.17
  BOTTOM w0.102: UV1.G26 131.74,141.4 v1(131.74,141.47)
M_DA14: length 31.8
  TOP w0.127: v1(157.91,146.33) 157.51,145.93 UV12.M13
  IN1 w0.102: v1(157.91,146.33) 157.49,146.74 154.3,146.74 154.2,146.85 154.2,147.42
  IN1 w0.145: v1(133.33,141.48) 133.61,141.77 133.62,141.77 133.86,142 133.86,142.36 133.96,142.46 133.96,142.87 134.03,142.93 134.03,143.63 134.45,144.05 134.45,144.3 134.66,144.5 134.88,144.5 135.12,144.74 135.12,145.22 135.31,145.41
  IN1 w0.147: 154.2,147.42 154.2,147.59 154.13,147.67 154.13,148.22 153.74,148.6 138.1,148.6 135.31,145.81 135.31,145.41
  BOTTOM w0.127: v1(133.33,141.48) 133.33,141.47 133.38,141.42 133.38,141.03 UV1.D26
M_DA15: length 33.4
  TOP w0.127: v1(161.91,143.93) 161.51,144.33 UV12.U11
  IN1 w0.102: v1(161.91,143.93) 161.53,143.54 160.88,143.54 159.35,142.02 151.71,142.02 150.21,143.52 148.33,143.52 148,143.85
  IN1 w0.145: v1(132.53,140.48) 134.11,140.48 135.02,141.38 135.31,141.38
  IN1 w0.147: 135.31,141.38 137.7,141.38 139.95,143.63 139.98,143.63 140.2,143.85 148,143.85
  BOTTOM w0.102: UV1.F25 132.22,140.2 132.5,140.48 v1(132.53,140.48)
M_DA16: length 21.4
  TOP w0.127: v1(152.31,138.33) 152.71,138.72 UV12.F4
  IN3 w0.142: v1(152.31,138.33) 152.31,140.11 151.66,140.76 149.12,140.76 148.49,141.4 138.47,141.4 137.77,140.7 137,140.7 136.7,140.39 136.44,140.39 v1(135.93,139.88)
  BOTTOM w0.102: 135.31,139.93 135.04,140.2 UV1.A25
  BOTTOM w0.14: 135.31,139.93 135.36,139.88 v1(135.93,139.88)
M_DA17: length 18.2
  TOP w0.127: UV12.B4 149.51,138.73 v1(149.91,139.13)
  IN3 w0.142: v1(136.7,139.95) 137.32,139.32 139.02,139.32 139.73,140.03 149.01,140.03 v1(149.91,139.13)
  BOTTOM w0.102: UV1.C25 134.11,140.2 134.55,140.64 134.85,140.64
  BOTTOM w0.127: 134.85,140.64 134.87,140.66 135.31,140.66
  BOTTOM w0.14: 135.31,140.66 135.93,140.66 136.34,140.25 136.4,140.25 v1(136.7,139.95)
M_DA18: length 23.1
  TOP w0.127: v1(151.51,138.33) 151.91,138.72 UV12.E4
  IN3 w0.142: v1(151.51,138.33) 151.93,138.74 151.93,140.1 151.54,140.49 148.44,140.49 148.22,140.71 138.75,140.71 138.05,140.01 v1(137.58,140.01)
  BOTTOM w0.102: UV1.E25 133.19,140.2 133.53,140.54 134.11,140.54 134.77,141.2
  BOTTOM w0.127: 134.77,141.2 134.97,141.39 135.31,141.39
  BOTTOM w0.14: v1(137.58,140.01) 136.2,141.39 135.31,141.39
M_DA19: length 17.4
  TOP w0.127: UV12.A4 148.71,138.73 v1(149.11,139.13)
  IN3 w0.142: v1(135.26,139.37) 135.71,139.37 136.09,138.99 136.69,138.99 136.95,138.73 139.39,138.73 140.01,139.35 147.64,139.35 147.65,139.35 147.79,139.35 148.01,139.13 v1(149.11,139.13)
  BOTTOM w0.102: v1(135.26,139.37) 135.26,139.55 135.03,139.78 134.09,139.78 133.71,139.4 UV1.D24
M_DA20: length 18.8
  TOP w0.127: v1(149.11,136.72) 149.51,137.12 UV12.B2
  IN3 w0.102: v1(133.33,138.29) 133.33,137.98 133.72,137.58 133.72,137.18 134.2,136.71 134.98,136.71
  IN3 w0.142: 134.98,136.71 136.06,135.62 148.01,135.62 v1(149.11,136.72)
  BOTTOM w0.102: v1(133.33,138.29) 133.24,138.29 UV1.E23
M_DA21: length 23.3
  TOP w0.127: v1(151.51,136.72) 151.91,137.12 UV12.E2
  IN3 w0.102: 135.03,135.88 134.24,135.88 133.68,136.44 133.59,136.44 132.95,137.09 132.95,137.43 133.01,137.49 133.01,137.73 v1(132.57,138.17)
  IN3 w0.142: 135.03,135.88 135.89,135.02 148.74,135.02 148.96,134.8 150.5,134.8 151.29,135.59 151.29,136.09 151.51,136.31 v1(151.51,136.72)
  BOTTOM w0.102: UV1.F23 v1(132.57,138.17)
M_DA22: length 17.2
  TOP w0.127: UV12.A2 v1(148.3,136.72)
  IN3 w0.142: v1(148.3,136.72) 147.71,136.13 136.46,136.13 135.61,136.97 135.61,137.55 135.31,137.85 134.54,137.85 v1(134.1,138.28)
  BOTTOM w0.127: UV1.D22 133.62,137.8 v1(134.1,138.28)
M_DA23: length 25.1
  TOP w0.127: UV12.F2 152.71,137.08 v1(152.35,136.72)
  IN3 w0.142: v1(152.35,136.72) 152.35,135.04 151.82,134.51 151.42,134.11 148.68,134.11 148.45,134.34 136.07,134.34 135.89,134.51 135.89,134.55 134.8,135.64 134.14,135.64 133.61,136.17 133.43,136.17 132.45,137.16 v1(131.66,137.16)
  BOTTOM w0.127: UV1.F21 131.98,137.16 v1(131.66,137.16)
M_DA24: length 32.3
  BOTTOM w0.102: UV1.E21 133.24,136.69 135.06,136.69 135.4,137.04
  BOTTOM w0.127: UV13.M11 153.09,144.71 153.09,147.32 ; 136.58,138.9 136.58,138.76 135.44,137.62 135.44,137.07 135.4,137.04
  BOTTOM w0.14: 153.09,147.32 152.82,147.59 152.82,147.81 152.76,147.87 152.76,147.89 150.62,150.03 145.59,150.03 v3(145.05,149.49) 140.97,145.41 140.97,142.48 137.6,139.11 136.78,139.11 136.58,138.9
M_DA25: length 28.9
  BOTTOM w0.102: 152.22,147.42 152.22,146.41 UV13.M13 ; 135.66,136.79 134.78,135.91 134.28,135.91 134.27,135.89 134.01,135.89 133.71,136.2 UV1.D20
  BOTTOM w0.127: 136.58,138.34 135.66,137.43 135.66,136.79
  BOTTOM w0.14: 136.58,138.34 137.73,138.34 141.48,142.09 141.48,144.18 146.7,149.4 v3(147.74,149.4) 150.57,149.4 152.22,147.75 152.22,147.42
M_DA26: length 28.6
  BOTTOM w0.102: 136.58,137.7 135.88,137 135.88,136.7 134.88,135.7 134.41,135.7 134.4,135.69 133.88,135.69 133.87,135.7 132.81,135.7 132.51,135.4 UV1.F19 ; UV13.N13 151.91,145.94 151.41,146.43 151.43,147.4 151.43,147.42
  BOTTOM w0.14: 151.43,147.42 151.43,147.5 150.17,148.76 146.96,148.76 v3(146.15,147.95) 141.99,143.79 141.99,141.68 138.12,137.8 136.68,137.8 136.58,137.7
M_DA27: length 26.7
  BOTTOM w0.102: UV13.N11 151.56,144.67 151.56,145.93 151.09,146.4 150.97,146.4 150.63,146.74 150.63,147.42 ; 136.58,137.11 135.94,136.47 134.88,135.42 134.56,135.42 UV1.A19
  BOTTOM w0.14: 150.63,147.42 149.92,148.13 147.22,148.13 v3(145.68,146.58) 142.92,143.82 142.92,141.55 138.54,137.17 136.64,137.17 136.58,137.11
M_DA28: length 21.8
  BOTTOM w0.102: UV1.D18 133.71,134.6 133.8,134.51 134.01,134.29 134.27,134.29 134.31,134.33 134.76,134.33 134.88,134.22 135.2,134.22 135.74,134.76 136.05,134.76
  BOTTOM w0.127: 148.08,145.52 148.34,145.77 148.56,145.77 UV13.U13
  BOTTOM w0.14: 148.08,145.52 147.89,145.52 v3(146.58,144.21) 145.48,143.11 145.48,140.75 139.5,134.76 136.05,134.76
M_DA29: length 24
  BOTTOM w0.102: 136.41,134.28 135.55,134.28 135.28,134.01 134.8,134.01 134.68,134.13 134.39,134.13 134.35,134.09 133.93,134.09 133.85,134.17 132.51,134.17 UV1.F17
  BOTTOM w0.127: UV13.T13 149.11,145.53 148.67,145.53 148.6,145.46 148.57,145.46 148.37,145.27 148.37,145.24 148,144.86
  BOTTOM w0.14: 148,144.86 146.12,142.98 v3(146.12,141.85) 146.12,140.48 139.92,134.28 136.41,134.28
M_DA30: length 20
  BOTTOM w0.102: UV1.A17 136.16,133.8
  BOTTOM w0.127: UV13.U11 148.37,144.33 148,143.95 148,143.94
  BOTTOM w0.14: 136.16,133.8 140.33,133.8 v3(145.9,139.37) 146.88,140.34 146.88,142.82 148,143.94
M_DA31: length 22.3
  BOTTOM w0.102: 136.04,133.49 136.04,133.49 134.41,133.49 134.41,133.49 134.1,133.8 UV1.C17
  BOTTOM w0.127: 136.58,133.19 136.28,133.49 136.04,133.49 ; 147.36,139.93 147.36,142.76 148.5,143.89 149.08,143.89 UV13.T11
  BOTTOM w0.14: 147.36,139.93 v3(144.96,137.52) 140.63,133.19 136.58,133.19
M_DA32: length 45.1
  IN3 w0.142: v1(132.54,133.52) 136.45,133.52 136.58,133.65 146.73,133.65 147.31,133.08 161.35,133.08 163.02,131.41 163.02,124.73 161.95,123.66 161.95,121.39 161.66,121.1 161.66,120.26 v1(161.11,119.71)
  BOTTOM w0.102: UV1.E17 132.67,133.53 132.53,133.53 132.53,133.53 132.53,133.52 v1(132.54,133.52)
  BOTTOM w0.127: UV15.U13 v1(161.11,119.71)
M_DA33: length 41.3
  IN3 w0.142: v1(161.19,121.32) 161.67,121.8 161.67,124.35 162.34,125.01 162.34,131.13 161.07,132.39 147.03,132.39 146.37,133.05 136.22,133.05 v1(135.93,132.75)
  BOTTOM w0.102: v1(135.93,132.75) 135.39,133.29 134.32,133.29 134.16,133.45 133.62,133.45 133.34,133.18 UV1.D16
  BOTTOM w0.127: v1(161.19,121.32) 161.19,121.39 UV15.U11
M_DA34: length 39.6
  IN3 w0.142: v1(133.34,131.92) 132.9,132.36 132.9,132.78 133.1,132.98 134.16,132.98 134.65,132.49 134.74,132.49 135.16,132.07 136.37,132.07 136.53,131.92 145.57,131.92 146.43,131.06 157.85,131.06 158.73,130.18 158.73,129.95 159.07,129.61 159.07,129.46 159.07,129.46 159.07,129.12 159.07,129.12 159.07,128.19 159.93,127.33 159.93,126.37 160.01,126.29 160.01,123.73 159.89,123.61 159.89,121.69 v1(160.25,121.33)
  BOTTOM w0.102: v1(133.34,131.92) 133.31,131.89 132.53,131.89 132.23,132.2 UV1.F15
  BOTTOM w0.127: UV15.T11 160.34,121.33 v1(160.25,121.33)
M_DA35: length 40.6
  IN3 w0.142: v1(160.31,119.71) 160.78,120.17 160.78,123.84 161.53,124.6 161.53,128.46 161.48,128.5 161.48,129.58 161.58,129.68 161.58,130.91 160.79,131.71 146.74,131.71 146.12,132.34 135.54,132.34 135.37,132.51 v1(135.37,132.78)
  BOTTOM w0.102: v1(135.37,132.78) 135.37,132.66 134.9,132.2 UV1.A15
  BOTTOM w0.127: UV15.T13 v1(160.31,119.71)
M_DA36: length 31.8
  IN3 w0.142: v1(136.31,129.49) 136.75,129.06 144.56,129.06 145.26,128.36 147.06,128.36 150.06,125.36 156.79,125.36 158.31,123.84 158.31,121.61 v1(158.62,121.31)
  BOTTOM w0.102: v1(136.31,129.49) 136.17,129.63 136.17,130.5 135.78,130.89 134.57,130.89 134.57,130.89 133.85,130.89 UV1.D14
  BOTTOM w0.127: UV15.N11 158.62,121.4 v1(158.62,121.31)
M_DA37: length 34.5
  IN3 w0.142: v1(157.11,119.71) 156.68,120.14 156.68,121.91 156.61,121.98 156.61,123.28 155.54,124.35 154.55,124.35 154.36,124.53 149.72,124.53 147.96,126.29 147.36,126.29 146.54,127.1 140.27,127.1 139.79,127.58 134.89,127.58 133.93,128.54 132.74,128.54 132.12,129.15 132.12,129.97 v1(131.18,130.91)
  BOTTOM w0.127: UV1.F13 131.94,130.6 131.63,130.91 v1(131.18,130.91) ; UV15.M13 v1(157.11,119.71)
M_DA38: length 30.9
  IN3 w0.142: v1(157.94,121.32) 157.94,121.73 157.89,121.79 157.89,123.88 156.68,125.09 149.95,125.09 148.02,127.01 147.82,127.01 146.89,127.94 143.28,127.94 143.11,128.11 142.44,128.11 142.27,127.94 141.98,127.94 141.82,128.11 141.82,128.41 141.65,128.57 141.31,128.57 141.14,128.41 141.14,128.11 140.98,127.94 140.62,127.94 139.93,128.64 136.21,128.64 135.64,129.21 v1(135.64,129.49)
  BOTTOM w0.102: UV1.A13 134.74,130.39 135.49,130.39 135.64,130.24 v1(135.64,129.49)
  BOTTOM w0.127: v1(157.94,121.32) 157.94,121.32 157.89,121.32 UV15.M11
M_DA39: length 32.6
  IN3 w0.142: v1(135.06,129.49) 134.88,129.31 134.88,128.76 135.06,128.58 135.66,128.58 136.02,128.22 137.33,128.22 137.55,128 138.01,128 138.22,128.22 139.75,128.22 140.44,127.52 146.71,127.52 147.65,126.59 148.05,126.59 149.83,124.81 156.56,124.81 157.53,123.85 157.53,121.08 157.49,121.04 157.49,120.12 v1(157.91,119.71)
  BOTTOM w0.102: UV1.C13 134.15,130.19 134.77,130.19 135.06,129.9 v1(135.06,129.49)
  BOTTOM w0.127: UV15.N13 v1(157.91,119.71)
M_DA40: length 32.1
  TOP w0.127: UV14.B2 161.04,129.24 v1(161.04,129.29)
  IN1 w0.145: v1(133.74,129.52) 134.28,130.07 136.41,130.07 136.58,130.24
  IN1 w0.147: 136.58,130.24 136.8,130.46 141.5,130.46 143.62,132.57 158.6,132.57 158.67,132.5 158.96,132.5 160.41,131.06 160.41,130.77 160.66,130.52 160.66,129.67 v1(161.04,129.29)
  BOTTOM w0.102: UV1.E11 133.46,129.52 133.73,129.52 v1(133.74,129.52)
M_DA41: length 38.9
  TOP w0.127: v1(161.05,126.88) 161.48,127.31 UV14.A4
  IN1 w0.145: 162.18,128 v1(161.05,126.88)
  IN1 w0.147: v1(137.58,131) 137.58,131.38 140.45,134.25 160.71,134.25 162.89,132.07 162.89,128.72 162.18,128
  BOTTOM w0.127: 136.44,129.07 136.39,129.07 136.37,129.05 134.59,129.05 UV1.A11
  BOTTOM w0.14: 136.44,129.07 136.47,129.09 136.48,129.09 136.71,129.33 136.71,129.33 137.8,130.42 137.8,130.77 v1(137.58,131)
M_DA42: length 35.1
  TOP w0.127: v1(161.92,129.32) 161.51,128.91 UV14.A2
  IN1 w0.147: v1(138.91,131) 138.91,131.55 139.11,131.76 140.96,133.6 159.8,133.6 162.44,130.96 162.44,129.84 v1(161.92,129.32)
  BOTTOM w0.102: UV1.C11 134.11,129 134.41,128.69 134.67,128.69 134.77,128.79 135.87,128.79 136.09,128.57 136.58,128.57
  BOTTOM w0.14: 136.58,128.57 136.82,128.57 138.91,130.65 v1(138.91,131)
M_DA43: length 38.8
  TOP w0.127: v1(160.35,126.91) 160.4,126.96 160.4,127 UV14.B4
  IN1 w0.145: v1(160.35,126.91) 160.35,127.67 161.46,128.78 161.46,129.58 161.83,129.95 161.83,130.16
  IN1 w0.147: v1(139.54,131) 139.54,131.26 141.42,133.14 159.51,133.14 161.83,130.82 161.83,130.16
  BOTTOM w0.102: UV1.F11 132.44,128.69 133.07,128.69 133.17,128.79 133.47,128.79 133.57,128.69 134.13,128.69 134.33,128.49 134.95,128.49 135,128.54 135.83,128.54 136.29,128.08 136.58,128.08
  BOTTOM w0.14: v1(139.54,131) 139.54,130.42 137.21,128.08 136.58,128.08
M_DA44: length 26.3
  TOP w0.127: v1(158.65,129.28) 158.65,129.25 UV14.E2
  IN1 w0.145: v1(158.65,129.28) 158.16,129.76 156.09,129.76 155.81,130.04 154.85,130.04 154.58,129.76 148,129.76
  IN1 w0.147: v1(137.13,127.15) 138.07,128.09 144.17,128.09 144.36,128.29 144.37,128.29 145.84,129.76 148,129.76
  BOTTOM w0.102: UV1.A9 134.57,127.42 136.29,127.42
  BOTTOM w0.14: v1(137.13,127.15) 136.85,127.42 136.29,127.42
M_DA45: length 26.6
  TOP w0.127: UV14.F2 157.51,128.95 v1(157.87,129.31)
  IN1 w0.145: v1(157.87,129.31) 156.19,129.31 155.71,129.79 154.98,129.79 154.65,129.46 148.91,129.46 148.57,129.11 148,129.11
  IN1 w0.147: v1(138.37,127.15) 138.86,127.63 144.64,127.63 146.11,129.11 148,129.11
  BOTTOM w0.102: 136.47,126.55 135.93,127.09 134.41,127.09 134.36,127.14 134,127.14 133.74,127.4 UV1.C9
  BOTTOM w0.127: 136.47,126.55 136.58,126.55
  BOTTOM w0.14: 136.58,126.55 137.77,126.55 v1(138.37,127.15)
M_DA46: length 29.1
  TOP w0.127: UV14.F4 v1(157.91,127.71)
  IN1 w0.145: 148,128.46 148.61,128.46 149.11,128.96 155.18,128.96 156.82,127.31 157.51,127.31 v1(157.91,127.71)
  IN1 w0.147: 148,128.46 146.1,128.46 144.62,126.98 139.78,126.98 139.62,127.14 v1(139.19,127.14)
  BOTTOM w0.102: 136.58,126.07 136.44,126.07 135.61,126.89 134.33,126.89 134.28,126.94 132.97,126.94 132.51,127.4 UV1.F9
  BOTTOM w0.14: v1(139.19,127.14) 138.89,126.84 138.89,126.73 138.23,126.07 136.58,126.07
M_DA47: length 30.4
  TOP w0.127: UV14.E4 v1(158.71,127.71)
  IN1 w0.145: v1(135.6,125.91) 136.04,126.35 136.58,126.35 ; v1(158.71,127.71) 158,127 156.78,127 155.68,128.11 148.1,128.11 148,128.01
  IN1 w0.147: 136.58,126.35 146.3,126.35 146.44,126.49 146.44,127.66 146.59,127.8 146.88,127.8 147.02,127.66 147.02,126.87 147.17,126.73 147.52,126.73 147.67,126.87 147.67,127.68 148,128.01
  BOTTOM w0.102: v1(135.6,125.91) 135.03,125.91 134.93,126.01 134.76,126.01 134.48,126.29 134.01,126.29 133.71,126.6 UV1.D8
M_DA48: length 23.4
  TOP w0.127: UV14.M11 v1(152.31,121.31)
  IN3 w0.142: v1(133.31,125.49) 135.66,125.49 135.67,125.5 136.5,125.5 136.8,125.8 139.35,125.8 139.65,125.5 145.92,125.5 146.71,124.71 148.42,124.71 149.38,123.75 151.87,123.75 152.5,123.12 152.5,121.5 v1(152.31,121.31)
  BOTTOM w0.127: UV1.E7 133.25,125.49 v1(133.31,125.49)
M_DA49: length 22
  TOP w0.127: UV14.N11 v1(151.51,121.31)
  IN3 w0.142: v1(136.05,124.51) 136.26,124.51 136.52,124.77 136.56,124.77 137.17,125.38 138.97,125.38 139.28,125.08 145.75,125.08 146.53,124.29 148.16,124.29 148.99,123.47 151.75,123.47 151.93,123.29 151.93,121.72 v1(151.51,121.31)
  BOTTOM w0.127: UV1.A7 134.54,125.65 134.77,125.43 135.23,125.43 136.05,124.61 136.05,124.52 v1(136.05,124.51)
M_DA50: length 17.9
  TOP w0.127: UV14.T11 v1(149.11,122.11)
  IN3 w0.142: v1(135.5,124.61) 135.5,124.27 135.67,124.1 136.2,124.1 136.21,124.1 136.22,124.1 136.47,124.35 145.88,124.35 146.36,123.88 147.45,123.88 149.11,122.22 v1(149.11,122.11)
  BOTTOM w0.127: UV1.C7 134.07,125.8 135.26,124.61 v1(135.5,124.61)
M_DA51: length 27.4
  TOP w0.127: UV14.M13 v1(152.31,119.71)
  IN3 w0.142: v1(152.31,119.71) 151.81,119.2 151.81,118.73 151.04,117.96 146.6,117.96 144.29,120.27 134.33,120.27 132.63,121.97 132.63,122.56 132.92,122.85 132.92,123.12 133.15,123.35 133.15,124.88 v1(132.6,125.43)
  BOTTOM w0.127: v1(132.6,125.43) 132.23,125.8 UV1.F7
M_DA52: length 16
  TOP w0.127: UV14.U11 148.45,121.45 v1(148.28,121.45)
  IN3 w0.142: v1(148.28,121.45) 148.28,122.14 146.96,123.46 146.19,123.46 145.71,123.93 136.43,123.93 136.33,123.83 136.32,123.83 136.31,123.82 135.56,123.82 135.44,123.95 134.97,123.95 v1(134.87,123.84)
  BOTTOM w0.102: UV1.A5 134.87,123.87 v1(134.87,123.84)
M_DA53: length 24
  TOP w0.127: UV14.N13 v1(151.51,119.71)
  IN3 w0.142: v1(133.34,122.95) 133.34,122.87 132.91,122.44 132.91,122.09 134.02,120.98 135.78,120.98 136.09,120.67 144.49,120.67 146.75,118.41 150.8,118.41 151.13,118.73 151.13,119.32 v1(151.51,119.71)
  BOTTOM w0.102: UV1.E5 133.34,123.8 v1(133.34,122.95)
M_DA54: length 17.2
  TOP w0.127: UV14.U13 v1(148.24,119.64)
  IN3 w0.142: v1(148.24,119.64) 148.04,119.44 146.9,119.44 144.81,121.53 135.1,121.53 134.6,122.04 134.6,122.54 v1(134.15,122.99)
  BOTTOM w0.102: UV1.C3 v1(134.15,122.99)
M_DA55: length 18.7
  TOP w0.127: UV14.T13 v1(149.11,119.71)
  IN3 w0.142: v1(133.32,122.26) 134.33,121.26 136.34,121.26 136.53,121.06 144.69,121.06 146.88,118.87 148.37,118.87 149.11,119.61 v1(149.11,119.71)
  BOTTOM w0.102: v1(133.32,122.26) 133.27,122.26 UV1.E1
M_DA56: length 39.4
  BOTTOM w0.089: 136.49,121.54 136.27,121.33 132.15,121.33 131.95,121.53
  BOTTOM w0.102: UV1.G7 131.74,125.4 131.74,124.84 131.85,124.73 131.85,123.94 131.64,123.73 131.64,123.11 131.71,123.04 131.71,122.94 131.85,122.81 131.85,122.39 131.72,122.26 131.72,121.75 131.95,121.53
  BOTTOM w0.127: UV15.F4 152.71,127.31 153.12,127.71 153.12,129.06 153.39,129.34 153.65,129.34 153.91,129.6 153.91,130.4
  BOTTOM w0.14: 153.91,130.4 153.91,130.99 153.78,131.12 153.78,131.51 151.23,134.05 v3(146.48,134.05) 139.64,127.21 139.64,126.85 139.27,126.48 139.27,124.33 136.49,121.54
M_DA57: length 35.1
  BOTTOM w0.089: 131.71,120.79 132,120.5 137.14,120.5 137.19,120.56
  BOTTOM w0.102: 131.06,121.91 131.04,121.94 131.04,122.73 131.04,122.74 131.04,122.78 131.05,122.79 131.05,123.21 131.04,123.22 131.04,123.27 131,123.31 131,123.61 131.19,123.8 131.42,123.8 131.64,124.02 131.64,124.41 131.34,124.71 UV1.G6
  BOTTOM w0.127: 151.51,130.13 151.51,127.71 151.67,127.55 151.67,127.55 UV15.E4 ; 131.71,120.79 131.06,121.44 131.06,121.91
  BOTTOM w0.14: 151.51,130.13 151.51,130.46 151.52,130.47 151.52,131.1 150.43,132.19 147.42,132.19 v3(144.85,129.62) 140.7,125.47 140.7,124.06 137.19,120.56
M_DA58: length 31.5
  BOTTOM w0.089: 136.94,120.99 136.77,120.82 132.01,120.82 131.81,121.02
  BOTTOM w0.127: UV15.E2 152.3,129.3 152.3,130.4 ; UV1.G1 131.29,122.55 131.29,121.54 131.81,121.02
  BOTTOM w0.14: 136.94,120.99 140.16,124.21 140.16,125.74 v3(145.53,131.1) 147.31,132.88 150.73,132.88 152.3,131.31 152.3,130.4
M_DA59: length 33.7
  BOTTOM w0.089: 136.58,121.21 136.44,121.07 132.08,121.07 131.84,121.31
  BOTTOM w0.102: 131.52,121.63 131.52,121.65 131.5,121.66 131.5,121.84 131.52,121.86 131.52,122.34 131.64,122.47 131.64,122.72 131.51,122.86 131.51,122.95 131.34,123.12 UV1.G3
  BOTTOM w0.127: UV15.F2 152.71,129.23 153.12,129.64 153.12,130.4 ; 131.52,121.63 131.84,121.31
  BOTTOM w0.14: 136.58,121.21 139.72,124.35 139.72,126.3 140.08,126.67 140.08,126.75 v3(145.87,132.54) 146.85,133.52 150.99,133.52 153.12,131.39 153.12,130.4
M_DA60: length 28.5
  BOTTOM w0.089: 130.82,118.91 138.58,118.91 139,119.33 ; 129.92,120.03 129.92,120.31 129.58,120.65
  BOTTOM w0.102: UV1.J6 129.84,124.9 129.84,124.55 130.04,124.34 130.04,124.07 130.04,124.07 130.04,124.05 129.81,123.82 129.73,123.82 129.42,123.51 129.42,123.28 129.52,123.18 129.52,122.81 129.43,122.72 129.43,120.8 129.58,120.65
  BOTTOM w0.127: UV15.A4 148.23,127.31
  BOTTOM w0.14: 139,119.33 141.18,121.51 142.43,121.51 v3(144.14,123.22) 148.23,127.31 ; 130.82,118.91 129.92,119.81 129.92,120.03
M_DA61: length 26.3
  BOTTOM w0.089: 139,119.96 138.33,119.29 131.24,119.29 129.63,120.91
  BOTTOM w0.102: 129.63,120.91 129.63,122.49 UV1.J1
  BOTTOM w0.127: UV15.B2 149.05,128.45 148.57,128.45 148.39,128.27
  BOTTOM w0.14: 148.39,128.27 v3(145.01,124.89) 142.07,121.95 140.99,121.95 139,119.96
M_DA62: length 25.8
  BOTTOM w0.089: 139,120.59 138.02,119.61 131.45,119.61 130.94,120.12 130.94,120.15 130.53,120.55
  BOTTOM w0.102: 130.53,120.55 129.83,121.25 129.83,122.26 130.04,122.47 130.04,122.77 129.81,123 129.81,123.33 UV1.J3
  BOTTOM w0.127: 148,128.86 148.04,128.91 UV15.A2
  BOTTOM w0.14: 139,120.59 140.81,122.4 141.53,122.4 v3(145.5,126.37) 148,128.86
M_DA63: length 29.2
  BOTTOM w0.089: 139,118.7 138.76,118.47 130.59,118.47 ; 129.41,120.18 129.41,120.03
  BOTTOM w0.102: 129.22,120.37 129.22,122.4 129.21,122.42 129.21,122.78 129.27,122.85 129.27,123.14 129.2,123.21 129.2,123.6 129.74,124.14 UV1.J5 ; 147.93,126.37 147.36,125.8
  BOTTOM w0.127: UV15.B4 149.51,127.31 149.11,126.91 148.47,126.91 147.93,126.37
  BOTTOM w0.14: 147.36,125.8 v3(146.53,124.96) 142.63,121.06 141.36,121.06 139,118.7 ; 129.22,120.37 129.41,120.18 ; 130.59,118.47 129.41,119.64 129.41,120.03
M_DBI0#: length 47.4
  IN3 w0.102: v1(159.51,136.72) 159.89,137.11 159.89,139.28 159.68,139.5 159.68,142.71 159.94,142.97 159.94,143.28 159.89,143.33 159.89,147.37 159.84,147.42
  IN3 w0.142: 159.84,147.42 157.06,150.2 143.29,150.2 141.35,148.26 134.86,148.26 132.07,145.47 131.56,145.47 131.05,144.96 131.05,142.96 130.57,142.49 130.56,142.49 v1(130.26,142.19)
  BOTTOM w0.127: UV13.D2 v1(159.51,136.72) ; v1(130.26,142.19) 130.28,142.19 130.28,142.06 UV1.H27
M_DBI1#: length 28.7
  TOP w0.127: UV12.P13 159.11,145.93 v1(159.51,145.53)
  IN1 w0.102: v1(159.51,145.53) 159.13,145.14 153.61,145.14 152.18,146.57 148,146.57
  IN1 w0.145: v1(135.2,141.85) 135.2,142.25 135.23,142.28 135.23,142.65 135.31,142.73
  IN1 w0.147: 148,146.57 139.2,146.57 139.18,146.55 139.13,146.55 135.31,142.73
  BOTTOM w0.127: v1(135.2,141.85) 135.15,141.8 UV1.A27
M_DBI2#: length 19.5
  TOP w0.127: UV12.D2 151.11,137.12 v1(150.71,136.72)
  IN3 w0.102: 149.7,137.91 150.07,137.91 150.29,137.68 150.29,137.14 v1(150.71,136.72)
  IN3 w0.142: v1(134.12,138.89) 134.89,138.89 134.96,138.82 135.85,138.82 136.71,137.96 139.59,137.96 140.29,138.66 148.18,138.66 148.94,137.91 149.7,137.91
  BOTTOM w0.127: v1(134.12,138.89) 133.83,138.6 UV1.C23
M_DBI3#: length 25
  BOTTOM w0.102: UV13.P13 150.69,146.34 150.14,146.34 149.84,146.65 149.84,147.01 ; 136.1,136.32 136.08,136.32 134.97,135.21 134.83,135.21 134.7,135.08 134.41,135.08 134.33,135.16 133.98,135.16 UV1.C19
  BOTTOM w0.127: 136.1,136.32 136.15,136.32 ; 149.68,147.42 149.77,147.33 149.77,147.08 149.84,147.01
  BOTTOM w0.14: 149.68,147.42 149.6,147.49 149.31,147.49 149.3,147.5 148.97,147.5 148.97,147.5 148.17,147.5 148.17,147.49 147.49,147.49 v3(145.18,145.18) 143.55,143.55 143.55,141.31 138.66,136.41 136.23,136.41 136.15,136.32
M_DBI4#: length 35.7
  IN3 w0.142: v1(158.71,119.71) 158.71,120.71 159.15,121.15 159.15,125.46 157.93,126.69 157.12,126.69 154.84,128.96 148.18,128.96 148.11,129.04 145.54,129.04 144.84,129.73 137.06,129.73 136.88,129.91 136.86,129.91 136.71,130.06 136.11,130.06 136.08,130.1 134.35,130.1 134.02,130.42 134.02,131.8 v1(134.12,131.9)
  BOTTOM w0.127: UV15.P13 v1(158.71,119.71) ; v1(134.12,131.9) 133.82,132.2 UV1.C15
M_DBI5#: length 29.6
  TOP w0.127: v1(159.49,129.29) 159.49,129.29 UV14.D2
  IN1 w0.145: 158.64,130.4 158.73,130.31 158.73,130.05 v1(159.49,129.29) ; v1(133.33,127.68) 133.73,127.28 135.89,127.28
  IN1 w0.147: 158.64,130.4 158.25,130.79 145.94,130.79 144.1,128.94 144.09,128.94 143.89,128.74 137.73,128.74 136.27,127.28 135.89,127.28
  BOTTOM w0.102: UV1.E9 133.23,127.68 v1(133.33,127.68)
M_DBI6#: length 20.8
  TOP w0.127: UV14.P13 v1(150.71,120.51)
  IN3 w0.142: v1(135.87,122.48) 136.65,123.26 145.43,123.26 145.91,122.78 146.36,122.78 148.13,121.01 148.4,121.01 148.52,120.89 150.33,120.89 v1(150.71,120.51)
  BOTTOM w0.102: UV1.C5 133.82,124.2 134.33,124.71 134.86,124.71 135.87,123.7 v1(135.87,122.48)
M_DBI7#: length 30.5
  BOTTOM w0.089: 131.62,120.56 132,120.18 137.28,120.18 137.32,120.23
  BOTTOM w0.102: 130.83,121.87 130.83,122.82 130.84,122.82 130.84,122.86 130.84,122.87 130.84,123.12 130.84,123.13 130.84,123.18 130.54,123.48 UV1.H4
  BOTTOM w0.127: UV15.D2 150.69,129.32 ; 130.83,121.87 130.83,121.54 130.83,121.35 131.62,120.56
  BOTTOM w0.14: 150.69,129.32 150.65,129.37 150.65,129.85 150.61,129.89 150.61,130.29 150.6,130.3 150.6,130.44 150.6,130.44 150.6,131 150.09,131.51 147.83,131.51 v3(144.53,128.2) 143.78,127.45 143.78,127.44 141.39,125.05 141.39,124.29 137.32,120.23
M_EDC_0: length 52.4
  IN3 w0.102: 160.7,147.42 160.7,137.15 160.58,137.03 160.58,136.99 v1(160.31,136.72)
  IN3 w0.142: 160.7,147.42 160.7,147.69 157.83,150.55 157.83,150.75 157.25,151.33 141.27,151.33 140.71,150.76 140.71,149.21 140.53,149.04 140.18,149.04 140,149.21 140,149.74 139.83,149.91 139.48,149.91 139.3,149.74 139.3,149.21 139.13,149.04 138.78,149.04 138.6,149.21 138.6,149.76 138.43,149.94 138.06,149.94 137.87,149.75 137.87,149.21 137.7,149.04 134.53,149.04 130.53,145.03 130.53,143.27 v1(130.24,142.97)
  BOTTOM w0.127: UV1.H28 130.54,142.67 v1(130.24,142.97) ; UV13.C2 v1(160.31,136.72)
M_EDC_1: length 31.4
  TOP w0.102: UV12.R13 159.91,145.93 v1(159.51,146.33)
  IN1 w0.102: v1(159.51,146.33) 159.13,145.95 153.75,145.95 153.09,146.61 153.09,147.42
  IN1 w0.145: v1(134.26,142.19) 134.52,142.45 134.52,143.05 134.69,143.21 134.69,143.57 135.06,143.94
  IN1 w0.147: 153.09,147.42 152.69,147.82 138.83,147.82 137.37,146.37 137.37,146.37 137.12,146.11 137.12,145.9 137.14,145.88 137.14,145.67 136.89,145.41 136.68,145.41 136.65,145.44 136.44,145.44 136.19,145.18 136.19,144.98 136.22,144.95 136.22,144.74 135.41,143.94 135.06,143.94
  BOTTOM w0.127: v1(134.26,142.19) 134.24,142.17 134.11,142.17 UV1.C27
M_EDC_2: length 17.6
  TOP w0.127: v1(149.91,136.72) 150.31,137.12 UV12.C2
  IN3 w0.142: v1(149.91,136.72) 149.14,137.49 140.38,137.49 139.96,137.07 136.34,137.07 136.12,137.29 136.12,137.85 v1(135.61,138.36)
  BOTTOM w0.102: UV1.A23 134.74,138.8 135.17,138.8 v1(135.61,138.36)
M_EDC_3: length 24.5
  BOTTOM w0.102: UV1.E19 132.94,135.02 133.04,134.91 134.29,134.91 134.34,134.86 134.76,134.86 134.88,134.98 135.45,134.98
  BOTTOM w0.127: UV13.R13 150.05,145.93 149.71,146.26 148.43,146.26 ; 135.45,134.98 136.06,135.59
  BOTTOM w0.14: 136.06,135.59 138.93,135.59 139.29,135.95 139.59,135.95 139.9,136.26 139.9,136.56 140.21,136.87 140.5,136.87 140.81,137.17 140.81,137.47 144.62,141.28 144.62,143.41 v3(144.83,143.62) 147.69,146.49 148.2,146.49 148.43,146.26
M_EDC_4: length 38.9
  IN3 w0.142: v1(159.51,119.71) 159.84,120.03 159.84,120.77 159.55,121.05 159.55,125.45 158.04,126.96 157.24,126.96 154.87,129.33 150.51,129.33 150.18,129.66 149.81,129.66 149.48,129.33 148.5,129.33 147.58,130.26 146.1,130.26 145.85,130.51 145.02,130.51 144.83,130.69 144.83,130.85 144.67,131.02 144.33,131.02 144.16,130.85 144.16,130.69 144,130.53 143.51,130.53 143.35,130.69 143.35,130.85 143.18,131.02 142.84,131.02 142.68,130.85 142.68,130.69 142.51,130.53 142.17,130.53 142,130.69 142,130.85 141.84,131.02 141.49,131.02 141.33,130.85 141.33,130.69 141.16,130.53 140.82,130.53 140.66,130.69 140.66,130.85 140.49,131.02 140.15,131.02 139.98,130.85 139.98,130.69 139.82,130.53 137.41,130.53 137.03,130.91 136.79,130.91 136.58,131.12 135.96,131.73 134.88,131.73 134.09,132.52 v1(133.36,132.52)
  BOTTOM w0.102: v1(133.36,132.52) 133.26,132.52 UV1.E15
  BOTTOM w0.127: UV15.R13 v1(159.51,119.71)
M_EDC_5: length 32.1
  TOP w0.127: UV14.C2 v1(160.32,129.32)
  IN1 w0.145: v1(160.32,129.32) 159.55,130.1 159.55,130.4 ; v1(134.13,127.69) 135,128.56 136.39,128.56 136.58,128.74
  IN1 w0.147: 159.55,130.4 159.55,130.7 158.61,131.64 145.58,131.64 144.89,130.95 144.69,130.95 144.3,131.34 144.09,131.34 143.89,131.14 143.89,130.93 144.28,130.54 144.28,130.34 143.74,129.8 143.74,129.8 143.54,129.6 137.43,129.6 136.58,128.74
  BOTTOM w0.102: v1(134.13,127.69) 134.05,127.69 133.54,128.2 UV1.D10
M_EDC_6: length 22.8
  TOP w0.127: UV14.R13 v1(150.69,119.73)
  IN3 w0.142: v1(135.22,122.48) 135.22,122.19 135.54,121.87 136.07,121.87 136.59,122.39 145.1,122.39 147.25,120.24 147.69,120.24 147.81,120.12 150.29,120.12 v1(150.69,119.73)
  BOTTOM w0.102: v1(135.22,122.48) 135.27,122.53 135.27,124 134.77,124.5 134.41,124.5 134.24,124.32 134.24,124.26 133.87,123.89 133.61,123.89 133.44,124.07 133.44,124.12 133.2,124.36 133.2,124.86 UV1.D6
M_EDC_7: length 30.7
  BOTTOM w0.089: 137.65,120.05 137.6,119.99 131.76,119.99 130.05,121.71
  BOTTOM w0.102: 130.05,121.71 130.05,122.19 130.25,122.39 130.25,122.86 130.1,123 130.1,123.79 130.41,124.1 131.24,124.1 UV1.G5
  BOTTOM w0.127: UV15.C2 149.96,129.25 149.96,129.78 149.77,129.97 149.77,130.4
  BOTTOM w0.14: 137.65,120.05 140.78,123.17 141.21,123.17 143.56,125.52 143.56,126.07 v3(146.3,128.81) 148.18,130.69 149.52,130.69 149.77,130.43 149.77,130.4
M_RAS#0: length 32.9
  TOP w0.102: 148.19,138.29 148.38,138.48 148.38,139.73 148.95,140.31 151.67,140.31 152.25,139.72 152.25,139.52 152.57,139.2 152.69,139.2 153.03,138.86 153.03,138.33 v1(153.02,138.32)
  TOP w0.127: 148,138.1 148.19,138.29 ; v1(130.93,137.96) 130.65,137.68 130.27,137.68 129.63,137.04 129.63,135.65 130.21,135.08 132.21,135.08 132.38,135.25 133.06,135.25 133.33,134.99 135.69,134.99 135.96,135.18 136.49,135.18 ; UV12.G3 153.42,137.93 v1(153.02,138.32)
  TOP w0.14: 148,138.1 147.76,137.87 146.6,137.87 v3(144.62,135.89) 143.92,135.18 136.49,135.18
  BOTTOM w0.127: v1(130.93,137.96) 130.98,137.96 UV1.G22 ; v1(153.02,138.32) 153.42,137.93 UV12.G3
M_RAS#1: length 32.4
  TOP w0.127: 154.73,129.95 154.73,128.81 155.03,128.51 156.3,128.51 v1(156.33,128.49) UV14.G3 ; v1(131.74,133.53) 131.83,133.53 132.29,133.99 132.73,133.99 133.06,133.66 136.28,133.66 136.58,133.36
  TOP w0.14: 136.58,133.36 136.77,133.17 137.04,133.17 137.25,133.38 137.6,133.38 137.81,133.17 138.08,133.17 138.29,133.38 138.64,133.38 138.85,133.17 v3(152.56,133.17) 153.31,133.17 153.95,132.53 153.95,132.33 153.48,131.86 153.48,131.66 153.68,131.46 153.87,131.46 154.35,131.93 154.54,131.93 154.73,131.74 154.73,130.4 154.74,130.39 154.74,130.06 154.73,130.06 154.73,129.95
  BOTTOM w0.102: v1(131.74,133.53) 131.68,133.53 131.34,133.87 UV1.G17
  BOTTOM w0.127: v1(156.33,128.49) UV14.G3
M_WCKA0_0: length 39.2
  TOP w0.112: UV12.P4 159.11,138.73 v1(159.51,139.13)
  IN1 w0.13: v1(140.46,143.2) 140.46,142.96 140.78,142.64 140.78,140.92 140.91,140.79 141.46,140.79 141.59,140.92 141.59,142.3 141.85,142.56 142.42,142.56 142.68,142.3 142.68,140.92 142.81,140.79 143.19,140.79 143.32,140.92 143.32,142.3 143.58,142.56 144.15,142.56 144.41,142.3 144.41,140.92 144.54,140.79 158.89,140.79 159.3,140.39 159.3,139.34 v1(159.51,139.13)
  BOTTOM w0.112: UV12.P4 159.11,138.73 v1(159.51,139.13) ; UV1.E32 133.06,144.32 133.06,144.79 133.94,145.67 135.29,145.67 135.3,145.66 135.31,145.66
  BOTTOM w0.122: 135.31,145.66 137.72,145.66 140.17,143.21 140.22,143.21 140.23,143.2 v1(140.46,143.2)
M_WCKA0_0#: length 39.6
  TOP w0.112: v1(158.71,139.13) 159.11,139.52 UV12.P5
  IN1 w0.13: v1(158.71,139.13) 158.86,139.13 159.08,139.34 159.08,140.3 158.8,140.57 144.45,140.57 144.19,140.83 144.19,142.21 144.06,142.34 143.67,142.34 143.54,142.21 143.54,140.83 143.28,140.57 142.71,140.57 142.46,140.83 142.46,142.21 142.33,142.34 141.94,142.34 141.81,142.21 141.81,140.83 141.55,140.57 140.82,140.57 140.56,140.83 140.56,142.55 140.32,142.79 v1(140.05,142.79)
  BOTTOM w0.112: 135.31,145.44 135.21,145.44 135.19,145.46 134.03,145.46 133.27,144.7 133.27,144.22 133.26,144.22 133.26,143.72 UV1.E30 ; UV12.P5 159.11,139.52 v1(158.71,139.13)
  BOTTOM w0.122: 135.31,145.44 137.63,145.44 140.05,143.02 140.05,142.79 v1(140.05,142.79)
M_WCKA0_1: length 20
  TOP w0.112: UV12.D4 151.11,138.73 v1(151.51,139.13)
  IN1 w0.13: v1(135.04,137.21) 134.76,137.5 134.76,137.61 134.89,137.74 135.54,137.74 135.86,137.42 149.15,137.42 149.86,138.14 150.69,138.14 151.23,138.68 151.23,138.85 v1(151.51,139.13)
  BOTTOM w0.102: UV1.A21 134.56,137.04 134.77,137.13 134.81,137.11 v1(135.04,137.21)
  BOTTOM w0.112: UV12.D4 151.11,138.73 v1(151.51,139.13)
